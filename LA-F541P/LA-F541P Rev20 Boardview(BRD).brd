# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
NVVDD_PGOOD: length 4.1
  BOTTOM w0.203: PU1001.13 170.18,115.66 170.29,115.55 170.74,115.55 170.89,115.39 v1(170.93,115.39) 171.08,115.39 171.43,115.05 171.43,114.3 171.72,114.01 PR1019.1 PR1017.1
NVVDD_PWM_VID: length 1
  BOTTOM w0.14: PR1003.1 163.72,118.48 RV1095.2
NVVDD_VID: length 2.4
  BOTTOM w0.254: PR1003.2 165.52,117.87 165.89,117.5 165.89,116.76 166.19,116.46 PU1001.5
NVVDDS_EN: length 180.8
  TOP w0.203: v2(204.88,57.05) 206.07,55.86 206.07,53.48 206.73,52.82 206.73,52.25 206.58,52.1 U33.17
  TOP w0.254: QZ14.2 223.26,118.81 223.83,118.81 v2(223.87,118.78) ; v2(176.04,113) 175.84,113.2 RV1807.1
  IN1 w0.254: v2(176.04,113) 176.04,110.77 176.41,110.41 183.94,110.41 185.17,111.63 185.68,111.63 187.58,113.54 188.58,113.54 v2(188.97,113.93)
  IN3 w0.254: v2(223.87,118.78) 223.87,119.03 222.05,120.85 215.72,120.85 215.27,120.4 204.6,120.4 201.42,117.22 197.61,117.22 195.45,115.06 195.45,113.16 194.95,112.65 189.36,112.65 188.97,113.04 v2(188.97,113.93) ; v2(204.88,57.05) 204.52,57.41 203.92,57.41 203.31,56.79 201.13,56.79 200.71,56.38 199.03,56.38 195.92,59.48 195.92,61.46 195.07,62.31 193.88,62.31 186.84,69.34 186.45,69.34 183.33,72.46 183.33,76.62 185.42,78.71 185.42,82.96 183.66,84.71 182.14,84.71 181.25,85.61 181.25,87.22 181.64,87.61 181.64,89.96 180.98,90.62 180.98,93.71 179.98,94.71 177.52,94.71 176.89,94.08 175.59,94.08 174.46,95.21 173.88,95.21 173.31,95.78 173.31,105.94 171.94,107.31 171.94,109.62 175.33,113 v2(176.04,113)
  IN5 w0.254: v2(246.79,113.7) 246.46,113.7 244.58,111.81 239.42,111.81 238.32,112.92 237.5,112.92 237.27,112.69 230.16,112.69 229.64,113.21 229.64,116.94 229.51,117.07 227.5,119.09 224.18,119.09 v2(223.87,118.78)
  BOTTOM w0.203: v2(188.97,113.93) 188.9,114 PU1501.3
  BOTTOM w0.254: PR902.1 246.71,113.62 v2(246.79,113.7)
NVVDDS_PGOOD: length 3.8
  BOTTOM w0.203: PU1501.13 188.9,118.42 189.04,118.57 189.38,118.57 189.92,119.1 PR1522.1 189.61,119.43 189.61,120.6 PR1518.1
NVVDDS_PSI: length 3.2
  BOTTOM w0.203: PU1501.4 188.5,114.12 188.46,114.09 188.46,113.77 188.82,113.41 PR1502.1 PR1501.1 PR1500.2
NVVDDS_PWM_VID: length 1.7
  BOTTOM w0.254: RV1098.2 PR1503.1 185.57,113.34 186.03,113.8 RV1835.1
NVVDDS_VID: length 2.6
  BOTTOM w0.203: PU1501.5 188.1,114.36 187.96,114.22 187.29,114.22 v2(187.2,114.13) 186.48,113.42 PR1503.2
OTGEN/CMIN: length 3.4
  TOP w0.203: PR1909.2 53.87,15.77 PR1912.2 52.91,15.55 v1(52.21,15.55) 52.1,15.55 51.47,14.91 PU1900.20
P_SYS: length 451.9
  TOP w0.14: v2(51.53,34.24) 51.53,32.93 49.56,30.96 49.56,27.53 50.8,26.29 50.8,25.27 48.97,23.45 46.91,23.45 46.66,23.19 46.66,22.53 46.38,22.25 v2(46.28,22.25) 45.51,23.02 44.3,23.02 43.56,22.28 PR1929.2 ; RE126.2 310.81,11.11 311.12,10.8 311.29,10.8 311.54,10.55 v1(311.54,9.59) v2(311.17,9.22)
  TOP w0.203: PC1100.2 112.03,110.5 v2(112.71,110.5) 113.55,109.67 113.55,108.84 113.81,108.59 PU1100.1
  IN2 w0.099: v2(51.53,34.24) 51.53,34.89 53.45,36.8 85.82,36.8 87.54,38.52 88.55,38.52 90.13,40.11 90.91,40.11 95.87,45.07 100.64,45.07 101.35,45.79 v2(101.35,46.32)
  IN3 w0.091: v2(101.35,46.32) 101.35,47.53 103.3,49.48 103.3,96.09 104.78,97.56 104.78,109.04 106.24,110.5 v2(112.71,110.5)
  IN6 w0.089: 73.72,11.38 73.83,11.49 73.83,12.27 73.28,12.82
  IN6 w0.099: v2(311.17,9.22) 311.17,8.55 310.06,7.44 308.85,7.44 308.09,8.2 307.71,8.2 306.17,9.74 305.21,9.74 303.44,7.97 298.8,7.97 297.64,6.81 292.32,6.81 291.14,5.64 287.72,5.64 287.04,6.32 285.09,6.32 284.86,6.1 284.86,5.52 284.47,5.13 282.19,5.13 281.14,6.18 279.7,6.18 278.39,7.49 271.65,7.49 271.07,8.07 234.77,8.07 234.3,7.6 218.06,7.6 214.53,11.13 212.28,11.13 211.86,10.71 178.39,10.71 177.67,10 177.11,10 175.17,8.06 169.95,8.06 169.63,8.38 163.89,8.38 163.25,7.74 159.22,7.74 158.75,7.27 152.01,7.27 151.68,7.59 147.73,7.59 145.49,9.83 142.29,9.83 141.39,10.74 129.91,10.74 129.26,11.38 124.93,11.38 124.32,10.77 123.04,10.77 122.41,10.14 119.53,10.14 118.48,9.09 117.5,9.09 114.69,6.28 113.99,6.28 113.53,5.82 113.53,5.26 113.22,4.95 107.16,4.95 105.32,6.79 103.48,6.79 103.26,7.01 101.2,7.01 101.11,7.1 100.29,7.1 100.03,6.85 99.39,6.85 99.15,6.61 99.14,6.61 99,6.46 95.07,6.46 94.23,7.31 92.98,7.31 92.67,7.62 92.23,7.62 91.09,6.48 90.34,6.48 89.35,5.49 87.53,5.49 86.62,6.4 86.62,8.19 86.8,8.37 86.8,9.76 86.14,10.42 85.6,10.42 85.1,9.92 81.58,9.92 81.12,9.47 80.48,9.47 80.1,9.09 79.83,9.09 79.59,9.32 79.11,9.32 78.94,9.15 78.18,9.15 77.77,8.75 77.13,8.75 76.4,9.47 74.27,9.47 73.72,10.02 73.72,11.38 ; v2(46.28,22.25) 46.94,21.59 48.74,21.59 49.08,21.93 51.73,21.93 51.99,21.67 51.99,21.09 52.13,20.96 56.76,20.96 57.75,19.97 60.37,19.97 61.73,18.61 62.74,18.61 62.87,18.73 69.56,18.73 70.53,17.76 70.53,15.33 72.98,12.89 73.21,12.89 73.28,12.82
  BOTTOM w0.254: v2(112.71,110.5) 112.7,110.49 PR1100.2
PANEL_BKEN_EC: length 283.4
  TOP w0.14: v2(144.73,12.42) 144.73,12.4 v1(143.92,11.58) ; v2(300.96,17.37) UE3.J9
  IN1 w0.076: 101.98,15.18 101.32,15.84 99.3,15.84 99.23,15.91 98.28,15.91 97.8,16.39 95.5,16.39 94.46,17.43 94.05,17.43 v2(93.76,17.14)
  IN1 w0.099: 101.98,15.18 101.99,15.17 109.59,15.17 111.97,17.55 128.55,17.55 130.87,15.24 138.1,15.24 140.1,13.24 143.91,13.24 v2(144.73,12.42)
  IN2 w0.089: v2(93.76,17.14) 92.86,18.05 84.3,18.05 83,16.75 79.6,16.75 78.49,17.86 77.59,17.86 76.65,18.8 76.65,20.26 75.57,21.34 75.57,22.34 75.06,22.85
  IN2 w0.099: v2(49.14,30.79) 50.85,29.08 61.88,29.08 63.85,27.1 63.85,26.47 64.85,25.47 69.56,25.47 70.13,26.03 73.36,26.03 74.66,24.73 74.66,23.25 75.06,22.85
  IN5 w0.099: v2(300.96,17.37) 300.54,17.79 299.99,17.79 299.98,17.8 299.17,17.8 298.64,18.33 298.64,18.66 297.83,19.47 293.16,19.47 291.09,17.4 290.32,17.4 290.04,17.68 288.49,17.68 286.92,16.11 286.06,16.11 285.5,16.67 278.53,16.67 276.32,14.45 272.9,14.45 271.29,12.84 268.49,12.84 267.73,13.61 266.37,13.61 265.8,13.03 262.58,13.03 262.28,13.34 257.53,13.34 256.95,12.76 249.3,12.76 246.56,15.5 231.4,15.5 230.64,14.74 227.28,14.74 226.81,15.21 215.44,15.21 214.53,16.12 202.63,16.12 202.26,16.49 180.95,16.49 177.6,13.15 164.13,13.15 163.72,13.56 145.87,13.56 v2(144.73,12.42)
  BOTTOM w0.14: v2(49.14,30.79) 49.14,30.45 48.41,29.72 48.41,28.13 48.66,27.88 48.66,26.76 48.29,26.39 48.29,25.71 DV1.2
PANEL_BKEN_PCH: length 43.2
  TOP w0.14: v2(64.14,19.69) 64.14,19.44 63.86,19.15 63.86,18.84 v1(63.82,18.8)
  IN2 w0.099: v2(47.94,24.44) 48.85,24.44 49.24,24.83 52.49,24.83 53.52,23.79 61.37,23.79 61.58,23.59 61.58,22.67 62.09,22.16 63.25,22.16 64.14,21.27 v2(64.14,19.69)
  IN6 w0.089: v2(74.17,10.72) 74.09,10.8 74.09,12.33 73.32,13.09 73.28,13.09
  IN6 w0.099: 73.28,13.09 73.11,13.09 70.76,15.45 70.76,17.97 68.97,19.76 66.41,19.76 65.8,19.15 64.26,19.15 64.01,19.41 64.01,19.55 v2(64.14,19.69)
  BOTTOM w0.089: UH2.AV46 76.99,9.39 ; 76.99,9.39 75.8,9.39 75.63,9.57 75.31,9.57 75.17,9.71 75.17,10.03 74.89,10.31 74.85,10.31 74.84,10.31 74.57,10.31 v2(74.17,10.72) ; 76.99,9.39 76.94,9.45 UH2.AU46
  BOTTOM w0.14: DV1.3 47.36,25.02 v2(47.94,24.44)
PARSVD1: length 1.3
  TOP w0.089: v2(93.27,20.86) 93.59,20.54 T4951.1
  BOTTOM w0.089: UH2.R13 93.27,20.59 v2(93.27,20.86)
PARSVD2: length 1.5
  TOP w0.089: v2(92.7,20.89) 92.41,20.6 T4950.1
  BOTTOM w0.089: UH2.R15 92.17,20.36 v2(92.7,20.89)
PBAT_CHARGER_SMBCLK: length 341.6
  TOP w0.14: v2(274.37,18.75) 271.74,16.12 v1(271.74,14.12) 271.74,12.1 v2(271.88,11.96) ; PR106.2 13.49,6.81 13.31,6.98 v2(13.31,7.87) 13.31,8.36 13.6,8.65 PD101.2 ; v2(87.46,25.19) 87.21,25.19 86.16,26.25 86.11,26.25 86.11,26.25 83.79,26.25 82.89,25.35 82.89,24.9 82.67,24.67 82.67,24.31 82.21,23.85 82.21,23.3 82.28,23.11 82.36,23.04 82.36,22.7 82.1,22.44 80.42,22.44 80.09,22.77 79.35,22.77 78.72,22.14 76.55,22.14 75.73,21.31 74.66,21.31 73.85,20.5 72.55,20.5 72.11,20.93 72.11,21.34 71.26,22.19 70.33,22.19 69.7,21.55 67.23,21.55 63.58,17.9 62.59,17.9 60.52,19.97 57.03,19.97 56.33,19.26 56.33,18.11 56.08,17.86 56.08,17.28 55.95,17.15 55.59,17.15 v2(55.5,17.24) 55.29,17.03 55.09,17.03 54.88,17.24 PR1917.1 ; UE3.N2 v2(304.42,11.37) 304.42,11.24 305.04,10.62 306.05,10.62 RE23.1
  IN1 w0.099: v2(13.31,7.87) 13.31,8.2 13.75,8.63 13.78,8.63 15.05,9.91 26.05,9.91 30.49,14.35 30.49,15.45 31.8,16.76 44.95,16.76 45.18,16.99 49.84,16.99 50.57,16.27 52.81,16.27 53.66,17.12 55.38,17.12 v2(55.5,17.24)
  IN2 w0.099: v2(304.42,11.37) 304.59,11.19 304.59,11.04 304.49,10.93 303.99,10.93 303.71,11.21 302.61,11.21 301.91,10.51 299.27,10.51 298.48,11.3 293.08,11.3 291.35,13.03 290.48,13.03 290.02,12.57 287.8,12.57 287.28,12.05 287.28,10.65 286.88,10.25 286.36,10.25 286.05,10.56 283.56,10.56 282.7,9.7 273.26,9.7 271.65,11.3 271.65,11.74 v2(271.88,11.96)
  IN5 w0.099: v2(107.87,18.06) 107.98,18.16 110.71,18.16 111.55,17.32 124.82,17.32 125.71,16.43 138.21,16.43 138.65,15.99 140.73,15.99 141.43,16.69 164.98,16.69 165.39,16.28 175.75,16.28 178.98,19.51 178.98,22.08 179.53,22.63 181.31,22.63 181.95,21.98 182.55,21.98 184.77,19.76 234.75,19.76 235.47,19.04 251.82,19.04 253.03,17.83 255.2,17.83 255.6,17.43 256.99,17.43 257.32,17.76 261.06,17.76 261.56,18.25 273.88,18.25 v2(274.37,18.75)
  IN6 w0.099: v2(87.46,25.19) 87.46,24.96 89.08,23.34 93.38,23.34 94.12,22.6 97.49,22.6 99.19,20.91 102.69,20.91 103.43,20.17 106.15,20.17 107.87,18.44 v2(107.87,18.06)
PBAT_CHARGER_SMBDAT: length 340.6
  TOP w0.14: PD101.3 14.55,8.83 v2(14.07,8.34) 13.95,8.22 PR108.2 ; v2(87.1,24.57) 87.1,24.77 85.96,25.91 83.94,25.91 83.24,25.21 83.24,24.75 83.01,24.52 83.01,24.17 82.55,23.71 82.55,23.36 82.57,23.31 82.7,23.18 82.7,22.56 82.25,22.1 80.28,22.1 79.95,22.43 79.49,22.43 78.86,21.79 76.7,21.79 75.87,20.97 74.81,20.97 73.99,20.16 72.4,20.16 71.77,20.79 71.77,21.2 71.12,21.85 70.48,21.85 69.84,21.21 67.38,21.21 63.72,17.55 62.45,17.55 60.38,19.62 57.17,19.62 56.67,19.12 56.67,17.97 56.42,17.72 56.42,17.14 56.09,16.81 55.72,16.81 v2(55.51,16.6) 55.41,16.69 55.03,16.69 54.88,16.53 PR1913.1 ; UE3.M3 303.32,11.81 304.59,11.81 305.03,11.37 v2(305.12,11.37) 305.12,11.13 305.27,10.97 306.43,10.97 RE22.1 ; v2(271.12,11.99) 271.39,12.26 v1(271.39,15.38) 271.39,16.26 273.76,18.63 v2(273.76,18.75)
  IN1 w0.099: v2(14.07,8.34) 14.07,8.49 15.18,9.6 26.17,9.6 30.8,14.23 30.8,15.33 31.93,16.46 45.07,16.46 45.3,16.69 49.72,16.69 50.44,15.97 52.93,15.97 53.78,16.82 55.29,16.82 v2(55.51,16.6)
  IN2 w0.099: v2(271.12,11.99) 271.35,11.76 271.35,11.18 273.13,9.4 282.83,9.4 283.69,10.25 285.92,10.25 286.23,9.95 287,9.95 287.58,10.52 287.58,11.92 287.93,12.27 290.15,12.27 290.6,12.73 291.23,12.73 292.95,11 298.36,11 299.15,10.21 302.03,10.21 302.73,10.91 303.59,10.91 303.87,10.63 304.61,10.63 304.95,10.97 304.95,11.19 v2(305.12,11.37)
  IN5 w0.099: v2(273.76,18.75) 273.57,18.55 261.43,18.55 260.94,18.06 257.19,18.06 256.86,17.73 255.72,17.73 255.32,18.13 253.15,18.13 251.94,19.34 235.6,19.34 234.88,20.07 184.9,20.07 182.68,22.29 182.08,22.29 181.43,22.93 179.4,22.93 178.68,22.21 178.68,19.63 175.63,16.58 165.51,16.58 165.1,16.99 141.31,16.99 140.6,16.29 138.78,16.29 138.33,16.74 125.84,16.74 124.95,17.63 111.67,17.63 110.83,18.47 107.62,18.47 v2(107.24,18.09)
  IN6 w0.099: v2(87.1,24.57) 87.13,24.6 87.4,24.6 88.96,23.04 93.26,23.04 93.99,22.3 97.36,22.3 99.06,20.6 102.57,20.6 103.3,19.87 106.02,19.87 107.24,18.65 v2(107.24,18.09)
PBAT_PRES#: length 329.1
  TOP w0.14: PR1924.1 51.75,20.78 51.75,22.23 v2(54.03,24.51) ; v2(146.51,12.38) v1(146.51,11.82) ; v2(22.58,4.44) 22.51,4.51 PD102.2 PD102.3 20.64,4.51 20.45,4.32 PR112.1 19.69,4.52 PR111.2 ; v2(297.76,17.37) UE3.F9
  IN2 w0.089: 73.28,9.21 73.41,9.08 73.83,9.08 74.11,9.37 76.15,9.37 76.85,8.67 77.93,8.67 78.1,8.84 78.1,8.84 78.49,9.23 79.04,9.23 79.15,9.34 79.58,9.34 79.76,9.16 80.08,9.16 80.35,9.43 80.35,9.98 80.73,10.36 85.35,10.36 85.58,10.6 86.63,10.6 86.71,10.52 87.53,10.52 88.17,11.16 89.12,11.16 89.68,11.71 90.04,11.71 90.77,10.99 90.77,10.23 90.97,10.02 91.67,10.02 92.75,8.94 94.66,8.94 94.98,9.26 94.98,9.53 95.51,10.06 96.62,10.06 96.91,9.77 97.81,9.77 98.69,10.65 99.26,10.65 99.86,11.25 100.56,11.25 100.71,11.4 101.52,11.4 101.98,11.86
  IN2 w0.099: 73.28,9.21 72.88,9.61 72.36,9.61 72.22,9.75 72.22,12.91 70.64,14.49 70.64,17.24 70.23,17.65 70.23,18.66 68.71,20.18 66.74,20.18 65.84,21.09 65.47,21.09 64.65,21.91 64.65,23.11 64.16,23.61 63.66,23.61 62.1,25.16 57.51,25.16 56.75,24.39 54.15,24.39 v2(54.03,24.51) ; 101.98,11.86 103.24,13.12 105.61,13.12 106.27,13.78 108.93,13.78 109.11,13.96 109.65,13.96 112.09,16.4 113.51,16.4 113.87,16.76 115.47,16.76 115.76,17.05 121.21,17.05 121.89,16.37 122.46,16.37 123.5,15.33 128.7,15.33 129.42,14.62 140.21,14.62 142.88,11.94 146.07,11.94 v2(146.51,12.38)
  IN3 w0.091: v6(45.41,19.79) 45.41,19.06 43.98,17.63 33.39,17.63 31.06,15.3 31.06,13.92 30.02,12.88 30.02,6.48 28.88,5.34 23.48,5.34 v2(22.58,4.44)
  IN5 w0.099: v2(146.51,12.38) 147.09,12.96 163.47,12.96 163.88,12.55 177.85,12.55 180.77,15.47 214.33,15.47 215.29,14.51 225.9,14.51 226.27,14.14 231.31,14.14 231.9,14.73 246.46,14.73 249.28,11.91 262.55,11.91 263.08,12.43 266.21,12.43 266.4,12.24 268.38,12.24 269.06,11.56 272.1,11.56 272.35,11.81 272.35,12.38 273.73,13.76 276.9,13.76 278.27,15.13 285.02,15.13 285.6,15.71 287.08,15.71 287.41,16.03 289.81,16.03 290.69,16.91 294.16,16.91 295.11,15.96 296.98,15.96 297.36,16.34 297.36,16.97 v2(297.76,17.37)
  BOTTOM w0.14: v2(54.03,24.51) 54.03,22.73 53.28,21.97 52.25,21.97 51.7,21.43 51.7,21.12 51.06,20.47 46.09,20.47 v6(45.41,19.79)
PBRSVD1: length 1.1
  TOP w0.089: T4964.1 92.97,19.67 v2(92.94,19.69)
  BOTTOM w0.089: v2(92.94,19.69) 92.91,19.66 UH2.U13
PBTN_SW#: length 347.4
  TOP w0.14: RE36.2 CE29.1 287.1,19.18 286.65,18.73 v2(286.53,18.73) ; SW1.1 336.54,111.85 338.39,110 342.79,110 v1(343.87,111.08) v2(345.31,112.52) 345.31,115.37 DL1.3
  IN6 w0.099: v2(173.61,8.76) 175.17,10.33 177.31,10.33 177.89,10.91 202.68,10.91 203.1,11.33 214.7,11.33 218.16,7.88 234.19,7.88 234.59,8.28 271.25,8.28 271.78,7.75 278.51,7.75 279.87,6.38 280.79,6.38 280.99,6.58 282.32,6.58 283.14,5.76 v2(283.18,5.76) 283.3,5.76 284.12,6.58 287.18,6.58 287.92,5.84 291.06,5.84 292.24,7.01 297.56,7.01 298.72,8.17 303.36,8.17 305.13,9.94 306.25,9.94 307.74,8.45 309.31,8.45 310.49,9.63 311.67,9.63 311.89,9.41 314.49,9.41 315.23,10.16 315.23,11.16 314.54,11.86 314.54,16.07 315.23,16.76 315.23,18.64 318.85,22.26 319.14,22.26 320.4,23.52 320.4,30.59 322.94,33.13 327.51,33.13 328.89,34.5 v2(330.9,34.5) 330.46,34.95 330.46,42.17 332.82,44.53 332.82,51.88 332.82,52.27 332.82,55.34 337.08,59.59 337.08,63.66 334.36,66.37 334.36,80.21 337.26,83.11 337.26,83.64 337.26,83.67 337.26,86.89 338.3,87.93 339.39,87.93 339.67,87.65 339.67,87.3 339.47,87.11 339.47,86.58 339.77,86.29 340.85,86.29 342.6,88.04 343.64,88.04 344.34,88.74 344.34,89.77 345.13,90.56 345.13,104.94 344.3,105.77 344.3,111.51 v2(345.31,112.52)
  BOTTOM w0.14: SW_BOT.1 329.39,32.97 v2(330.9,34.5) 330.9,34.74 329.44,36.2 329.44,38.36 328.8,38.99 317.63,38.99 315.6,36.96 313.44,36.96 312.23,35.75 Q6.1 ; JAPS.11 173.62,8.75 173.61,8.76 v2(173.61,8.76) ; v2(286.53,18.73) 286.53,18.71 285.83,18.01 281.79,18.01 281.18,17.4 281.18,5.58 281.43,5.33 282.75,5.33 v2(283.18,5.76)
PBTN_SW#_R: length 10.2
  TOP w0.14: v2(309.25,35.82) v1(309.25,34.93)
  BOTTOM w0.14: v2(309.25,35.82) 309.25,34.85 Q6.3 311.16,34.76 D324.1 312.55,35.43 313.56,36.45 314.71,36.45 315.1,36.06 JFP.7
PCH_3.3V_TS_EN: length 329
  IN6 w0.089: 101.98,5.77 99.01,5.77 98.85,5.93 94.15,5.93 94.05,6.03 91.59,6.03 91.4,5.85 90.47,5.85 89.57,4.95 86.88,4.95 86.46,5.37 85.99,5.37 84.91,6.45 84.91,7.54 85.45,8.09 v2(85.45,8.79)
  IN6 w0.099: v2(339.5,62.99) 339.5,61.6 337.75,59.85 337.75,52.2 333.22,47.68 333.22,41.47 331.34,39.58 331.34,37.19 330.77,36.63 330.77,35.34 331.52,34.59 331.52,34.12 331.26,33.86 328.97,33.86 326.77,31.65 326.77,27.69 325.25,26.16 321.18,26.16 320.81,25.78 320.81,23.32 319.46,21.97 318.95,21.97 315.43,18.45 315.43,16.68 314.74,15.99 314.74,11.94 315.51,11.17 315.51,10.12 313.8,8.41 312.74,8.41 311.04,6.7 307.6,6.7 306.4,7.9 306.4,9.15 306.05,9.5 305.25,9.5 303.34,7.59 300.21,7.59 298.57,5.94 297.3,5.94 296.63,6.61 292.4,6.61 291.23,5.44 287.64,5.44 286.95,6.12 285.17,6.12 285.06,6.01 285.06,5.61 285.06,5.44 284.55,4.93 282.11,4.93 281.06,5.98 279.61,5.98 278.36,7.24 271.53,7.24 270.89,7.87 263,7.87 261.76,6.63 254.41,6.63 253.74,7.29 245.12,7.29 243.85,6.02 219.07,6.02 214.57,10.52 212.56,10.52 212.33,10.28 184.41,10.28 183.39,9.26 177.24,9.26 174.99,7.01 166.29,7.01 165.55,6.27 162.51,6.27 162.05,6.73 152.54,6.73 152.03,6.22 148.34,6.22 145.28,9.28 140.85,9.28 139.89,10.24 134.76,10.24 133.6,9.09 124.56,9.09 124.21,8.74 119.59,8.74 118.21,7.36 118.21,5.47 117.01,4.27 106.75,4.27 105.02,6.01 102.36,6.01 102.12,5.77 101.98,5.77
  BOTTOM w0.089: UH2.BD30 84.95,6.32 84.95,7.42 85.14,7.61 85.14,8.17 85.35,8.38 85.35,8.69 v2(85.45,8.79)
  BOTTOM w0.14: v1(339.21,60.45) 339.87,61.11 339.87,61.84 RZ39.1 339.35,62.84 v2(339.5,62.99) 339.95,62.99 340.53,62.42 UZ5.3
PCH_ALW_ON: length 281.9
  TOP w0.14: v2(106.68,52.78) 106.25,53.21 UZ23.2 ; v2(133.73,10.29) 133.28,9.84 131.52,9.84 130.54,10.82 130.54,14.61 127.76,17.39 119.37,17.39 118.92,17.85 118.92,18.31 117.7,19.53 115.29,19.53 114.32,20.5 112.63,20.5 111.72,21.42 111.72,26.22 109.13,28.81 109.13,36.58 111.88,39.33 116.75,39.33 123.1,45.68 v1(123.1,47.38) 123.1,49.94 122.75,50.29 v2(122.69,50.29) ; UE3.M8 303.3,16.51 304.03,16.51 304.12,16.59 304.53,16.59 v2(304.99,16.13)
  IN5 w0.099: v2(304.99,16.13) 305.9,15.22 305.9,14.55 305.45,14.09 305.45,13.77 302.21,10.53 300.28,10.53 300.09,10.34 298.83,10.34 298.58,10.59 293.37,10.59 291.06,12.9 290.27,12.9 290.26,12.89 287.61,12.89 287.01,13.49 283.46,13.49 280.05,10.08 278.68,10.08 277.43,8.83 273.68,8.83 272.16,10.35 268.49,10.35 268.43,10.41 265.89,10.41 265.07,11.23 263.58,11.23 263.05,10.7 248.63,10.7 246.76,12.57 225.71,12.57 225.15,13.13 214.96,13.13 213.84,14.26 187.15,14.26 185.7,12.81 185.7,11.18 184.14,9.63 169.57,9.63 169.34,9.4 163.93,9.4 162.82,10.52 152.48,10.52 151.98,11.01 140.33,11.01 139.67,10.34 133.79,10.34 v2(133.73,10.29)
  BOTTOM w0.14: v2(106.68,52.78) 106.91,52.55 106.91,48.33 109.02,46.22 112.96,46.22 113.98,47.24 115.01,47.24 116.53,48.76 117.88,48.76 118.75,47.89 121.73,47.89 122.69,48.85 v2(122.69,50.29)
PCH_ALW_ON_R: length 4.8
  TOP w0.14: v5(57.98,9.84) 57.98,9.34 57.63,8.99 RZ46.2 RZ1133.2 57.23,7.72 56.08,7.72 55.44,7.08 UZ4.3
PCH_BATLOW#: length 2.9
  TOP w0.089: v2(77.64,6.18) 77.84,6.37 77.84,6.67 v1(77.8,6.71) 77.7,6.81 77.14,6.81 RH515.1
  BOTTOM w0.089: v2(77.64,6.18) 77.85,5.96 UH2.BF44
PCH_CPU_BCLK_N: length 118.4
  IN6 w0.089: 171.36,79.95 171.37,79.96 171.37,79.98 171.41,80.02 171.41,80.03 171.74,80.37 172.54,80.37 172.75,80.16 173.43,80.16 174.36,81.09 176.18,81.09 176.4,81.32 177.84,81.32 178.54,82.02 v2(178.54,82.91)
  IN6 w0.107: 171.36,79.95 170.22,78.82 168.99,78.82 168.89,78.72 162.64,78.72 162.15,78.23 162.15,77.95 160.38,76.18 158.7,76.18 158.12,75.59 153.39,75.59 153.04,75.95 141.51,75.95 141.11,75.54 138.25,75.54 137.85,75.13 132.82,75.13 130.31,72.63 130.31,70.59 129.62,69.89 129.62,67.9 123.2,61.48 123.2,58.32 122.92,58.04 122.92,57.28 122.69,57.05 122.69,56.49 123.01,56.17 123.01,54.02 120.8,51.82 119.72,51.82 118.24,50.34 118.24,48.48 115.32,45.56 115.32,44.67 106.35,35.71 106.35,33.12 101.04,27.81 99.9,26.67 98.28,26.67 97.81,27.14 97.17,27.14 96.83,26.8 96.31,26.8 v2(96.18,26.67)
  BOTTOM w0.076: UH1.A32 178.28,82.91 v2(178.54,82.91)
  BOTTOM w0.089: UH2.C8 96.18,26.65 v2(96.18,26.67)
PCH_CPU_BCLK_P: length 118.4
  IN6 w0.089: v2(178.08,82.57) 178.3,82.57 178.35,82.52 178.35,82.09 177.76,81.51 176.33,81.51 176.1,81.28 174.28,81.28 173.35,80.35 172.82,80.35 172.62,80.55 171.67,80.55 171.21,80.1
  IN6 w0.107: 171.21,80.1 170.13,79.02 168.9,79.02 168.8,78.92 162.55,78.92 161.95,78.32 161.95,78.04 160.29,76.38 158.62,76.38 158.03,75.79 153.48,75.79 153.12,76.15 141.43,76.15 141.02,75.74 138.17,75.74 137.76,75.34 132.73,75.34 130.11,72.71 130.11,70.67 129.41,69.98 129.41,67.98 123,61.56 123,58.41 122.71,58.12 122.71,57.36 122.48,57.13 122.48,56.41 122.81,56.08 122.81,54.11 120.72,52.02 119.64,52.02 118.03,50.42 118.03,48.57 115.11,45.64 115.11,44.76 106.15,35.79 106.15,33.21 100.75,27.81 99.81,26.87 98.36,26.87 97.9,27.34 97.08,27.34 96.74,27 96.46,27 v2(96.22,27.24)
  BOTTOM w0.076: v2(178.08,82.57) 177.79,82.86 177.63,82.86 UH1.B31
  BOTTOM w0.089: v2(96.22,27.24) 96.21,27.24 95.71,26.74 UH2.B8
PCH_CPU_PCIBCLK_N: length 119.8
  IN6 w0.089: 172.13,85.14 172.15,85.14 172.16,85.15 175.19,85.15 175.63,84.7 176.28,84.7 176.46,84.87 v2(176.71,84.87)
  IN6 w0.107: 172.13,85.14 171.11,85.14 170.48,84.51 170.48,81.91 169.77,81.2 139.45,81.2 137.25,79.01 133.44,79.01 132.9,78.48 132.9,77.79 129.07,73.95 129.07,71.48 128.35,70.76 128.35,68.4 120.73,60.79 120.73,57.76 121.08,57.41 121.08,56.38 118.77,54.06 118.77,52.72 116.79,50.74 116.79,48.96 114.79,46.97 112.11,46.97 110.41,45.26 109.2,45.26 105.68,41.74 105.68,40.53 105.16,40.01 102.78,40.01 96.79,34.02 96.79,28.69 v2(97.02,28.46)
  BOTTOM w0.076: UH1.C36 176.69,84.89 v2(176.71,84.87)
  BOTTOM w0.089: 96.98,27.81 96.98,27.8 96.92,27.74 96.92,26.98 UH2.B6
  BOTTOM w0.152: 96.98,27.81 96.98,28.42 v2(97.02,28.46)
PCH_CPU_PCIBCLK_P: length 119.9
  IN6 w0.089: v2(175.91,85.29) 176.27,85.29 176.35,85.21 176.35,85.03 176.21,84.89 175.71,84.89 175.26,85.33 172.16,85.33 172.15,85.34 172.13,85.34
  IN6 w0.107: v2(96.43,28.48) 96.46,28.48 96.58,28.61 96.58,34.11 102.69,40.22 105.08,40.22 105.47,40.61 105.47,41.82 109.12,45.47 110.33,45.47 112.03,47.17 114.71,47.17 116.59,49.05 116.59,50.83 118.57,52.81 118.57,54.15 120.88,56.46 120.88,57.32 120.53,57.67 120.53,60.87 128.14,68.49 128.14,70.84 128.87,71.56 128.87,74.03 132.7,77.87 132.7,78.57 133.35,79.22 137.17,79.22 139.36,81.41 169.69,81.41 170.28,82 170.28,84.59 171.03,85.34 172.13,85.34
  BOTTOM w0.076: UH1.D35 176.22,84.98 v2(175.91,85.29)
  BOTTOM w0.089: UH2.A6 96.65,27.81
  BOTTOM w0.152: 96.65,27.81 96.65,28.13 96.43,28.35 v2(96.43,28.48)
PCH_DMIC_CLK: length 71.5
  IN4 w0.089: 91.95,1.91 91.77,2.08 v2(91.77,3.2) ; 101.98,3.11 101.66,3.43 100.72,3.43 100.46,3.17 100.46,2.03 100.33,1.91
  IN4 w0.091: 101.98,3.11 103,2.1 109.86,2.1 110.39,2.63 115.17,2.63 115.61,2.18 124.57,2.18 125.1,1.65 148.46,1.65 148.85,2.03 148.85,3.44 v2(148.45,3.84) ; 91.95,1.91 92.27,1.59 100.01,1.59 100.33,1.91
  BOTTOM w0.089: v2(91.77,3.2) 91.71,3.27 91.71,3.28 91.71,3.29 91.71,4.91 91.9,5.1 91.9,5.43 92.04,5.57 92.04,5.99 UH2.BD16
  BOTTOM w0.14: v2(148.45,3.84) 148.07,4.22 148.07,8.4 RA103.2
PCH_DMIC_CLK_R: length 5.5
  BOTTOM w0.14: RA103.1 148.4,9.46 148.59,9.66 148.59,9.8 CE3321.1 149.89,11.09 150.54,11.09 150.72,11.28 v1(151.55,11.28) 151.99,11.71 RE310.1
PCH_DMIC_DAT: length 72.1
  TOP w0.14: v2(152.43,4.19) v1(152.43,3.44)
  IN3 w0.089: v6(92.27,3.4) 92.58,3.71 94.64,3.71 95.32,3.03 95.95,3.03 96.19,3.26 97.2,3.26 97.8,2.66 99.53,2.66 100,3.14 100,3.6 100.45,4.05 101.76,4.05 101.98,3.82
  IN3 w0.091: 101.98,3.82 102.57,3.24 107.19,3.24 107.81,3.86 110.81,3.86 112.54,2.13 112.54,1.98 112.71,1.8 116.35,1.8 117.14,2.6 124.53,2.6 125.24,1.88 146.56,1.88 147.59,2.91 151.14,2.91 v2(152.43,4.19)
  BOTTOM w0.089: UH2.BF15 92.08,5.2 92.08,5.03 91.88,4.84 91.88,3.89 92.27,3.51 v6(92.27,3.4)
  BOTTOM w0.14: RA102.2 151.17,3.99 151.5,3.66 152.03,3.66 152.43,4.06 v2(152.43,4.19)
PCH_DMIC_DAT_R: length 2.2
  BOTTOM w0.14: RE309.1 152.35,8.44 CE3322.1 151.17,8.23 RA102.1
PCH_DP1_HPD: length 95.8
  IN3 w0.089: 33.66,41.48 32.03,43.11 32.03,45.01 32.33,45.31 v2(32.45,45.31) ; 94.53,14.29 95.98,12.85 95.98,12.09 96.78,11.29 v2(96.78,11.02)
  IN3 w0.112: 33.66,41.48 33.66,37.92 33.35,37.62 33.35,35.97 33.79,35.54 34.16,35.54 34.48,35.22 34.48,34.29 34.95,33.82 34.95,31.85 35.38,31.42 37.52,31.42 38.12,30.83 39.08,30.83 39.33,30.57 39.33,30.45 42.98,26.8 43.27,26.8 43.27,26.8 45.34,26.8 46.37,25.77 48.73,25.77 48.94,25.56 59.66,25.56 60.27,24.94 66.34,24.94 67.7,23.58 68.1,23.58 71.41,20.27 73.97,20.27 76.33,17.91 76.33,15.01 76.99,14.35 79.23,14.35 79.41,14.17 81.91,14.17 82.12,14.38 82.12,15.11 83.98,16.97 87.69,16.97 88.14,17.42 89.91,17.42 90.18,17.15 90.18,16.81 90.47,16.52 91.83,16.52 93.23,15.12 93.7,15.12 94.53,14.29
  BOTTOM w0.089: 33.66,45.56 33.62,45.52 32.66,45.52 v2(32.45,45.31) 32,45.31 31.94,45.25 31.54,45.25 31.41,45.12 31.41,44.74 UT1.AA2 ; v2(96.78,11.02) 96.55,10.8 UH2.AT6
  BOTTOM w0.17: RT41.2 33.66,45.56
PCH_DP2_HPD: length 102.8
  TOP w0.14: RT42.2 36.43,42.15 36.72,42.15 37.29,41.57 37.62,41.57 37.93,41.25 37.93,40.6 37.09,39.75 37.09,38.23 37.85,37.47 v1(37.85,36.87) 37.85,35.94 37.4,35.5 34.93,35.5 34.29,34.86 v2(33.97,34.86)
  IN3 w0.089: v2(33.97,34.86) 33.97,34.16 34.16,33.97
  IN3 w0.112: v2(30.61,42.82) 30.96,42.47 31.43,42.47 33.12,40.77 33.12,35.71 v2(33.97,34.86) ; 34.16,33.97 34.41,33.97 34.69,33.68 34.69,31.81 35.29,31.21 37.44,31.21 38.76,29.88 39.48,29.88 42.78,26.58 45.25,26.58 46.28,25.55 48.64,25.55 48.85,25.35 59.57,25.35 60.19,24.73 65.78,24.73 67.41,23.1 68.04,23.1 71.22,19.92 73.42,19.92 76.11,17.23 76.11,14.92 77.52,13.51 79.15,13.51 79.61,13.96 81.99,13.96 82.32,14.3 82.32,14.86 82.76,15.3 83.74,15.3 84.06,14.98 86.19,14.98 87.04,15.84 89.52,15.84 89.75,16.07 90.07,16.07 90.79,15.34 91.6,15.34 92.27,14.67 92.27,14.11 92.57,13.81 94.42,13.81 95.7,12.53 95.7,12.13 94.44,10.87 94.08,10.87 v2(94.06,10.9)
  BOTTOM w0.089: v2(94.06,10.9) 94.4,11.24 UH2.AN10
  BOTTOM w0.102: v2(30.61,42.82) UT1.Y6
PCH_DP3_HPD: length 123.3
  TOP w0.089: v1(94.83,11.02) 95.09,10.76 v2(95.09,10.43) 95.1,10.44 96.84,10.44 RM1145.2
  TOP w0.14: v2(31.06,53.31) 31.1,53.26 31.1,52.82 31.97,51.96 33.21,49.72 33.21,48.71 35.1,46.82 35.1,46.52 36.09,45.52 36.09,45.29 42.16,39.22 42.82,39.22 43.63,38.41 44.4,38.41 45.65,37.16 47.32,37.16 47.7,36.78 50.33,36.78 50.76,36.35 50.76,33.14 49.21,31.6 48.58,31.6 48.08,31.1 48.08,30.59 49.09,29.59 49.09,26.73 v2(49.66,26.16) ; RM3.2 27.84,69.71 28.13,70 v2(28.37,70)
  IN6 w0.089: v2(95.09,10.43) 95.08,10.42 92.3,10.42 91.77,10.95 91.77,12.04 91.49,12.32 90.95,12.32 90.61,11.98 87.65,11.98 85.2,14.42 84.46,14.42 83.95,14.94 83.4,14.94 82.93,15.42 82.93,16.09 82.67,16.35 82.06,16.35 81.8,16.09 81.8,15.25 82.1,14.96 82.1,14.22 81.63,13.75 79.84,13.75 79.64,13.56 77.49,13.56 76.65,14.4 76.65,16.93 74.54,19.04
  IN6 w0.099: 30.77,53.31 29.46,54.61 29.46,57.07 29.15,57.39 29.15,58.15 28.62,58.68 28.62,60.38 28.06,60.95 28.06,65.18 27.58,65.65 27.58,69.22 v2(28.37,70) ; v2(49.66,26.16) 49.66,26.04 49.98,25.71 56.45,25.71 56.93,25.24 59.9,25.24 60.57,24.56 61.4,24.56 62.47,23.49 65.46,23.49 66.22,22.73 66.85,22.73 67.13,23.01 69.54,23.01 70.48,22.07 71.35,22.07 72.05,21.37 73.24,21.37 73.3,21.3 73.3,20.72 74.19,19.83 74.19,19.38 74.54,19.04
  IN6 w0.107: 30.77,53.31 v2(31.06,53.31)
  BOTTOM w0.089: v2(95.09,10.43) 95.09,10.43 95.09,10.49 95.16,10.56 UH2.AP9
PCH_DP3_HPD_R: length 3.7
  TOP w0.14: UM1.B1 25.69,70.87 25.95,70.87 26.44,70.37 v1(27.38,70.37) 27.38,69.93 RM3.1
PCH_DPWROK_EC: length 286.1
  TOP w0.14: UE3.F8 297.8,16.53 v2(297.8,16.56) ; v1(293.45,26.25) 293.11,25.91 v2(293.11,25.74) ; RH309.1 67.04,8.38 v6(66.84,8.19)
  IN2 w0.099: v6(66.84,8.19) 66.81,8.16 66.77,8.16 66.58,8.35 66.48,8.35 64.04,10.79 64.04,11.59 v2(64.04,11.6)
  IN5 w0.089: 97.3,21.89 98.44,20.76 101.22,20.76 101.59,20.38 101.98,20.38
  IN5 w0.099: 97.3,21.89 96.22,21.89 95.11,20.79 94.38,20.79 93.71,21.45 89.98,21.45 88.94,20.42 86.07,20.42 84.94,19.29 84.22,19.29 83.95,19.02 83.95,18.19 83.64,17.89 83.64,17.07 83.01,16.43 82.15,16.43 81.87,16.16 81.87,15.25 82.08,15.05 82.08,14.23 81.75,13.91 79.96,13.91 79.24,13.18 79.24,12.61 79.02,12.39 78.74,12.39 78.43,12.07 76.56,12.07 76.2,12.43 76.2,13.02 75.05,14.17 74.78,14.17 73.94,15 72.24,15 71.49,14.25 70.28,14.25 68.56,12.52 67.34,12.52 65.6,10.78 64.26,10.78 64.04,11.01 v2(64.04,11.6) ; 101.98,20.38 102.17,20.38 102.88,19.67 105.86,19.67 106.72,18.81 129.48,18.81 130.66,17.63 165.49,17.63 165.86,17.26 173.8,17.26 174.77,18.23 176.35,18.23 178.07,19.94 178.07,22.51 187.25,31.7 243.87,31.7 247.59,27.98 251.68,27.98 252.75,26.91 257.79,26.91 259.75,24.95 259.75,24.13 262.96,20.92 262.96,20.09 262.9,20.03 262.9,19.57 263.25,19.23 268.51,19.23 269.35,20.07 272.25,20.07 275.82,23.63 276.74,23.63 277.62,22.76 286.77,22.76 289.11,25.1 291.53,25.1 292.15,25.73 293.1,25.73 v2(293.11,25.74)
  IN6 w0.076: 293.56,19.32 294.32,18.57 297.12,18.57 297.36,18.33 297.36,17 v2(297.8,16.56)
  IN6 w0.099: 293.56,19.32 293.14,19.74 293.14,21.08 292.08,22.15 289.4,22.15 289,22.55 289,23.34 289.5,23.84 292.45,23.84 293.4,24.79 293.4,25.45 v2(293.11,25.74)
PCH_DPWROK_R: length 21.7
  TOP w0.14: RH309.2 67.92,7.9 RH5859.2 67.92,6.45 RH401.2 v5(69.38,6.43) 69.86,6.43 v6(70.13,6.7)
  IN1 w0.076: 73.28,12.78 73.52,12.78 74.88,11.41 75.86,11.41 76.92,10.35 79.05,10.35 79.55,9.85 79.55,9.18 79.46,9.09 79.46,8.98 v2(79.43,8.95)
  IN1 w0.099: 73.28,12.78 72.19,12.78 70.81,11.4 70.81,7.06 70.45,6.7 v6(70.13,6.7)
  BOTTOM w0.089: UH2.AW41 v2(79.43,8.95)
PCH_GPP_A11_BALL: length 3.4
  BOTTOM w0.089: T17.1 81.73,2.91 81.73,4.16 81.4,4.49 81.4,5.42 81.66,5.68 UH2.BE36
PCH_GPP_A18: length 1.5
  TOP w0.089: T124.1 82.12,4.98 v2(81.8,4.66)
  BOTTOM w0.089: UH2.BF35 82.32,5.11 81.88,4.66 v2(81.8,4.66)
PCH_GPP_C10: length 1.3
  TOP w0.089: T4989.1 88.69,8.2 88.49,8.01 v2(88.48,8.01)
  BOTTOM w0.089: v2(88.48,8.01) 88.48,8 88.04,8 UH2.BA24
PCH_GPP_C11: length 1.3
  TOP w0.089: v2(88.39,10.8) 88.15,11.04 T4988.1
  BOTTOM w0.089: UH2.AP24 88.35,10.84 v2(88.39,10.8)
PCH_GPP_D7_BALL: length 1.5
  TOP w0.089: T121.1 90.33,9.73 v2(90.33,8.78)
  BOTTOM w0.089: v2(90.33,8.78) 90.37,8.74 90.49,8.74 UH2.AW18
PCH_GPP_H23_BALL: length 9
  BOTTOM w0.089: 72.4,16.62 72.97,16.62 74.04,15.55 74.04,15.02 75.07,13.99 75.52,13.99 75.98,13.53 UH2.AJ47
  BOTTOM w0.14: 72.4,16.62 71.86,16.62 71.36,17.12 69.61,17.12 T8.1
PCH_GPP_K2_BALL: length 9.5
  BOTTOM w0.089: 75.06,21.64 75.49,21.64 75.77,21.92 76.74,21.92 UH2.L46
  BOTTOM w0.14: 75.06,21.64 74.84,21.64 73.91,22.58 71.17,22.58 70.63,23.12 69.8,23.12 69.51,22.82 T94.1
PCH_GPP_K8_BALL: length 8.8
  BOTTOM w0.089: 75.06,21.14 75.83,21.14 UH2.P48
  BOTTOM w0.14: T91.1 68.81,21.3 69.53,22.02 70.76,22.02 70.82,22.08 73.64,22.08 74.58,21.14 75.06,21.14
PCH_GPP_K9_BALL: length 8.5
  BOTTOM w0.089: UH2.V47 76.53,18.94 74.93,18.94 74.68,19.18
  BOTTOM w0.14: 74.68,19.18 74.68,19.57 73.32,20.93 73.32,21.64 73.12,21.84 70.92,21.84 70.64,21.55 T92.1
PCH_GPP_K23_BALL: length 11.2
  BOTTOM w0.089: 75.06,21.38 75.48,21.38 75.84,21.74 76.82,21.74 76.92,21.85 77.34,21.85 UH2.M45
  BOTTOM w0.14: T4.1 67.3,21.32 67.88,21.32 68.82,22.26 70.66,22.26 70.72,22.32 73.74,22.32 74.68,21.38 75.06,21.38
PCH_ITP_PMODE: length 142.5
  TOP w0.14: v2(120.34,94.28) 119.91,94.28 119.3,94.88 RH479.1
  IN2 w0.099: v2(97.51,12.65) 97.51,13.24 98.27,14 98.85,14 99.34,14.49 101.83,14.49 102.12,14.78 103.76,14.78 103.97,14.98 108.43,14.98 108.61,15.16 109.15,15.16 111.64,17.65 113.01,17.65 113.4,18.05 v2(113.4,18.31)
  IN4 w0.099: v2(113.4,18.31) 111.25,20.45 111.25,27.51 110.81,27.96 110.81,32.05 127.68,48.92 128.65,48.92 132.81,53.09 132.81,64.72 131.73,65.8 131.73,70.83 131.14,71.42 131.14,76.69 133.61,79.17 136.77,79.17 137.12,79.51 137.12,80.12 136.95,80.28 136.26,80.28 135.26,81.28 135.26,95.87 134.79,96.34 134.79,99.02 133.48,100.33 133.48,101.26 132.76,101.98 129.71,101.98 129.15,101.43 128.04,101.43 127.77,101.7 120.97,101.7 120.02,100.75 120.02,96.65 119.79,96.42 119.79,94.83 v2(120.34,94.28)
  BOTTOM w0.089: UH2.AL3 97.65,12.51 v2(97.51,12.65)
PCH_JTAG_TCK: length 167.2
  TOP w0.14: JXDP.55 129.28,99.51 129.68,99.91 130.17,99.91 130.62,100.36 v5(133.54,100.36) v2(133.95,100.78)
  IN2 w0.099: v2(113.32,44.02) 113.56,44.02 114.96,42.61 117.18,42.61 123.67,49.1 123.67,50.52 123.17,51.03 123.17,51.35 123.53,51.72 123.53,52.21 123.94,52.62 123.94,58.78 124.45,59.29 124.45,61.99 126.38,63.92 130.95,63.92 131.08,63.79 131.73,63.79 132.57,64.62 v2(132.57,66.68)
  IN4 w0.089: 134.62,77.92 137.36,77.92 138,78.56 138,80.31 137.61,80.7 136.63,80.7 135.74,81.58 135.74,89.72 135.73,89.73 ; 101.74,27.81 101.74,27.69 101.95,27.48 101.95,21.25 100.88,20.19 v2(100.79,20.19)
  IN4 w0.091: 101.74,27.81 101.74,32.99 101.17,33.55 101.17,34.49 101.47,34.8 103.38,34.8 103.63,35.05 103.63,36.96 103.89,37.21 106.97,37.21 110.26,40.51 110.26,41.29 112.99,44.02 v2(113.32,44.02) ; 134.62,77.92 133.39,77.92 131.83,76.35 131.83,72.2 132.85,71.18 132.85,66.96 v2(132.57,66.68) ; v2(133.95,100.78) 135.59,99.13 135.59,95.66 135.73,95.52 135.73,89.73
  IN5 w0.089: v2(101.18,11.94) 100.51,11.94 100.24,12.21 95.09,12.21 94.85,12.45 93.51,12.45 92.98,11.92 91.84,11.92 91.51,12.25 89.7,12.25 89.08,11.63 86.76,11.63 86.2,12.19 85.73,12.19 83.25,14.67 83.25,16.3 83.83,16.88 83.83,17.82 84.18,18.17 84.18,18.83 84.37,19.02 84.99,19.02 86.11,20.14 93.67,20.14 94,20.47 95.76,20.47 95.87,20.58 100.4,20.58 v2(100.79,20.19)
  BOTTOM w0.089: RH95.2 101.33,11.79 v2(101.18,11.94) 101.18,13.09 100.91,13.36 99.26,13.36 98.84,13.79 98.21,13.79 98.19,13.78 98.03,13.78 97.87,13.62 UH2.AJ3
PCH_JTAG_TDI: length 137.3
  TOP w0.14: v5(116.79,93.68) 117.37,93.68 117.64,93.94 v2(117.64,94.51)
  IN4 w0.091: v2(117.64,94.51) 118.28,93.88 120.25,93.88 120.39,93.73 120.66,93.73 120.81,93.87 120.81,94.53 120.34,94.99 120.34,100.45 121.24,101.35 127.32,101.35 127.65,101.02 130.1,101.02 130.91,100.2 132.59,100.2 133.77,99.02 133.77,96.05 134.53,95.29 134.53,81.32 131.78,78.57 131.78,78.12 130.34,76.67 130.34,71.21 130.85,70.69 130.85,65.33 131.89,64.29 131.89,54.55 109.83,32.49 109.83,27 110.8,26.03 110.8,17.07 110.52,16.79 v2(110.03,16.79)
  BOTTOM w0.089: 101.98,12.93 101.95,12.93 101.23,13.65 99.25,13.65 98.87,14.03 UH2.AH2
  BOTTOM w0.14: v2(110.03,16.79) 108.7,16.79 108.23,16.32 108.02,16.32 107.89,16.19 107.89,15.35 106.56,14.02 105.1,14.02 104.01,12.93 101.98,12.93 ; RH100.2 118.33,94.96 RH477.2 118.11,94.98 v2(117.64,94.51)
PCH_JTAG_TDO: length 108.9
  TOP w0.14: v2(120.96,95.85) 120.36,95.26 v5(120.36,95.16)
  IN4 w0.089: v2(97.5,14.79) 97.24,15.05 95.9,15.05 95.48,15.47 95.48,16.09 97.61,18.22 97.61,22.74 99.6,24.73 99.6,26.15 100.06,26.61 100.06,27.81
  IN4 w0.091: 100.06,27.81 100.06,28.6 97.37,31.29 97.37,34.78 100.07,37.48 100.07,38.47 100.92,39.32 105.76,39.32 107.65,41.21 107.65,41.5 109.27,43.12 109.82,43.12 113.62,46.91 115.11,46.91 117.73,49.54 117.73,63.27 122.12,67.66 122.12,69.45 124.32,71.66 124.32,85.06 122.31,87.08 122.31,91.75 121.49,92.57 121.49,95.35 120.99,95.85 v2(120.96,95.85)
  BOTTOM w0.089: v2(97.5,14.79) 97.5,14.53 97.84,14.18 97.84,14.03 97.87,14 UH2.AH3
  BOTTOM w0.14: v2(120.96,95.85) 120.55,95.45 120.55,95.28 120.26,94.98 RH478.2 120.34,94.79 120.63,94.79 120.85,94.57 120.85,93.64 120.52,93.32 120.52,92.83 120.25,92.57 RH97.2
PCH_JTAG_TMS: length 103.9
  TOP w0.14: v2(120.02,93.26) 120.02,92.86 v5(120.22,92.66)
  IN4 w0.089: 99.85,27.81 99.85,26.65 99.42,26.22 99.42,24.81 97.41,22.79 97.41,18.27 95.31,16.17 95.31,15.4 95.79,14.92 v2(95.79,14.62)
  IN4 w0.091: 99.85,27.81 99.85,28.54 97.18,31.21 97.18,34.89 99.79,37.5 99.79,38.57 100.73,39.51 105.68,39.51 107.45,41.29 107.45,41.58 109.19,43.32 109.74,43.32 113.55,47.12 115.01,47.12 117.52,49.62 117.52,63.45 121.91,67.84 121.91,69.7 124.13,71.92 124.13,84.98 122.12,87 122.12,91.67 121.2,92.58 120.59,92.58 120.27,92.9 120.27,93.01 v2(120.02,93.26)
  BOTTOM w0.089: UH2.AJ4 96.88,14.1 96.31,14.1 v2(95.79,14.62)
  BOTTOM w0.14: v2(120.02,93.26) 120.02,93.34 RH98.2 119.17,94.96 RH12.2
PCH_JTAGX: length 116.9
  TOP w0.14: v2(133.05,101.05) 132.77,101.33 v5(131.99,101.33) 131.89,101.44 RH491.1
  IN2 w0.099: v2(96.89,14.69) 97.02,14.69 97.33,14.38 97.75,14.38 98.26,14.89 101.55,14.89 101.85,15.18 103.59,15.18 103.8,15.38 106.65,15.38 107.25,15.98 107.25,16.19 107.52,16.46 108.55,16.46 108.68,16.59 110.84,18.75 111.78,18.75 v2(112.23,18.3)
  IN4 w0.089: 134.89,81.77 134.89,81.24 134.62,80.98 ; 134.89,89.57 134.89,84.65
  IN4 w0.091: 134.62,80.98 133.02,79.38 133.02,79.03 130.72,76.73 130.72,71.34 131.31,70.74 131.31,65.58 132.3,64.6 132.3,54.24 110.32,32.26 110.32,28.02 110.32,27.67 111.02,26.97 111.02,19.51 v2(112.23,18.3) ; 134.89,89.57 134.89,95.21 133.97,96.14 133.97,99.1 133.05,100.01 v2(133.05,101.05)
  IN4 w0.099: 134.89,84.65 134.89,81.77
  BOTTOM w0.089: UH2.AH4 97.38,14.27 97.38,14.4 97.08,14.69 v2(96.89,14.69)
PCH_PCIE_WAKE#: length 283.3
  TOP w0.14: RH453.1 72.86,7.37 73.22,7.01 73.22,6.44 v2(73.69,5.97) 73.69,5.73 73.56,5.61 73.56,5.52 73.26,5.21 RT5843.1 ; v2(305.78,8.87) 305.26,9.4 304.67,9.4 304.28,9.01 303.07,9.01 302.16,9.92 UE3.L1 ; v1(305.73,27.22) 305.99,26.95 v2(305.99,26.74)
  IN3 w0.089: 101.98,6.72 101.23,5.97 99.13,5.97 98.65,5.48 95.72,5.48 95.43,5.2 95.37,5.17 94.49,5.17 94.02,5.64 91.55,5.64 91.26,5.93 89.94,5.93 89.31,5.3 88.03,5.3 87.59,5.74 86.34,5.74 85.84,6.24 85.04,6.24 84.65,5.85 83.18,5.85 83.13,5.9 79.17,5.9 78.71,5.44 76.74,5.44 76.69,5.39 75.06,5.39
  IN3 w0.091: 75.06,5.39 74.86,5.39 74.27,5.97 v2(73.69,5.97) ; v2(305.99,26.74) 305.39,26.13 304.67,26.13 303.97,25.43 300.69,25.43 298.61,23.35 294.85,23.35 294.31,22.8 291.61,22.8 290.63,21.82 288.8,21.82 286.66,19.68 285.08,19.68 281.67,16.27 272.53,16.27 270.23,13.97 266.83,13.97 263.65,10.8 214.31,10.8 213.87,11.24 204.28,11.24 203.33,10.29 199.9,10.29 198.32,11.86 198.32,12.62 198.14,12.81 193.06,12.81 192.12,11.87 189.76,11.87 188.77,10.88 187.87,10.88 186.69,9.69 184.24,9.69 183.8,9.25 179.75,9.25 179.07,9.93 175.15,9.93 174.67,10.4 171.52,10.4 170.76,11.16 164.14,11.16 163.68,10.7 156.41,10.7 156.13,10.42 151.16,10.42 151.07,10.32 148.97,10.32 148.37,10.92 140.84,10.92 140.02,10.1 139.26,10.1 138.43,10.92 135.26,10.92 134.64,11.54 130.85,11.54 129.68,12.72 121.56,12.72 118.33,9.49 115.56,9.49 114.68,8.61 114.68,7.42 114.33,7.07 108.84,7.07 108.28,7.63 106.33,7.63 106.32,7.62 105.81,7.62 105.32,7.12 102.39,7.12 101.98,6.72
  BOTTOM w0.089: UH2.BB47 75.79,6.73 75.32,6.73 75.17,6.58
  BOTTOM w0.14: v2(305.78,8.87) 306.31,9.41 306.31,11.9 305.46,12.75 305.46,15.39 306.01,15.94 306.01,18.61 306.56,19.15 306.56,25.81 305.99,26.37 v2(305.99,26.74) 305.88,26.85 RE322.1 ; 75.17,6.58 75.06,6.58 74.45,5.97 v2(73.69,5.97)
PCH_PECI: length 6.7
  BOTTOM w0.089: UH2.AF2 98.96,14.71 99.06,14.61 100.7,14.61 100.75,14.56 101.95,14.56 101.98,14.53 101.98,14.53
  BOTTOM w0.14: v1(103.63,13.44) RH5836.1 103.28,14.48 102.78,14.98 RH539.1 102.16,14.53 101.98,14.53
PCH_PLTRST#: length 33.2
  TOP w0.14: CH3327.1 64.53,5.64 64.64,5.53 v2(64.64,5.23) 64.64,5.06 64.16,4.59 64.16,4.09 v1(64.3,3.95)
  IN3 w0.089: v2(84.47,8.92) 84.47,9.55 83.78,10.24 80.09,10.24 79.76,9.9 79.1,9.9 78.99,10.02 76.39,10.02 75.31,11.1 73.3,11.1 73.28,11.08
  IN3 w0.091: v2(64.64,5.23) 64.61,5.23 64.5,5.34 64.5,5.65 66.64,7.79 67.14,7.79 68.32,8.97 69.47,8.97 69.85,8.59 71.53,8.59 72.18,9.24 72.18,10.2 72.45,10.47 72.67,10.47 73.28,11.08
  BOTTOM w0.089: UH2.AV29 84.71,9.22 84.47,8.98 v2(84.47,8.92)
  BOTTOM w0.14: v2(64.64,5.23) 64.64,5 66.33,3.3 UH7.1 67.64,3.3 67.77,3.18 67.77,2.78 67.64,2.65 UH7.2
PCH_PLTRST#_5105: length 13.3
  TOP w0.14: UE5.4 308.12,5.7 307.85,5.97 306.71,5.97 306.33,5.59 306.33,5.21 306.07,4.95 305.56,4.95 305.23,5.29 305.23,7.17 RE183.1 305.43,8.02 305.43,8.57 305.16,8.84 304.8,8.84 304.51,8.55 302.88,8.55 v1(302.74,8.69) 301.69,9.74 301.69,10.24 UE3.K1
PCH_PLTRST#_EC: length 633.9
  TOP w0.14: v2(230.52,45.11) 231.36,44.26 231.83,44.26 232.26,43.84 232.26,42.59 233.71,41.14 247.69,41.14 248.81,40.02 252.39,40.02 260.3,32.11 260.3,29.58 261.14,28.74 261.14,23.88 261.66,23.37 261.66,22.48 263.37,20.77 263.37,19.74 v2(263.35,19.72) 263.02,19.4 262.75,19.4 261.36,18 261.36,11.16 v1(261.06,10.86) 261.06,9.25 261.67,8.64 v2(261.67,7.3) ; v2(150.64,9.57) 150.71,9.5 U32.17 ; RE31.2 308.53,4.14 307.77,4.9 v2(307.49,4.9) 307.21,4.62 307.21,3.81 307.47,3.56 UE5.2 ; v2(209.21,46.94) 208.99,46.94 208.28,46.23 205.62,46.23 204.57,47.28 204.57,48.74 204.77,48.94 U33.8 ; RT1135.2 297.38,28.31 v2(297.67,28.02) ; v2(227.52,45.03) 227.27,44.77 UV19.2
  IN1 w0.099: v2(209.21,46.94) 210.76,45.39 212.32,45.39 213,44.71 216.81,44.71 217.04,44.48 219.26,44.48 220.12,45.34 222.2,45.34 223.06,44.48 226.98,44.48 v2(227.52,45.03)
  IN2 w0.099: v2(64.69,3.51) 64.67,3.53 64.66,3.53 63.45,4.75 63.26,4.75 61,7.01 61,9.56 61.04,9.6 61.04,10.04 61.62,10.63 61.62,11.74 60.97,12.4 60.97,13.63 61.62,14.27 61.62,16.3 61.53,16.38 61.53,18.13 61.02,18.63 59.5,18.63 59.22,18.92 59.22,20.08 58.83,20.47 58.83,21.24 59.02,21.43 59.02,22.64 v2(58.82,22.83) ; v2(307.49,4.9) 300.84,4.9 298.75,6.99 292.21,6.99 291.06,5.84 287.78,5.84 286.79,6.83 280.19,6.83 279.27,7.75 270.94,7.75 v2(270.43,7.24) 269.93,7.75 262.12,7.75 v2(261.67,7.3) 261.15,6.78 245.61,6.78 243.08,4.26 236.16,4.26 235.46,3.56 215.2,3.56 209.99,8.76 204.55,8.76 201.75,5.97 184.61,5.97 182.28,8.31 176.58,8.31 175.78,7.51 170.7,7.51 169.58,6.39 159.68,6.39 159.4,6.11 157.58,6.11 156.68,7.01 152.82,7.01 150.64,9.19 v2(150.64,9.57) ; v2(341.28,90.79) 341.87,90.2 341.87,88.72 342.47,88.13 342.47,86.52 340.62,84.67 338.75,84.67 334.44,80.37 334.44,67.13 339.57,62.01 339.81,62.01 340.77,61.04 340.77,51.81 345,47.57 345,44.49 v2(344.78,44.27) 344.78,42.61 344.17,42 344.17,36.1 343.26,35.19 v2(342.67,35.19)
  IN5 w0.089: 101.98,2.48 101.96,2.48 101.94,2.5 97.72,2.5 96.11,4.11 95.38,4.11 94.79,3.53 92.99,3.53 92.28,2.82 89.98,2.82 89.7,2.54 88.69,2.54 87.95,3.28 86.53,3.28 85.94,2.69 84.41,2.69 84.14,2.96 84.14,3.82 83.82,4.14 82.73,4.14 82.17,4.7 82.17,4.93 82.06,5.04 81.47,5.04 80.03,3.61 80.03,2.95 79.87,2.8 79.03,2.8 78.6,2.36 77.69,2.36 77.31,2.74 75.06,2.74
  IN5 w0.099: v2(64.69,3.51) 64.71,3.51 64.71,3.51 65.67,3.51 66.35,4.19 73.01,4.19 73.28,3.91 73.28,3.54 73.7,3.12 74.54,3.12 74.93,2.74 75.06,2.74 ; v2(342.67,35.19) 342.49,35.01 341.59,35.01 339.62,33.05 330.08,33.05 328.6,31.57 328.6,27.12 327.2,25.72 316.42,25.72 314.33,23.62 310.39,23.62 310.14,23.88 310.14,25.27 309.24,26.17 305.84,26.17 305.61,26.39 300.76,26.39 299.54,27.61 298.08,27.61 v2(297.67,28.02) 297.53,28.16 297.05,28.16 295.1,26.22 292.01,26.22 291.31,25.52 289.05,25.52 286.69,23.16 277.65,23.16 276.82,23.98 273.6,23.98 270.06,20.44 269.17,20.44 268.28,19.56 263.51,19.56 v2(263.35,19.72) ; 101.98,2.48 102.31,2.48 103.01,3.18 107.62,3.18 108,3.56 115.42,3.56 116.27,2.7 125.76,2.7 126.56,1.9 146.29,1.9 147.3,2.9 147.8,2.9 v2(148.27,2.44)
  IN6 w0.099: v2(227.52,45.03) 228.15,44.4 229.81,44.4 v2(230.52,45.11) ; v2(58.82,22.83) 58.82,23.07 58.63,23.27 56.69,23.27 56.32,23.64 52.12,23.64 51.09,24.67 49.23,24.67 49.02,24.88 46.01,24.88 45.19,24.05 42.85,24.05 39.91,21.11 33.26,21.11 32.62,20.47 30.85,20.47 28.68,22.64 27.67,22.64 25.5,24.81 21.43,24.81 18.13,28.12 18.13,29.28 16.9,30.51 16.9,32.41 17.33,32.85 17.33,34.19 16.51,35.01 16.51,35.46 16.94,35.89 16.94,36.55 16.07,37.42 16.07,40.97 16.64,41.54 16.64,46.04 v2(17.07,46.47)
  BOTTOM w0.14: v2(342.67,35.19) 342.54,35.06 341.53,35.06 341.38,35.2 UR1.1 ; v2(64.69,3.51) 64.69,3.51 64.69,2.7 64.36,2.38 RH77.1 64.29,2.11 64.97,2.11 65.07,2 UH7.4 ; v2(150.64,9.57) 150.64,8.55 150.06,7.98 150.06,5.24 149.63,4.81 149.63,3.8 v2(148.27,2.44) ; RR43.1 344.68,44.37 v2(344.78,44.27) ; JNGFF2.50 269.35,10.8 270.53,9.62 270.53,7.33 v2(270.43,7.24) ; v2(17.07,46.47) 16.51,47.03 RT435.1 ; JNGFF1.44 341.3,90.82 v2(341.28,90.79)
PCH_PLTRST#_EC_AR: length 101.5
  TOP w0.089: v2(88.39,6.22) 88.48,6.14 RT5857.2
  IN2 w0.089: 73.28,8.13 73.46,7.95 74.52,7.95 74.79,7.68 74.81,7.68 75.62,6.86 77.53,6.86 77.85,6.54 77.85,6.48 78.36,5.97 78.59,5.97 79.05,6.43 79.71,6.43 79.81,6.53 85.5,6.53 85.81,6.22 v2(88.39,6.22)
  IN2 w0.099: 73.28,8.13 72.9,8.51 72.41,8.51 71.77,9.15 71.77,10.21 70.85,11.12 69.66,11.12 67.67,13.11 67.67,13.98 67.18,14.46 67.18,15.43 67.37,15.62 v2(67.37,15.88)
  IN3 w0.089: 23.62,33.53 22.86,34.29 22.86,37.48 20.58,39.77
  IN3 w0.091: v2(67.37,15.88) 67.25,16 67.25,16.53 65.81,17.97 64.39,17.97 62.23,20.13 62.1,20.13 61.53,20.7 61.53,21.72 60.94,22.31 57.57,22.31 57.28,22.61 51.37,22.61 50.8,22.04 50.8,21.08 50.42,20.7 49.34,20.7 48.66,21.38 42.78,21.38 39.45,24.71 39.45,25.48 37.46,27.47 37.46,28.36 36.62,29.2 32.94,29.2 32.54,29.6 32.54,31.79 31.97,32.36 24.8,32.36 23.62,33.53 ; v2(17.09,45.83) 17.71,45.83 19.56,43.99 19.56,40.83 20.51,39.88 20.51,39.83 20.58,39.77
  BOTTOM w0.089: UH2.BE23 88.44,6.17 v2(88.39,6.22)
  BOTTOM w0.14: v2(17.09,45.83) 17,45.75 RT5855.1
PCH_PLTRST#_EC_R: length 4
  TOP w0.14: v1(297.95,29.22) RT1135.1 296.95,29.69 v2(296.67,29.97)
  BOTTOM w0.14: JLPDE1.8 296.06,30.59 v2(296.67,29.97)
PCH_PRIM_EN: length 247.8
  TOP w0.14: v2(244.91,11.98) 244.72,11.79 RZ1951.2 CZ2154.1 244.72,9.26 v1(244.1,8.64) 245.16,7.57 RH5871.1 247.14,7.63 RH5870.1
  IN3 w0.091: v2(248.95,108.78) 249.26,108.47 249.26,104.76 248.91,104.41 248.91,102.12 249.63,101.4 249.63,100.32 v2(250.09,99.86)
  IN6 w0.099: v2(244.91,11.98) 245.81,12.89 254.71,12.89 255.97,14.15 255.97,16.82 252.99,19.8 252.99,23.06 253.12,23.2 253.12,25.02 258.43,30.32 258.43,33.13 258.89,33.59 258.89,44.09 258.88,44.11 258.88,44.44 258.89,44.45 255.53,47.82 253.62,47.82 252.67,48.77 252.67,49.29 253.81,50.43 253.81,54.49 252.23,56.07 252.23,59.71 251.77,60.16 251.77,95.6 248.7,98.67 248.7,99.71 248.83,99.84 250.07,99.84 v2(250.09,99.86)
  BOTTOM w0.14: PR1602.1 249.76,108.17 249.15,108.78 v2(248.95,108.78) ; PR1950.1 138.28,1.16 150.86,1.16 152.39,2.68 204.08,2.68 205.6,1.16 219.09,1.16 227.46,9.53 227.46,14.35 228.86,15.75 243.21,15.75 244.91,14.05 v2(244.91,11.98)
PCH_PWROK: length 30.7
  TOP w0.089: v2(79.37,7.82) 79.77,7.82 v5(79.93,7.99)
  IN1 w0.076: 73.28,12.45 73.47,12.45 74.68,11.24 75.48,11.24 76.54,10.19 78.91,10.19 79.37,9.72 79.37,9.41 79.04,9.08 79.04,8.55 79.37,8.22 v2(79.37,7.82)
  IN1 w0.099: v2(69.52,7.01) 69.6,6.94 69.6,6.62 70.06,6.16 70.8,6.16 71.13,6.49 71.13,11.3 72.29,12.45 73.28,12.45
  BOTTOM w0.089: UH2.AY42 79.19,8 v2(79.37,7.82)
  BOTTOM w0.14: v2(69.52,7.01) 69.48,7.05 69.25,7.05 69.07,7.24 68.4,7.24 68.05,6.89 68.05,6.58 67.45,5.98 64.59,5.98 64.14,5.53 64.14,4.57 63.99,4.42 63.39,4.42 63.17,4.64 RH529.1 62.32,4.83 62.23,4.74 UH14.4
PCH_RSMRST#: length 282.7
  TOP w0.14: v1(310.41,5.89) 310.09,5.89 v2(309.92,6.07) ; v2(306.02,12.88) 305.65,12.88 305.28,13.25 304.03,13.25 303.94,13.34 303.4,13.34 302.97,13.77 UE3.M5
  IN3 w0.091: v2(306.02,12.88) 306.02,13.11 306.46,13.55 306.99,13.55 308.05,14.61 311.15,14.61 312.13,13.63 312.13,11.61 312.79,10.95 312.79,9.2 309.92,6.33 v2(309.92,6.07) 309.75,6.23 308.76,6.23 308.16,5.63 308.16,4.71 307.93,4.47 307.32,4.47 306.93,4.08 301.77,4.08 301.29,3.6 294.83,3.6 294.36,4.07 289.25,4.07 288.63,3.44 280.6,3.44 279.95,4.09 274.06,4.09 273.87,3.9 273.12,3.9 272.72,4.29 267.81,4.29 266.85,5.25 263.48,5.25 262.55,4.32 259.02,4.32 258.64,4.7 252.05,4.7 251.57,5.18 240.52,5.18 239.27,3.94 214.25,3.94 210.43,7.76 206.36,7.76 205.18,6.58 205.18,5.07 204.63,4.52 198.41,4.52 197.95,4.07 184.68,4.07 183.91,4.84 182.81,4.84 182.58,4.6 177.42,4.6 177.1,4.27 173.96,4.27 173.18,3.5 168.59,3.5 167.42,4.67 165.29,4.67 164.85,4.23 v2(164.85,3.97)
  IN6 w0.089: 98.78,1.91 97.28,3.42 95.99,3.42 95.89,3.32 93.3,3.32 92.92,2.95 ; 73.38,7.67 73.53,7.82 75.06,7.82 75.58,7.3 75.58,6.08
  IN6 w0.099: 92.92,2.95 92.39,2.42 88.83,2.42 88.17,3.07 86.13,3.07 85.69,2.64 83.34,2.64 82.61,3.37 82.61,4.33 82.31,4.64 82.31,4.81 82.04,5.08 78.64,5.08 78.03,4.47 77.19,4.47 75.58,6.08 ; 98.78,1.91 110.3,1.91 111.01,2.63 115.14,2.63 115.48,2.29 116.59,2.29 116.97,2.67 124.57,2.67 125.33,1.91 133.25,1.91 134.97,3.63 134.97,6.94 135.59,7.56 137.6,7.56 138.23,8.19 140.23,8.19 140.55,7.88 144.79,7.88 147.86,4.8 148.32,4.8 149.09,4.03 150.52,4.03 151.13,4.64 156.92,4.64 157.6,3.95 161.55,3.95 162.15,4.55 164.26,4.55 v2(164.85,3.97) ; 73.38,7.67 72.67,7.67 v2(72.44,7.9)
  BOTTOM w0.14: v2(72.44,7.9) 72.43,7.9 72,8.33 RT1136.1
PCH_RSMRST#_EC: length 366.9
  TOP w0.14: RH5859.1 68.97,7.62 69.38,8.03 70.02,8.03 70.17,8.18 v2(70.21,8.18) ; v1(274.7,13.59) v2(275.72,12.57) ; RH481.1 v2(131.12,93.24)
  IN2 w0.099: v2(62.28,19.1) 62.49,18.9 62.49,18.11 63.13,17.46 63.13,17.13 62.42,16.41 62.42,14.4 62.92,13.9 62.92,11.43 66.64,7.71 67.1,7.71 68.37,8.98 69.32,8.98 70.13,8.18 v2(70.21,8.18)
  IN3 w0.091: v2(100.6,45.6) 102.42,45.6 103.87,47.05 103.87,48.94 107.69,52.77 107.69,53.37 108.62,54.3 110.32,54.3 111.31,55.29 114.54,55.29 117.21,57.96 117.21,62.96 121.56,67.31 121.56,69.42 123.88,71.74 123.88,85.04 128.58,89.74 128.58,92.13 129.69,93.24 v2(131.12,93.24)
  IN4 w0.091: v2(100.6,45.6) 100.55,45.56 100.55,41.28 98.51,39.23 98.51,37.89 93.26,32.64 85.77,32.64 85.52,32.39 79.26,32.39 78.97,32.68 76.01,32.68 68.67,25.34 66.49,25.34 65.92,24.77 65.92,21.61 64.44,20.13 63.31,20.13 v2(62.28,19.1)
  IN5 w0.089: 73.28,12.67 77.37,8.58 77.8,8.58 78.05,8.83 78.57,8.83 79.02,8.37 79.96,8.37 80.36,8.77 80.36,9.05 80.6,9.29 81.19,9.29 81.47,9.57 84.35,9.57 84.86,9.07 84.86,8.35 85.13,8.07 86.33,8.07 86.66,8.41 89.07,8.41 90.12,7.36 90.63,7.36 91.13,7.86 91.13,8.15 91.48,8.5 94.81,8.5 94.98,8.33 96.19,8.33 96.79,8.93 97.61,8.93 98.34,8.2 101.34,8.2 101.87,7.67 101.98,7.67
  IN5 w0.099: v2(70.21,8.18) 70.21,8.18 71.21,9.18 71.21,11.68 72.25,12.72 73.23,12.72 73.28,12.67 ; 101.98,7.67 104.34,7.67 105.4,6.62 108.5,6.62 110.97,9.09 111.91,9.09 112.49,8.51 113.89,8.51 115.16,9.78 117.73,9.78 118.43,10.48 122.02,10.48 122.6,11.06 124.41,11.06 125.32,11.97 132.23,11.97 133.03,11.18 137.58,11.18 137.96,11.55 148,11.55 148.99,12.54 157.26,12.54 158.24,11.56 164.79,11.56 165.04,11.81 183.56,11.81 186.82,15.06 201.89,15.06 201.89,15.06 214.17,15.06 215.16,14.07 225.63,14.07 226.22,13.48 247.14,13.48 249.12,11.51 262.72,11.51 263.24,12.03 265.4,12.03 266.22,11.21 268.76,11.21 268.83,11.15 272.33,11.15 272.92,11.75 272.92,12 274,13.08 275.21,13.08 v2(275.72,12.57)
  BOTTOM w0.14: RH133.1 RT1136.2 70.37,8.33 v2(70.21,8.18)
PCH_RSMRST#_R: length 6.2
  BOTTOM w0.089: 73.28,8.04 73.57,8.04 73.74,7.88 75.5,7.88 75.73,7.65 76.1,7.65 UH2.BA47
  BOTTOM w0.14: 73.28,8.04 73.27,8.04 72.58,7.35 72,7.35 RH133.2 71.81,7.34 RH5841.2
PCH_RTCRST#: length 128.8
  TOP w0.089: v2(76.07,6.16) 75.45,6.16 CH53.1 76.01,5.58 76.01,4.8 76.23,4.59 76.23,3.49 75.35,2.62 75.06,2.62
  TOP w0.14: v2(68.3,3.15) 67.9,2.74 67.9,2.57 67.64,2.31 v5(67.64,1.86) 67.64,1.58 67.96,1.26 75.27,1.26 75.39,1.38 75.39,2.14 75.08,2.45 RH84.2 74.93,2.52 75.03,2.62 75.06,2.62 ; v2(174.18,10.86) 174.12,10.8 RT1133.1
  IN3 w0.089: v2(76.07,6.16) 76.07,6.68 76.25,6.86 78.75,6.86 79.35,6.25 83.28,6.25 83.33,6.2 84.5,6.2 84.89,6.6 85.98,6.6 86.49,6.09 87.74,6.09 88.18,5.66 89.17,5.66 89.79,6.29 91.4,6.29 91.69,6 94.17,6 94.64,5.53 95.26,5.53 95.57,5.84 98.5,5.84 99.06,6.4 99.94,6.4 100.6,7.06 101.18,7.06 101.94,7.81 101.98,7.81
  IN3 w0.091: v2(174.18,10.86) 173.37,11.67 163.82,11.67 163.24,11.09 156.2,11.09 156.03,10.92 151.1,10.92 150.9,10.72 149.13,10.72 148.61,11.24 140.72,11.24 139.96,10.48 139.45,10.48 138.69,11.24 135.64,11.24 134.94,11.94 131.02,11.94 129.84,13.12 121.39,13.12 118.16,9.88 115.39,9.88 113.73,8.23 112.25,8.23 111.76,8.71 110.9,8.71 110.5,8.32 105.35,8.32 104.85,7.81 101.98,7.81
  BOTTOM w0.089: v2(76.07,6.16) 76.39,5.84 UH2.BE47
  BOTTOM w0.14: JAPS.9 174.62,9.02 174.18,9.47 v2(174.18,10.86) ; v2(68.3,3.15) 68.31,3.16 68.31,3.78 67.67,4.42 CLRP1.1
