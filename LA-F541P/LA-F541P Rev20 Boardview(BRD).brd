# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RUN_ON_EC_GATE: length 26.2
  TOP w0.14: RZ59.2 113.95,54.8 114.61,54.14 114.61,53.29 113.75,52.44 v2(113.6,52.44) 111.82,52.44 111.37,51.98 UZ20.4 ; RZ58.1 107.89,44.1 108.67,43.31 v1(114.95,43.31) 115.51,43.31 v2(115.63,43.44)
  IN5 w0.099: v2(115.63,43.44) 115.63,46.61 113.79,48.45 113.79,52.25 v2(113.6,52.44)
RUN_ON_P: length 245.2
  TOP w0.14: UZ26.1 108.52,47.91 107.89,47.28 v1(107.89,47.25) RZ58.2 ; v2(284.91,25.04) 284.91,27.52 285.18,27.79 285.8,27.79 286.25,27.34 286.65,27.34 287.69,28.39 288.01,28.39 289.38,29.75 289.38,31.47 289.9,31.99 PR610.2 ; RZ58.2 107.71,45.99 107,45.27 107,44.55 108.48,43.07 114.12,43.07 114.34,42.84 115.89,42.84 v2(116.46,43.41) ; RZ58.2 RZ50.1 ; v2(104.06,61.01) 104.06,60.78 103.54,60.26 103.54,51.49 103.32,51.27 103.32,48.46 v2(103.03,48.17)
  IN1 w0.099: v2(116.46,43.41) 116.46,42.89 120.89,38.45 121.33,38.45 121.49,38.61 v2(121.74,38.61)
  IN2 w0.099: v2(103.03,48.17) 106.24,44.96 114.81,44.96 116.36,43.41 v2(116.46,43.41) ; v2(284.91,25.04) 284.91,23.98 280.21,19.28 277.31,19.28 275.53,21.06 265.15,21.06 264.67,20.58 263.4,20.58 262.59,19.77 261.41,19.77 261.08,20.1 256.7,20.1 255.91,19.31 254.93,19.31 253.79,20.45 248.6,20.45 248.16,20.89 232.16,20.89 230.82,19.56 215.16,19.56 214.58,20.14 185.92,20.14 184.32,18.54 178.28,18.54 177.99,18.84 174.81,18.84 173.49,20.16 158.51,20.16 157.5,21.16 153.41,21.16 152.58,21.99 152.58,26.47 150.34,28.7 146.21,28.7 145.27,29.65 145.27,30.58 139.08,36.76 123.59,36.76 v2(121.74,38.61)
  BOTTOM w0.14: v2(104.06,61.01) PR1951.1
RUNPWROK: length 265
  TOP w0.076: UE3.G3 298.96,11.77 299.24,11.49 299.24,11.14 v2(299.4,10.98)
  TOP w0.14: v2(290.01,7.43) 290.02,7.41 290.02,7.22 287.88,5.08 RE52.2 ; v2(288.18,4.09) 288.18,4.74 RE52.2 ; QE4.3 286.97,5.08 RE52.2
  IN5 w0.089: 101.98,2.68 97.79,2.68 95.99,4.49 95.5,4.49 95.01,4 91.81,4 91.48,3.67 90.84,3.67 90.58,3.93 90.58,4.14 90.37,4.34 89.84,4.34 89.71,4.47 87.95,4.47 87.8,4.62 86.06,4.62 85.66,5.02 83.86,5.02 83.77,5.11 82.27,5.11 82.14,5.23 ; 75.06,2.96 77.33,2.96 77.58,3.2 78.18,3.2 80.21,5.23 81.66,5.23
  IN5 w0.099: v2(59.08,4.26) 59.17,4.17 60.36,4.17 61.41,5.22 63.56,5.22 64.25,5.91 64.93,5.91 66.39,4.44 68.68,4.44 68.74,4.39 73.58,4.39 75.01,2.96 75.06,2.96 ; 82.14,5.23 81.66,5.23 ; 101.98,2.68 102.23,2.68 102.93,3.38 107.27,3.38 107.65,3.76 116.92,3.76 117.73,2.96 125.81,2.96 126.62,2.14 130.98,2.14 131.6,2.77 135.49,2.77 135.98,3.25 139.79,3.25 140.7,2.34 146.16,2.34 147.2,3.37 148.95,3.37 149.34,3.76 162.08,3.76 163.17,4.85 167.57,4.85 168.6,3.82 177.81,3.82 178.24,4.25 181.94,4.25 182.73,5.04 184,5.04 184.94,4.1 195.55,4.1 198.4,6.95 204.13,6.95 205.8,8.62 210.1,8.62 214.61,4.1 242.81,4.1 244.97,6.26 257.07,6.26 258.08,5.25 263.39,5.25 263.92,5.77 267.7,5.77 268.91,4.57 270.29,4.57 270.95,5.23 274.01,5.23 274.9,4.34 280.1,4.34 280.25,4.19 283.12,4.19 283.54,3.77 284.38,3.77 284.96,4.36 284.97,4.42 285.08,4.54 287.83,4.54 288.18,4.19 v2(288.18,4.09)
  IN6 w0.099: v2(299.4,10.98) 299.59,10.79 299.59,9.4 299.38,9.19 298.32,9.19 297.14,8.02 290.86,8.02 290.45,7.6 290.18,7.6 v2(290.01,7.43)
  BOTTOM w0.14: UH14.2 59.24,4.09 59.08,4.24 v2(59.08,4.26)
S5_1.2V: length 5.6
  TOP w0.14: v5(293.83,29.01) 292.55,29.01 PC613.1
  TOP w0.254: v2(291.14,29.62) 291.2,29.69 291.8,29.69 PC613.1
  BOTTOM w0.203: PU600.8 290.44,30.14 290.95,29.62 v2(291.14,29.62) 291.79,28.97 PR606.2
SATA_PRX_C_DTX_N2: length 1.7
  BOTTOM w0.152: JHDD.8 234.86,11.76 234.94,11.84 234.94,12.48 CS20.2
SATA_PRX_C_DTX_P2: length 1.7
  BOTTOM w0.152: CS19.2 235.28,12.48 235.28,11.72 235.36,11.63 JHDD.9
SATA_PRX_DTX_N1A: length 199.8
  IN1 w0.107: v2(259.14,12.85) 259.14,12.21 258.89,11.96 253.44,11.96 252.24,13.16 247.49,13.16 246.81,13.84 242.09,13.84 241.51,14.42 238.45,14.42 237.81,15.06 231.95,15.06 231.18,14.29 157.02,14.29 156.12,15.19 155.09,15.19 151.4,18.87 146.84,18.87 145.88,19.83 140.8,19.83 138.89,21.74 138.89,25.5 138.05,26.34 136.78,26.34 135.18,27.94 110.52,27.94 108.92,29.54 103.32,29.54 102.49,28.7 97.61,28.7 97.06,29.25 94.78,29.25 94.2,28.66 94.2,28.36 91.34,25.5 90.16,25.5 89.84,25.18 89.84,23.57 87.5,21.24 81.9,21.24 81.22,21.91 80.34,21.91 79.27,22.98 79.27,23.96 v2(79.11,24.12)
  BOTTOM w0.089: v2(79.11,24.12) 79.11,23.92 78.98,23.8 UH2.H42
  BOTTOM w0.152: v2(259.14,12.85) 259.45,12.54 JNGFF2.43
SATA_PRX_DTX_N2: length 176.8
  IN1 w0.076: 101.84,21.36 101.82,21.35 101.82,21.33 101.22,20.72 98.39,20.72 96.61,22.51 94.84,22.51 94.11,21.78 94.11,21.03 93.42,20.33 89.19,20.33 88.93,20.07 85.18,20.07 84.72,19.6 83.43,19.6 83.13,19.3 80.83,19.3 80.55,19.58 78.34,19.58 76.71,21.21 76.71,24.2 76.83,24.32 77.34,24.32 77.47,24.45 v2(77.47,24.7)
  IN1 w0.107: v2(235.13,14) 235.3,14 235.46,13.84 235.46,13.5 235.22,13.26 221,13.26 218.1,10.36 214.81,10.36 213.03,12.14 204.9,12.14 204.07,11.31 178.38,11.31 177.35,12.35 163.96,12.35 163.37,11.76 160.32,11.76 159.81,12.27 156.42,12.27 155.71,12.98 154.97,12.98 151.62,16.34 140.36,16.34 138.85,17.84 134.16,17.84 133.78,18.22 133.78,18.66 131.75,20.69 107.31,20.69 106.18,21.81 102.29,21.81 101.84,21.36
  BOTTOM w0.089: v2(77.47,24.7) 77.59,24.82 77.95,24.82 UH2.F44
  BOTTOM w0.152: v2(235.13,14) 235.26,13.87 235.26,13.78 235.01,13.53 235.01,13.3 234.93,13.22 CS20.1
SATA_PRX_DTX_P1A: length 199.8
  IN1 w0.107: v2(258.56,12.85) 258.94,12.47 258.94,12.3 258.8,12.16 253.52,12.16 252.33,13.36 247.57,13.36 246.9,14.04 242.17,14.04 241.59,14.62 238.54,14.62 237.89,15.26 231.86,15.26 231.09,14.49 157.1,14.49 156.2,15.39 155.17,15.39 151.49,19.08 146.92,19.08 145.97,20.03 140.89,20.03 139.09,21.83 139.09,25.59 138.13,26.54 136.86,26.54 135.27,28.14 110.61,28.14 109.01,29.74 103.24,29.74 102.41,28.91 97.69,28.91 97.15,29.45 94.7,29.45 93.99,28.75 93.99,28.44 91.26,25.71 90.08,25.71 89.63,25.26 89.63,23.65 87.42,21.44 81.99,21.44 81.31,22.12 80.43,22.12 79.47,23.07 79.47,23.77 v2(79.66,23.95)
  BOTTOM w0.089: v2(79.66,23.95) 79.43,23.72 UH2.J41
  BOTTOM w0.152: v2(258.56,12.85) 258.56,12.89 259.01,13.34 259.32,13.34 259.61,13.04 JNGFF2.41
SATA_PRX_DTX_P2: length 176.8
  IN1 w0.076: v2(76.92,24.81) 76.92,24.66 76.54,24.28 76.54,21.14 78.27,19.41 80.48,19.41 80.76,19.12 83.2,19.12 83.5,19.42 84.79,19.42 85.26,19.89 89,19.89 89.26,20.16 93.49,20.16 94.28,20.95 94.28,21.71 94.91,22.34 96.53,22.34 98.32,20.55 101.29,20.55 101.95,21.21 101.97,21.21 101.98,21.22
  IN1 w0.107: v2(235.84,14) 235.66,13.82 235.66,13.41 235.31,13.06 221.08,13.06 218.19,10.16 214.72,10.16 212.95,11.94 204.99,11.94 204.15,11.11 178.3,11.11 177.27,12.14 164.04,12.14 163.46,11.56 160.24,11.56 159.73,12.07 156.34,12.07 155.62,12.78 154.89,12.78 151.53,16.13 140.27,16.13 138.77,17.64 134.07,17.64 133.58,18.14 133.58,18.57 131.67,20.48 107.22,20.48 106.09,21.61 102.37,21.61 101.98,21.22
  BOTTOM w0.089: UH2.E45 77.26,25.15 v2(76.92,24.81)
  BOTTOM w0.152: CS19.1 235.34,13.3 235.34,13.39 235.59,13.64 235.59,13.76 v2(235.84,14)
SATA_PTX_C_DRX_N1A: length 3
  BOTTOM w0.152: CD37.2 257.86,11.44 259.44,11.44 259.55,11.54 JNGFF2.47
SATA_PTX_C_DRX_N2: length 1.7
  BOTTOM w0.152: JHDD.6 233.86,11.8 233.78,11.88 233.78,12.5 CS18.2
SATA_PTX_C_DRX_P1A: length 3
  BOTTOM w0.152: JNGFF2.49 259.71,11.04 259.62,11.13 v3(258.59,11.13) 257.94,11.13 CD42.2
SATA_PTX_C_DRX_P2: length 1.8
  BOTTOM w0.152: CS17.2 233.45,12.46 233.45,11.88 233.36,11.8 JHDD.5
SATA_PTX_DRX_N1A: length 208.1
  IN1 w0.107: v2(80.81,25.11) 80.81,25.31 80.74,25.38 80.54,25.38 80.39,25.24 80.39,24.96 80.25,24.82 80.18,24.82 80.17,24.82 80.03,24.95 80.03,25.05 80.26,25.59 79.71,26.93 79.71,28.18 79.91,28.66 80.1,29.05 80.4,29.17 83.93,29.17 84.3,29.33 85.92,29.33 87.47,30.87 89.47,31.7 91.21,33.44 92,33.77 92.57,34.05 93.24,34.72 96.83,34.72 99.11,37 100.29,37.8 101.27,38.2 104.74,38.2 106.62,37.42 116.8,37.42 118.92,36.55 119.08,36.38 121.61,35.34 139.46,35.34 146.19,28.61 147,28.27 153.32,28.27 154.76,26.82 156.84,26.82 157.7,25.96 158.17,24.84 158.17,21.77 158.53,21.4 160.61,20.55 173.27,20.55 174.15,20.91 182.3,20.91 183.72,20.32 185.58,20.32 186,20.5 250.28,20.5 250.81,21.02 251.78,21.02 252.31,20.5 254.78,20.5 255.26,20.02 v2(255.42,20.02)
  BOTTOM w0.089: v2(80.81,25.11) 80.85,25.15 80.85,25.53 UH2.D38
  BOTTOM w0.152: CD37.1 256.69,12 256.57,12.12 256.15,12.12 256,11.97 256,11.52 255.89,11.42 255.42,11.42 253.8,13.04 253.8,14.66 252.88,15.57 252.88,16.87 253.65,17.64 253.65,19.16 254.74,20.26 254.92,20.26 255.16,20.02 v2(255.42,20.02)
SATA_PTX_DRX_N2: length 168.4
  IN3 w0.089: 101.98,24.09 101.98,24.09 101.91,24.09 101.88,24.12 101.26,24.73 100.02,24.73 99.18,23.89 99.18,23.23 97.67,21.73 96.02,21.73 95.56,21.26 95.56,20.92 95.29,20.65 94.47,20.65 93.83,21.28 92.01,21.28 91.46,21.84 91.46,22.25 91.1,22.61 90.59,22.61 88.47,24.73 88.47,25.96 88.14,26.29 86.14,26.29 85.62,25.77 81.96,25.77 81.54,26.18 81.05,26.18 80.58,26.65 80.58,26.71 80.28,27.01 v2(80.14,27.01)
  IN3 w0.099: v2(233.89,14.03) 233.7,13.83 233.7,13.61 233.36,13.27 204.47,13.27 204.13,13.61 200.74,13.61 199.93,14.43 179.86,14.43 179.39,13.96 151.81,13.96 151.66,14.1 139.89,14.1 139.07,14.92 138.32,14.92 138.13,15.11 127.08,15.11 126.53,15.66 125.03,15.66 124.56,15.19 122.87,15.19 122.26,15.81 121.6,15.81 120.32,17.09 114.94,17.09 114.02,18.01 114.02,18.93 112.92,20.04 109.23,20.04 108.31,20.97 107.34,20.97 106.55,21.76 104.31,21.76 101.98,24.09
  BOTTOM w0.089: UH2.B40 80.24,26.5 80.38,26.64 80.38,26.92 80.29,27.01 v2(80.14,27.01)
  BOTTOM w0.152: v2(233.89,14.03) 233.78,13.91 233.78,13.34 CS18.1
SATA_PTX_DRX_P1A: length 208.2
  IN1 w0.107: v2(81.1,24.61) 80.13,24.61 80.05,24.65 79.83,24.87 79.83,25.09 80.04,25.59 79.5,26.89 79.5,28.22 79.72,28.75 79.95,29.21 80.36,29.38 83.89,29.38 84.26,29.53 85.84,29.53 87.36,31.04 89.36,31.87 91.1,33.61 91.92,33.95 92.45,34.22 93.16,34.93 96.74,34.93 98.98,37.16 100.2,37.98 101.23,38.41 104.78,38.41 106.66,37.63 116.85,37.63 119.04,36.72 119.2,36.56 121.65,35.54 139.54,35.54 146.31,28.78 147.04,28.47 153.4,28.47 154.85,27.03 156.92,27.03 157.88,26.07 158.37,24.88 158.37,21.85 158.65,21.58 160.65,20.75 173.23,20.75 174.11,21.12 182.34,21.12 183.76,20.52 185.54,20.52 185.96,20.7 250.2,20.7 250.72,21.23 251.87,21.23 252.39,20.7 255.17,20.7 v2(255.28,20.59)
  BOTTOM w0.089: v2(81.1,24.61) 81.25,24.76 UH2.E37
  BOTTOM w0.152: v2(255.28,20.59) 255.28,20.59 254.61,20.59 253.32,19.3 253.32,17.77 252.55,17.01 252.55,15.43 253.47,14.52 253.47,12.9 v3(254.02,12.34) 255.28,11.09 256.4,11.09 CD42.1
SATA_PTX_DRX_P2: length 168.3
  IN3 w0.089: 101.98,24.28 101.96,24.3 101.95,24.3 101.34,24.91 99.95,24.91 99,23.96 99,23.31 97.6,21.91 95.95,21.91 95.38,21.34 95.38,20.99 95.21,20.83 94.54,20.83 93.91,21.46 92.09,21.46 91.64,21.91 91.64,22.33 91.18,22.79 90.66,22.79 88.65,24.8 88.65,26.04 88.21,26.47 86.07,26.47 85.54,25.95 82.03,25.95 81.62,26.36 81.12,26.36 80.76,26.72 80.76,27.06 v2(80.73,27.08)
  IN3 w0.099: 101.98,24.28 102.06,24.28 104.39,21.95 106.63,21.95 107.42,21.16 108.38,21.16 109.31,20.23 113,20.23 114.21,19.01 114.21,18.09 115.02,17.28 120.4,17.28 121.68,16 122.34,16 122.95,15.38 124.48,15.38 124.95,15.85 126.61,15.85 127.16,15.3 138.21,15.3 138.4,15.11 139.15,15.11 139.97,14.29 151.74,14.29 151.88,14.15 179.31,14.15 179.78,14.62 200.01,14.62 200.82,13.8 204.21,13.8 204.55,13.46 233.28,13.46 233.51,13.68 233.51,13.83 v2(233.31,14.03)
  BOTTOM w0.089: v2(80.73,27.08) 80.73,26.86 80.65,26.77 80.65,26.53 80.07,25.96 UH2.C40
  BOTTOM w0.152: CS17.1 233.45,13.4 233.45,13.89 v2(233.31,14.03)
SATAGP0: length 1.4
  TOP w0.089: RH5844.1 79.19,13.72 v2(78.94,13.97)
  BOTTOM w0.089: UH2.AH41 79.21,13.7 v2(78.94,13.97)
SATAGP3: length 5.1
  BOTTOM w0.089: 73.28,12.45 73.28,12.41 73.52,12.17 74,12.17 74.68,11.48 74.84,11.48 75.12,11.2 76.5,11.2 UH2.AN47
  BOTTOM w0.14: 73.28,12.45 72.54,12.45 72.26,12.73 RH5845.1
SATAGP4: length 5.6
  BOTTOM w0.089: UH2.AM46 76.61,11.56 76.29,11.56 76.16,11.43 75.14,11.43 74.91,11.66 74.76,11.66 74.04,12.37 73.84,12.37 73.36,12.85 73.28,12.85
  BOTTOM w0.14: 73.28,12.85 72.77,12.85 RH5846.1
SATAGP5: length 2.7
  TOP w0.089: RH5847.1 80.14,12.36 v1(79.6,12.36) 79.25,12.36 v2(78.84,12.77)
  BOTTOM w0.089: v2(78.84,12.77) 78.84,12.28 UH2.AM43
SATAGP6: length 5.2
  BOTTOM w0.089: UH2.AM47 76.28,11.8 76.08,11.6 75.47,11.6 75.24,11.84 74.83,11.84 74.12,12.55 73.92,12.55 73.28,13.18
  BOTTOM w0.14: 73.28,13.18 73.15,13.18 72.43,13.91 RH5848.1
SATALED#: length 6.3
  BOTTOM w0.089: 73.59,15.39 73.66,15.32 73.66,15.15 75.06,13.75 75.48,13.75 76.05,13.17 UH2.AK48
  BOTTOM w0.14: RH512.1 71.59,16.23 v1(72.18,16.23) 72.75,16.23 73.59,15.39
SBIOS_TX: length 270.2
  TOP w0.14: v2(314.11,25.31) 314.11,25.87 313.06,26.93 309.44,26.93 308.04,25.53 RE297.2 ; v2(314.35,9.89) v1(314.89,9.89)
  IN6 w0.089: v2(88.71,7.49) 88.31,7.49 88.12,7.69 88.12,8.28 89.27,9.44 90.65,9.44 90.97,9.12 91.72,9.12 92.59,9.98 94.77,9.98 94.92,9.84 95.28,9.84 95.78,10.34 96.73,10.34 97.52,9.55 98.76,9.55 99.48,8.83 101.07,8.83 101.14,8.91 101.98,8.91
  IN6 w0.099: v2(314.35,9.89) 314.29,9.83 310.41,9.83 309.23,8.65 307.82,8.65 306.33,10.14 305.03,10.14 303.26,8.37 298.64,8.37 297.48,7.21 292.15,7.21 290.98,6.04 288.07,6.04 287.33,6.78 280.9,6.78 280.71,6.58 279.95,6.58 278.54,8 273.69,8 271.67,10.01 265.71,10.01 264.32,8.63 257.31,8.63 256.67,9.27 240.16,9.27 239.9,9.02 226.19,9.02 222.15,13.06 194.87,13.06 192.92,11.11 185.14,11.11 184.9,11.35 164.56,11.35 163.35,10.14 157.89,10.14 157.33,9.58 156.35,9.58 156.11,9.82 152.36,9.82 151.63,9.09 149.39,9.09 147.78,10.71 143.01,10.71 141.95,11.76 138.89,11.76 137.8,12.85 123.25,12.85 121.52,11.11 119.23,11.11 118.1,9.98 115.11,9.98 113.34,8.21 112.35,8.21 111.71,8.84 110.8,8.84 110.25,9.39 106.63,9.39 105.49,8.25 103.84,8.25 103.19,8.91 101.98,8.91
  BOTTOM w0.089: v2(88.71,7.49) 88.65,7.56 88.36,7.56 UH2.BB24
  BOTTOM w0.14: v2(314.35,9.89) 314.15,10.09 314.15,15.72 313.19,16.69 313.19,18.31 313.59,18.71 313.59,20.66 314.71,21.78 314.71,24.71 v2(314.11,25.31)
SD_1P8_RCOMP: length 9
  BOTTOM w0.089: 101.98,3.78 100.42,3.78 99.89,3.26 99.89,3.23 99.41,2.74 97.66,2.74 96.57,3.83 96.57,4.27 96.38,4.46 96.38,5.19 96.87,5.69 UH2.BE5
  BOTTOM w0.14: 101.98,3.78 102.01,3.78 RH5832.1
SD_3P3_RCOMP: length 8.6
  BOTTOM w0.089: 101.98,4.19 101.75,3.96 100.34,3.96 99.71,3.33 99.71,3.3 99.33,2.92 97.74,2.92 97.69,2.97 97.68,2.97 96.75,3.9 96.75,4.24 96.9,4.4 96.9,4.9 96.93,4.93 96.93,5.23 97.1,5.4 97.33,5.4 97.34,5.41 UH2.BE4
  BOTTOM w0.14: 101.98,4.19 RH5833.1
SD_CD#: length 21.7
  TOP w0.14: v2(335.53,44.24) 335.29,44 JCR.8
  IN4 w0.091: v2(335.53,44.24) 335.77,44.24 337.72,42.28 337.72,41.14 339.13,39.73 342.86,39.73 343.22,39.38 343.22,38.91 343.11,38.8 342.67,38.8 342.56,38.69 342.56,38.54 342.67,38.44 343.11,38.44 343.22,38.33 343.22,38.18 343.11,38.07 342.67,38.07 342.56,37.96 342.56,37.81 342.67,37.7 343.11,37.7 343.22,37.6 v2(343.22,36.78)
  BOTTOM w0.14: UR1.30 342.48,36.99 342.69,36.78 v2(343.22,36.78)
SD_CLK: length 18.4
  TOP w0.14: v2(331.59,47.18) 331.2,46.8 JCR.6
  IN4 w0.091: v2(331.59,47.18) 331.95,47.18 332.05,47.08 332.05,45.9 332.15,45.8 332.31,45.8 332.42,45.91 332.42,47.32 332.52,47.42 332.74,47.42 332.83,47.33 332.83,46.29 332.94,46.18 333.09,46.18 333.36,46.45 333.51,46.45 334.29,45.67 334.44,45.67 335.09,46.31 335.24,46.31 335.35,46.21 335.35,46.06 334.7,45.41 334.7,45.29 334.81,45.19 335.84,45.19 335.95,45.08 335.95,44.92 335.84,44.82 334.81,44.82 334.7,44.71 334.7,44.1 334.81,43.99 335.08,43.99 335.19,43.88 335.19,43.73 335.08,43.62 334.81,43.62 334.7,43.52 334.7,43.23 334.87,43.05 v2(335.15,43.05)
  BOTTOM w0.14: RR4.2 CR8.1 v2(335.15,43.05)
SD_CLK_R: length 3.7
  BOTTOM w0.14: RR4.1 336.11,40.82 v1(336.53,40.4) 336.65,40.27 338.3,40.27 338.58,39.99 UR1.17
SD_CMD: length 20.4
  TOP w0.14: v1(328.48,53.75) JCR.3 331.44,53.75 v2(331.73,53.46)
  IN4 w0.091: v2(338.19,43.84) 337.88,43.84 335.94,45.78 335.94,46.34 334.41,47.87 334.26,47.87 333.99,47.61 333.84,47.61 333.73,47.72 333.73,47.87 334,48.13 334,48.28 333.89,48.39 333.74,48.39 333.47,48.13 333.32,48.13 333.22,48.24 333.22,48.39 333.48,48.65 333.48,48.8 333.12,49.16 333.12,49.31 333.3,49.49 333.3,49.64 333.19,49.75 333.04,49.75 332.86,49.57 332.71,49.57 332.39,49.89 332.39,51.2 332.28,51.31 331.72,51.31 331.61,51.41 331.61,51.57 331.72,51.67 332.28,51.67 332.39,51.78 332.39,52.8 v2(331.73,53.46)
  BOTTOM w0.14: RR5.2 v2(338.19,43.84)
SD_CMD_R: length 3
  BOTTOM w0.14: RR5.1 338.71,41.73 339.38,41.06 UR1.19
SD_D2: length 21.3
  TOP w0.14: v1(328.47,56.55) JCR.1 330.76,56.55 v2(331.79,55.52)
  IN4 w0.091: v2(331.79,55.52) 332.24,55.08 332.24,54.63 336.02,50.85 336.02,48.35 338.71,45.66 338.71,45.51 338.45,45.25 338.45,45.1 338.56,44.99 338.71,44.99 338.96,45.25 339.12,45.25 339.22,45.14 339.22,44.99 338.97,44.73 338.97,44.58 339.08,44.48 339.23,44.48 339.48,44.73 339.63,44.73 340.2,44.16 v2(340.2,43.94)
  BOTTOM w0.14: v2(340.2,43.94) 340.2,43.61 RR8.2
SD_D2_R: length 2.9
  BOTTOM w0.14: UR1.21 340.18,40.13 340.35,40.3 340.35,41.67 340.49,41.81 RR8.1
SD_D3: length 21.1
  TOP w0.14: v2(331.79,54.51) 331.14,55.15 JCR.2 v1(327.19,55.15)
  IN4 w0.091: v2(339.6,43.94) 339.07,43.94 338.06,44.95 338.06,45.68 337.53,46.2 337.38,46.2 336.91,45.73 336.76,45.73 336.65,45.83 336.65,45.98 337.12,46.46 337.12,46.61 335.14,48.6 335.14,50.94 331.79,54.29 v2(331.79,54.51)
  BOTTOM w0.14: RR7.2 v2(339.6,43.94)
SD_D3_R: length 2.8
  BOTTOM w0.14: RR7.1 339.6,41.81 339.78,41.63 v1(339.78,41.38) UR1.20
SD_LN0_M: length 24.3
  TOP w0.102: JCR.14 350.59,52.27 349.96,52.9 347.35,52.9 v2(347.16,52.7)
  IN4 w0.084: v2(346.57,39.97) 346.41,40.13 346.41,42.28 346.75,42.62 346.75,44.08 346.41,44.41 346.41,50.06 346.12,50.35 346.12,52.3 346.71,52.9 346.97,52.9 v2(347.16,52.7)
  BOTTOM w0.102: v2(346.57,39.97) 346.45,40.09 346.45,40.38 346.17,40.66 345.21,40.66 343.62,39.07 v3(343.36,39.07) 343.05,39.07 342.9,38.93 342.58,38.93 342.52,38.99 UR1.25
SD_LN0_P: length 24.3
  TOP w0.102: v2(347.16,53.34) 347.33,53.16 349.82,53.16 350.43,53.77 JCR.13
  IN4 w0.084: v2(347.16,53.34) 347.13,53.34 346.94,53.15 346.6,53.15 345.86,52.41 345.86,50.25 346.15,49.95 346.15,44.31 346.49,43.97 346.49,42.72 346.15,42.38 346.15,40.13 v2(345.99,39.97)
  BOTTOM w0.102: v2(345.99,39.97) 346.18,40.16 346.18,40.27 346.06,40.4 345.32,40.4 343.73,38.8 343.16,38.8 343.02,38.66 342.51,38.66 342.44,38.59 UR1.26
SD_LN1_M: length 23.2
  TOP w0.102: JCR.17 350.42,46.27 350.25,46.11 350.25,45.63 350.08,45.45 349.7,45.45 v2(349.56,45.59)
  IN4 w0.084: v2(341.66,41.14) 341.47,40.95 341.47,40.55 341.61,40.4 343.56,40.4 345.22,38.74 347.67,38.74 348.57,39.64 348.57,40.24 348.89,40.56 349.4,40.56 349.57,40.73 349.57,40.98 349.4,41.15 348.89,41.15 348.57,41.47 348.57,42.2 348.4,42.37 347.51,42.37 347.19,42.69 347.19,43.15 347.51,43.47 348.4,43.47 348.57,43.64 348.57,44.95 349.02,45.4 349.37,45.4 v2(349.56,45.59)
  BOTTOM w0.102: UR1.23 340.98,40.06 340.91,40.13 340.91,40.2 341.47,40.75 341.47,40.96 v2(341.66,41.14)
SD_LN1_P: length 23.2
  TOP w0.102: JCR.18 350.55,44.77 350.14,45.18 349.79,45.18 v2(349.56,44.95)
  IN4 w0.084: v2(341.02,41.14) 341.21,40.95 341.21,40.44 341.51,40.15 343.45,40.15 345.12,38.48 347.78,38.48 348.83,39.53 348.83,40.13 349,40.3 349.5,40.3 349.83,40.63 349.83,41.08 349.5,41.4 349,41.4 348.83,41.58 348.83,42.3 348.51,42.63 347.62,42.63 347.45,42.8 347.45,43.04 347.62,43.22 348.51,43.22 348.83,43.54 348.83,44.84 349.13,45.14 349.37,45.14 v2(349.56,44.95)
  BOTTOM w0.102: v2(341.02,41.14) 341.2,40.96 341.2,40.86 340.65,40.31 340.65,40.14 340.58,40.07 UR1.22
SD_RCLK_M: length 17.9
  TOP w0.102: JCR.10 330.72,41.2 331.29,41.77 331.51,41.77 v2(331.64,41.63)
  IN4 w0.084: v2(331.64,41.63) 331.81,41.8 332.57,41.8 333.06,42.29 333.06,45.24 333.18,45.36 333.45,45.36 333.66,45.14 333.66,42.03 332.11,40.48 331.17,40.48 330.94,40.25 330.94,39.61 331.17,39.38 332.21,39.38 332.52,39.69 332.77,39.69 v2(332.97,39.49)
  BOTTOM w0.102: v2(332.97,39.49) 333.15,39.68 333.38,39.68 333.58,39.87 333.69,39.87 RR2.2
SD_RCLK_M_R: length 3.7
  BOTTOM w0.102: UR1.15 337.58,38.59 337.21,38.96 336.97,38.96 v3(336.81,39.12) 336.06,39.87 335.22,39.87 RR2.1
SD_RCLK_P: length 17.9
  TOP w0.102: v2(331.64,42.22) 331.46,42.03 331.23,42.03 330.66,42.6 JCR.9
  IN4 w0.084: v2(332.97,40.13) 332.78,39.94 332.41,39.94 332.1,39.63 331.27,39.63 331.19,39.71 331.19,40.15 331.27,40.23 332.22,40.23 333.92,41.93 333.92,45.25 333.55,45.61 333.07,45.61 332.81,45.35 332.81,42.4 332.46,42.05 331.81,42.05 v2(331.64,42.22)
  BOTTOM w0.102: RR3.2 333.69,40.14 333.46,40.14 333.27,39.95 333.15,39.95 v2(332.97,40.13)
SD_RCLK_P_R: length 3.6
  BOTTOM w0.102: RR3.1 335.22,40.14 336.17,40.14 337.08,39.23 337.32,39.23 337.55,38.99 UR1.16
SD_REG2: length 1.1
  BOTTOM w0.14: CR16.1 344.02,40.18 v1(344.32,40.49)
SHD_CLK: length 17.1
  TOP w0.076: UE3.J8 300.6,16.17 v6(300.98,15.79)
  TOP w0.14: v1(311.33,21.11) 311.6,20.84 v2(311.6,20.66) 312.19,20.07 R5831.1
  IN6 w0.076: 303.47,15.37 303.02,15.37 303.02,15.37 301.4,15.37 v6(300.98,15.79)
  IN6 w0.099: v2(311.6,20.66) 312.18,20.07 312.18,18.61 308.94,15.37 303.47,15.37
SHD_CLK_R1: length 1.4
  TOP w0.14: T5999.1 313.26,20.52 R5831.2
SHD_IO0: length 18.9
  TOP w0.14: v2(300.96,14.97) UE3.J7 ; v2(312.68,24.39) 312.42,24.13 T5997.1
  IN1 w0.099: v2(312.68,24.39) 312.68,23.09 311.04,21.45 308.28,21.45 307.34,20.51 307.34,19.31 304.7,16.66 304.19,16.66 302.9,15.37 301.55,15.37 301.15,14.97 v2(300.96,14.97)
SHD_IO1: length 18.1
  TOP w0.14: v2(313.18,24.77) T5998.1 ; v2(302.56,14.97) UE3.L6
  IN1 w0.099: v2(302.56,14.97) 302.79,14.97 303.52,15.7 305.72,15.7 306.2,16.18 306.2,16.95 307.16,17.91 307.16,18.54 307.92,19.31 309.35,19.31 310.24,20.19 310.24,20.37 313.18,23.31 v2(313.18,24.77)
SHD_IO3: length 17
  TOP w0.14: v2(313.69,24.39) T5996.1 ; v2(303.36,14.97) UE3.M6
  IN1 w0.099: v2(303.36,14.97) 303.81,15.42 305.82,15.42 306.42,16.02 306.42,16.73 307.39,17.71 307.98,18.29 308.66,18.29 310.44,20.07 310.44,20.28 313.69,23.53 v2(313.69,24.39)
SIO_EXT_SCI#: length 20.1
  TOP w0.089: RH383.2 86.02,9.7 v2(85.87,9.85) ; v2(99.81,7.82) 100.28,7.82 v1(100.5,7.61)
  IN2 w0.089: v2(99.81,7.82) 99.01,8.63 98.29,8.63 98.16,8.75 96.38,8.75 95.99,8.36 92.44,8.36 91.33,9.47 89.48,9.47 88.75,8.74 87.63,8.74 86.51,9.87 85.9,9.87 v2(85.87,9.85)
  BOTTOM w0.089: v2(99.81,7.82) 99.83,7.84 100.32,7.84 100.4,7.76 101.31,7.76 RE291.2 ; UH2.AU26 86.22,9.76 86,9.76 85.92,9.85 v2(85.87,9.85)
SIO_EXT_SCI#_R: length 218.4
  TOP w0.076: v2(304.01,9.7) 304.01,9.71 303.16,10.57 UE3.M1
  IN2 w0.099: v2(304.01,9.7) 304.01,8.39 303.01,7.39 291.87,7.39 291.09,6.61 288.04,6.61 286.51,8.13 285.54,8.13 284.72,7.31 283.98,7.31 283.05,8.24 258.06,8.24 257.06,7.24 245.37,7.24 242.89,4.76 235.65,4.76 234.95,4.07 215.51,4.07 210.31,9.27 187.94,9.27 187.46,9.75 184.19,9.75 183.57,9.14 176.49,9.14 175.26,7.91 169.91,7.91 169.69,8.13 164.29,8.13 163.85,7.69 160.14,7.69 159.32,6.87 157.71,6.87 156.93,7.65 155.16,7.65 155.16,7.65 152.4,10.41 149.44,10.41 148.7,9.67 147.11,9.67 146.5,10.28 138.82,10.28 137.86,11.23 135.78,11.23 135.34,11.67 132.81,11.67 132.28,12.2 124.65,12.2 124.21,11.76 119.72,11.76 118.14,13.35 113.58,13.35 112.83,12.6 111.28,12.6 110.26,11.58 107.08,11.58 106.49,11 105.4,11 103.02,8.62 v2(103.02,8.48)
  BOTTOM w0.14: v2(103.02,8.48) 103.02,8.09 102.68,7.75 RE291.1
SIO_EXT_SMI#: length 11.1
  TOP w0.076: UE3.K7 v2(301.76,14.97)
  TOP w0.14: v2(308.17,16.96) 308.04,16.83 v1(307.66,16.83) 307.37,17.11 306.57,17.11 306.38,17.3 RE285.1
  IN1 w0.076: 304.17,14.53 302.2,14.53 v2(301.76,14.97)
  IN1 w0.099: v2(308.17,16.96) 307.02,16.96 306.65,16.58 306.65,15.92 305.26,14.53 304.17,14.53
SIO_EXT_SMI#_R: length 246.9
  TOP w0.089: v1(90.23,2.88) 90.39,3.04 v2(90.39,3.38)
  TOP w0.14: v2(307.94,17.62) 307.77,17.78 RE285.2
  IN1 w0.076: v2(90.39,3.38) 90.57,3.56 90.57,4.26 90.78,4.47 91.26,4.47 91.69,4.04 94.08,4.04 94.16,4.12 95.98,4.12 97.43,2.67 101.98,2.67
  IN1 w0.099: 101.98,2.67 102.29,2.67 103.35,3.73 106.35,3.73 106.56,3.52 115.45,3.52 116.12,2.85 116.47,2.85 116.91,3.3 121.46,3.3 121.87,2.9 126.24,2.9 126.26,2.87 137.25,2.87 137.92,2.2 146.03,2.2 147.81,3.98 147.81,3.99 148.04,4.22 148.05,4.22 148.1,4.27 148.65,4.27 149.39,3.53 177.65,3.53 178.47,4.34 181.78,4.34 182.75,3.37 188.33,3.37 189.03,4.06 203.97,4.06 206.31,1.72 242.6,1.72 246.9,6.01 249.89,6.01 251.8,4.09 252.98,4.09 253.43,4.54 263.03,4.54 264.04,5.55 266.58,5.55 267.49,4.65 272.62,4.65 273.04,5.07 274.29,5.07 275,4.37 281.02,4.37 281.58,3.81 284.76,3.81 284.89,3.68 288.76,3.68 289.45,4.37 292.27,4.37 292.3,4.4 296.07,4.4 296.79,5.11 298.3,5.11 299.8,6.61 303.79,6.61 304.17,6.99 304.17,8.64 305.44,9.91 305.44,10.67 305.82,11.05 305.82,12.19 305.31,12.7 305.31,12.96 305.82,13.46 307.09,13.46 307.6,13.97 307.6,14.76 v2(308.71,15.88)
  IN3 w0.091: v2(307.94,17.62) 307.72,17.4 307.72,15.5 307.91,15.31 308.5,15.31 308.71,15.52 v2(308.71,15.88)
  BOTTOM w0.089: 89.88,1.91 89.88,2.02 90.39,2.53 v2(90.39,3.38) 90.58,3.57 90.58,4.41 90.81,4.64 90.81,5.05 UH2.BF18
  BOTTOM w0.14: RH110.1 89.88,1.91
SIO_EXT_WAKE#: length 235.9
  TOP w0.089: RH523.2 89.22,9.36 v6(89.87,10.01)
  TOP w0.14: v2(303.71,20.78) 303.71,20.57 303.44,20.3 303.44,20.13 302.96,19.65 UE3.M12
  IN5 w0.089: v6(89.87,10.01) 90.78,10.92 91.46,10.92 92.06,11.52 93.61,11.52 93.65,11.48 94.46,11.48 94.79,11.16 95.63,11.16 96.13,10.66 97.04,10.66 97.28,10.9 98.17,10.9 98.8,10.27 101.98,10.27
  IN5 w0.099: 101.98,10.27 102.37,10.27 102.97,10.87 103.96,10.87 104.03,10.81 108.24,10.81 108.75,10.3 109.97,10.3 110.89,11.21 111.06,11.21 112.03,12.18 115.43,12.18 116.01,12.76 117.67,12.76 118.37,12.07 121.09,12.07 122.56,13.54 131.71,13.54 132.67,14.51 141.09,14.51 142.03,15.46 164.38,15.46 164.88,14.96 176.55,14.96 181.08,19.48 181.08,20.16 181.58,20.66 182.85,20.66 184.52,18.99 204.82,18.99 206.07,17.73 215.26,17.73 215.58,17.41 248.7,17.41 250.81,15.3 252.39,15.3 253.33,14.36 256.29,14.36 256.87,14.94 259.44,14.94 261.04,16.55 262.94,16.55 263.94,17.54 267.76,17.54 268.25,17.04 274.62,17.04 275.9,18.33 286.88,18.33 287.82,19.27 287.82,21.11 288.98,22.27 290.72,22.27 290.76,22.31 294.04,22.31 294.85,23.12 298.45,23.12 299.71,21.87 303.07,21.87 303.71,21.22 v2(303.71,20.78)
  BOTTOM w0.089: v6(89.87,10.01) 89.43,9.57 89.16,9.57 88.52,8.93 88.21,8.93 UH2.AU24
SIO_PWRBTN#: length 260
  TOP w0.089: v1(78.45,5.6) 77.9,5.06 v2(77.39,5.06) 77.29,5.06 RH6.2
  TOP w0.14: v2(300.97,18.18) UE3.K11
  IN3 w0.076: 302.97,12.83 302.97,13.74 302.35,14.35 301.63,14.35 301.37,14.61 301.37,15.47 301.51,15.61 301.51,16.17 301.37,16.32 301.37,17.53 301.37,17.54 301.37,17.78 v2(300.97,18.18)
  IN3 w0.091: 302.97,12.83 302.97,11.55 301.4,9.98 301.4,8.81 300.81,8.23 v2(300.81,6.07)
  IN6 w0.089: v2(77.39,5.06) 77.46,5.06 77.74,5.34 82.87,5.34 83.88,4.32 83.88,3.11 84.18,2.82 85.62,2.82 86.05,3.26 88.08,3.26 88.46,3.64 88.46,4.26 88.61,4.41 90.08,4.41 90.17,4.32 90.63,4.32 91.33,5.02 96.81,5.02 97.18,5.39 97.54,5.39 97.91,5.02 98.83,5.02 99.48,4.37 99.7,4.37 100.6,3.47 101.98,3.47
  IN6 w0.099: v2(300.81,6.07) 300.25,5.51 298.98,5.51 298.29,4.83 288.8,4.83 288.75,4.88 285.21,4.88 284.74,4.41 280.94,4.41 280.16,5.19 279.55,5.19 278.11,6.63 269.19,6.63 268.52,7.3 263.27,7.3 261.99,6.02 254.16,6.02 253.4,6.78 245.38,6.78 243.17,4.57 215.01,4.57 210.66,8.92 203.11,8.92 202.19,8 183.64,8 183.28,8.37 177.91,8.37 175.75,6.21 166.63,6.21 165.87,5.45 157.49,5.45 157.05,5.02 152.1,5.02 151.91,5.21 147.95,5.21 144.9,8.26 140.74,8.26 140.42,8.57 138.11,8.57 137.45,7.92 135.44,7.92 134.62,7.09 134.62,3.78 133.63,2.79 131.06,2.79 130.53,2.27 125.48,2.27 124.72,3.02 116.78,3.02 116.43,2.68 115.62,2.68 115.28,3.03 110.9,3.03 110.22,2.35 107.8,2.35 107.18,2.97 105.39,2.97 104.9,3.47 101.98,3.47
  BOTTOM w0.089: v2(77.39,5.06) 77.04,5.41 UH2.BE46
SIO_RCIN#: length 268.8
  TOP w0.14: v1(108.1,1.84) 108.28,1.84 RH518.1 v2(109.91,2.78) ; RE286.2 307.4,11.97 307.77,11.97 v2(307.98,11.77)
  IN2 w0.089: v6(80.27,4.38) 80.03,4.13 80.03,2.34 80.47,1.91
  IN2 w0.099: 80.47,1.91 81.29,1.08 89.68,1.08 90.34,1.74 91.4,1.74 91.72,1.42 94.49,1.42 94.81,1.75 95.15,1.75 95.83,1.07 108.19,1.07 v2(109.91,2.78) 111.45,1.23 136.12,1.23 137.99,3.1 138.46,3.1 139.92,1.64 150.55,1.64 152.25,3.34 171.88,3.34 173.96,5.42 175.68,5.42 176.61,4.5 181.94,4.5 183.07,3.37 188.15,3.37 189.23,4.45 203.84,4.45 206.25,2.03 244.29,2.03 247.14,4.89 251.37,4.89 252.03,5.55 262.09,5.55 262.82,6.28 267.02,6.28 268.73,4.57 272.73,4.57 273.24,5.08 274.45,5.08 275.01,4.52 284.72,4.52 285.2,5 286.36,5 286.47,5.11 298.54,5.11 298.79,5.35 299.68,5.35 300.36,4.67 300.36,4.23 300.76,3.82 301.58,3.82 301.98,4.23 306.72,4.23 307.39,3.56 308.9,3.56 310.42,5.08 311.93,5.08 312.29,4.71 312.61,4.71 312.96,5.06 312.96,5.6 312.56,6 312.56,7.17 315.17,9.78 315.17,10.74 314.82,11.09 308.75,11.09 308.36,10.69 307.86,10.69 307.6,10.96 307.6,11.38 v2(307.98,11.77)
  BOTTOM w0.089: v6(80.27,4.38) 80.49,4.59 UH2.BE39
SIO_SLP_A#: length 282.4
  TOP w0.14: RH1152.2 307.21,22.68 RE290.1 307.47,22.23 308.12,22.87 v1(310.06,22.87) 311.01,22.87 v2(311.41,22.48)
  IN3 w0.089: 101.98,4.42 100.32,4.42 99.65,3.75 99.65,3.29 99.38,3.02 97.95,3.02 97.35,3.62 96.04,3.62 95.81,3.39 95.47,3.39 94.79,4.07 94.48,4.07 93.62,4.93 91.25,4.93 90.96,5.22 90.24,5.22 89.61,4.59 87.73,4.59 87.51,4.81 85.65,4.81 85.4,5.06 84.53,5.06 83.33,3.86 83.04,3.86 82.93,3.75 81.92,3.75 81.73,3.94 81.73,4.19 81.47,4.45 80.84,4.45 80.27,3.88 v2(79.37,3.88)
  IN3 w0.091: 101.98,4.42 102.4,4.42 103.09,3.73 106.8,3.73 107.42,4.35 111.01,4.35 111.48,3.88 117.63,3.88 118.51,4.75 119.25,4.75 120.35,3.66 125.02,3.66 125.56,3.12 130.62,3.12 130.94,3.44 133.77,3.44 133.81,3.4 134.15,3.4 134.58,3.84 138.94,3.84 139.69,4.59 139.69,5.61 140.29,6.21 140.29,6.78 142.03,8.52 145.04,8.52 146.31,7.25 147.95,7.25 148.24,7.54 149.17,7.54 149.45,7.26 149.71,7.01 149.71,6.3 151,5.02 153.19,5.02 153.2,5.03 157.56,5.03 158.15,5.62 167.89,5.62 v2(168.87,4.63) ; v2(303.49,5.54) 303.17,5.86 303.17,8.59 303.58,9 303.58,14.35 303.86,14.63 303.86,19.45 304.93,20.51 306.28,20.51 307.01,21.25 309.87,21.25 311.1,22.48 v2(311.41,22.48)
  IN6 w0.099: v2(303.49,5.54) 302.98,5.03 301.49,5.03 300.1,3.65 297.12,3.65 296.45,4.32 289.48,4.32 288.84,3.68 280.66,3.68 280,4.34 278,4.34 277.68,4.02 269.33,4.02 267.63,5.72 263.01,5.72 262.38,5.09 253.57,5.09 252.82,5.84 246,5.84 242.04,1.88 207.07,1.88 204.04,4.92 198.08,4.92 196.96,3.8 169.71,3.8 v2(168.87,4.63)
  BOTTOM w0.089: UH2.BE40 79.68,5.55 79.68,5.05 79.56,4.93 79.56,4.06 v2(79.37,3.88)
  BOTTOM w0.14: v2(168.87,4.63) 168.87,5.22 169.5,5.84 174.75,5.84 176.12,7.21 JAPS.6
SIO_SLP_A#_R: length 5.5
  TOP w0.076: 304.29,19.84 303.63,19.84 303.4,19.61 303.4,18.95 303.02,18.57 UE3.M11
  TOP w0.14: RE290.2 306.3,21.9 v1(305.33,20.93) 305.02,20.61 305.02,20.52 304.34,19.84 304.29,19.84
SIO_SLP_S0#: length 168.8
  TOP w0.14: v2(123.6,51.17) 123.19,51.17 123.15,51.21 122.14,51.21 121.58,50.65 120.38,50.65 120.09,50.94 RZ61.1 ; RE125.1 162.85,3.43 v2(163.39,3.96)
  IN2 w0.089: v2(85.35,7.21) 85.35,7.72 85.6,7.98 86.29,7.98 86.88,8.57 89.52,8.57 89.73,8.36 90.83,8.36 91.13,8.66 91.89,8.66 92.55,8 94.25,8 95.38,6.88 95.82,6.88 96.8,7.86 98.83,7.86 99.35,7.34 99.86,7.34 100.76,8.24 100.76,8.91 101.59,9.74 101.59,9.8 101.98,10.19
  IN2 w0.099: v2(170.36,8.89) 170.11,8.64 164.23,8.64 163.69,8.09 159.98,8.09 159.3,7.42 157.73,7.42 156.87,8.28 155.47,8.28 152.87,10.89 139.24,10.89 136.68,13.45 123.81,13.45 123.09,14.17 121.09,14.17 119.77,15.5 v2(118.49,15.5) 118.48,15.48 118.48,15.25 118.22,14.99 114.01,14.99 113.58,14.56 112.95,14.56 112.03,13.64 110.89,13.64 109.84,12.59 106.66,12.59 106.11,12.04 103.83,12.04 101.98,10.19 ; v2(123.6,51.17) 124.32,50.45 124.32,49.34 119.2,44.22 119.2,36.2 121.47,33.92 121.47,31.48 121.13,31.13 115.83,31.13 v2(115.19,31.78)
  IN4 w0.091: v2(115.19,31.78) 116.21,30.76 116.21,28.07 118.62,25.66 118.62,15.62 v2(118.49,15.5)
  BOTTOM w0.089: v2(85.35,7.21) 85.35,6.85 UH2.BC28
  BOTTOM w0.14: v2(163.39,3.96) 164.24,4.82 165.7,4.82 167.4,6.52 170.62,6.52 171.62,7.52 JAPS.15 171.62,8.34 171.4,8.56 171.4,9.07 171.15,9.32 170.79,9.32 v2(170.36,8.89)
SIO_SLP_S0#_TPM: length 2.9
  TOP w0.14: v1(153.81,3.43) RE125.2 154.81,4.33 154.43,4.72 U32.29
SIO_SLP_S3#: length 614
  TOP w0.14: v2(19.99,50.88) 20.15,50.88 20.74,51.47 RZ1150.2 21.09,51.22 RT433.1 ; v2(301.76,17.37) UE3.K9 ; UZ31.2 252.54,51.18 252.99,51.63 v2(253.15,51.63) ; UZ20.2 112.02,54.55 RZ59.1 111.33,54.8 110.88,54.36 110.69,54.36 110.39,54.05 v2(110.39,53.87) ; v2(120.57,48.63) v1(120.57,47.88) 120.57,44.96 115.91,40.29 111.48,40.29 108.17,36.98 108.17,28.41 110.69,25.89 110.69,20.49 112.42,18.76 113.55,18.76 113.83,18.48 113.83,17.78 114.51,17.11 118.24,17.11 119.81,15.53 119.81,13.89 119.45,13.53 117.62,13.53 116.85,12.77 116.85,12.26 v2(116.66,12.07) ; v2(302.07,21.27) 302.07,21.5 RE35.2 ; v2(111.84,50.39) 111.71,50.39 111.37,50.06 UZ21.2
  IN1 w0.099: v2(17.3,24.76) 16.56,25.5 16.56,26.77 18.06,28.27 18.06,29.43 17.81,29.68 17.81,32.33 20.33,34.86 20.33,39.13 19.34,40.13 19.34,50.63 19.59,50.88 v2(19.99,50.88)
  IN2 w0.099: v2(298.39,28.89) 298.07,29.21 287.19,29.21 285.83,27.86 284.84,27.86 284.24,27.26 284.24,26.26 283.6,25.63 270.06,25.63 268.97,24.54 268.23,24.54 267.25,25.52 265.32,25.52 264.24,24.44 264.24,23.18 263.55,22.49 262.25,22.49 259.26,25.48 259.26,32.54 254.7,37.1 254.7,42.17 254.89,42.36 254.89,44.75 255.7,45.56 255.7,48.8 253.15,51.36 v2(253.15,51.63)
  IN3 w0.076: v2(301.76,17.37) 302.15,16.97 302.15,14.78 302.21,14.73
  IN3 w0.091: v2(301.82,9) 301.82,9.74 303.29,11.22 303.29,13.64 302.21,14.73
  IN6 w0.089: v2(77.76,2.81) 77.33,2.81 77.23,2.71 75.29,2.71 75.06,2.94
  IN6 w0.099: v2(17.3,24.76) 17.3,24.62 18.87,23.06 24.19,23.06 28.73,18.52 44.99,18.52 45.81,19.34 45.81,19.98 46.11,20.28 52.22,20.28 53.48,19.01 55.59,19.01 56.43,18.17 56.43,17.29 56.73,16.98 58.28,16.98 58.65,17.35 58.65,18.13 59.16,18.64 61.13,18.64 62.07,17.7 65.76,17.7 66.5,16.96 66.5,14.06 68.44,12.12 68.44,11.45 69.09,10.8 70.61,10.8 70.87,10.54 70.87,5.97 71.8,5.03 72.97,5.03 75.06,2.94 ; v2(77.76,2.81) 78.71,1.87 81.75,1.87 81.79,1.91 83.25,1.91 84.06,1.09 89.69,1.09 90.28,1.68 92.91,1.68 93.49,1.09 149.44,1.09 151.45,3.1 165.62,3.1 v2(166.5,3.98) ; v2(301.82,9) 301.61,8.79 298.48,8.79 297.31,7.62 291.99,7.62 290.81,6.44 288.32,6.44 286.72,8.04 286.03,8.04 285.46,7.48 281.04,7.48 280.54,6.99 280.12,6.99 278.7,8.4 273.85,8.4 271.84,10.42 243.08,10.42 242.32,11.18 228.8,11.18 225.7,14.28 180.38,14.28 v2(178.73,12.64) 178.48,12.38 163.51,12.38 163.25,12.65 160.36,12.65 159.96,12.24 152.83,12.24 151.79,11.21 150.77,11.21 150.46,10.9 149.05,10.9 148.07,11.88 143.34,11.88 140.61,14.6 130.38,14.6 129.94,15.04 125.29,15.04 124.9,14.66 123.06,14.66 120.86,12.46 117.04,12.46 v2(116.66,12.07) ; v2(298.39,28.89) 298.2,28.7 298.2,26.61 296.74,25.15 294.32,25.15 292.71,23.54 289.63,23.54 289.32,23.22 289.32,22.72 289.51,22.53 298.17,22.53 298.45,22.25 298.45,21.02 298.9,20.58 301.56,20.58 302.07,21.08 v2(302.07,21.27)
  BOTTOM w0.089: UH2.BF42 78.5,4.8 78.5,4.28 78.26,4.04 78.26,3.31 v2(77.76,2.81)
  BOTTOM w0.14: v2(110.39,53.87) 111.84,52.43 v2(111.84,50.39) 111.84,50.4 115.47,50.4 116.23,49.64 119.55,49.64 v2(120.57,48.63) ; v2(301.76,17.37) 302.21,17.82 302.21,20.94 302.07,21.08 v2(302.07,21.27) ; v2(166.5,3.98) 166.5,3.82 167.21,3.11 176.34,3.11 177.59,4.36 177.59,6.21 178.12,6.74 JAPS.2 178.12,8.61 178.89,9.38 178.89,12.48 v2(178.73,12.64)
SIO_SLP_S3#_AR: length 6.6
  TOP w0.14: RT433.2 22.25,48.26 v2(22.3,48.31) 22.3,48.34 v1(22.66,48.69)
  IN6 w0.089: 23.73,46.36 23.73,46.15 23.56,45.99 23.56,45.21 23.46,45.1 v4(23.46,44.08)
  IN6 w0.099: v2(22.3,48.31) 23.73,46.89 23.73,46.36
  BOTTOM w0.089: v4(23.46,44.08) 23.35,44.19 UT1.D2
SIO_SLP_S4#: length 375
  TOP w0.127: v2(304.42,19.37) UE3.N12
  TOP w0.14: RZ1151.2 176.3,6.05 v2(176.48,6.22) ; v2(305.67,20.08) 304.99,20.08 304.42,19.52 304.42,19.37 v2(304.42,19.37) ; v2(122.18,49.97) 122.66,49.49 v1(122.66,45.92) 122.66,45.58 116.65,39.57 111.78,39.57 108.89,36.68 108.89,28.71 111.48,26.12 111.48,21.32 112.53,20.26 114.22,20.26 115.19,19.29 117.6,19.29 118.67,18.21 118.67,17.75 119.27,17.15 127.66,17.15 129.78,15.03 129.78,11.01 128.56,9.8 128.09,9.8 v2(127.65,10.24) ; v2(122.05,65.53) 122.3,65.79 UZ22.2 ; v2(308.61,20.7) 308.74,20.83 RE38.2 ; RZ1954.1 107.22,55.67 110.45,55.67 111.02,56.24 120.04,56.24 v2(120.4,56.59) 120.4,57.14 120.26,57.28 RZ81.1
  IN2 w0.099: v2(122.18,49.97) 122.18,50.82 122.23,50.86 122.23,53.65 122.53,53.95 122.53,56.26 122.19,56.59 v2(120.4,56.59) 120.4,58.67 121.54,59.81 121.54,63.88 122.3,64.64 122.3,65.28 v2(122.05,65.53) ; v2(305.67,20.08) 306.73,21.14 308.22,21.14 308.61,20.76 v2(308.61,20.7)
  IN3 w0.089: v2(77.9,3.77) 77.95,3.77 77.96,3.76 78.44,3.76 79.76,5.09 84.31,5.09 84.46,5.24 85.47,5.24 85.72,4.99 87.59,4.99 87.81,4.77 89.53,4.77 90.16,5.4 91.03,5.4 91.32,5.11 93.69,5.11 94.49,4.31 97.63,4.31 98.27,4.95 98.89,4.95 99.37,5.43 101.98,5.43
  IN3 w0.091: 101.98,5.43 102.41,5.86 103.16,5.86 104.1,4.92 106.67,4.92 106.86,4.73 111.17,4.73 111.64,4.26 117.39,4.26 117.92,4.8 117.92,5.98 121.26,9.32 126.73,9.32 v2(127.65,10.24) 128.03,10.62 128.44,10.62 130.21,8.85 132.47,8.85 133.76,7.56 138.62,7.56 139.14,8.07 141.03,8.07 141.86,8.9 145.26,8.9 146.53,7.63 147.76,7.63 148.05,7.93 149.33,7.93 150.02,7.24 150.55,7.24 152.38,5.42 157.4,5.42 158.07,6.09 172.19,6.09 172.66,6.56 174.71,6.56 175.22,6.05 176.16,6.05 176.34,6.22 v2(176.48,6.22) 176.54,6.17 176.73,6.17 177,6.44 178.34,6.44 179.25,5.52 182.19,5.52 182.47,5.8 187.66,5.8 188.17,5.29 197.06,5.29 198.08,6.32 201.99,6.32 202.84,7.16 204.73,7.16 206.06,8.49 211.47,8.49 214.38,5.59 238.89,5.59 239.9,6.61 251.58,6.61 252.72,5.47 259.53,5.47 259.93,5.08 262.17,5.08 263.07,5.98 267.15,5.98 268.11,5.02 273.05,5.02 273.33,5.3 274.43,5.3 274.61,5.12 286.86,5.12 287.18,5.43 291.24,5.43 292.33,6.53 293.58,6.53 293.92,6.18 293.92,5.38 294.09,5.21 294.87,5.21 295.16,4.92 296.57,4.92 296.78,5.14 298.04,5.14 298.58,5.68 299.37,5.68 300.02,5.03 302.17,5.03 302.35,4.85 306.22,4.85 306.47,5.09 306.47,11.42 305.42,12.46 305.42,12.57 305.27,12.73 305.27,15.1 306.12,15.95 306.12,17.9 305.14,18.88 304.91,18.88 v2(304.42,19.37)
  BOTTOM w0.089: UH2.BE42 78.17,4.99 78.17,4.47 77.95,4.26 77.95,3.82 v2(77.9,3.77)
  BOTTOM w0.14: JAPS.5 176.62,6.51 176.48,6.37 v2(176.48,6.22)
SIO_SLP_S5#: length 278.1
  TOP w0.14: UE3.N8 304.29,16.17 v2(304.36,16.1) ; v2(167.31,7.54) v1(167.31,6.92)
  IN2 w0.089: 101.98,7.95 101.22,7.95 99.43,6.16 96.04,6.16 95.85,5.98 94.6,5.98 94.38,6.2 94.38,7.12 94.1,7.4 91.75,7.4 91.11,6.75 89.43,6.75 89.16,6.48 88.84,6.48 88.65,6.67 87.82,6.67 87.73,6.57 87.03,6.57 87.02,6.58 85.7,6.58 85.44,6.85 85.19,6.85 84.97,7.08 84.97,8.95
  IN2 w0.099: v2(78.53,6.43) 78.53,7.63 79.24,8.33 79.77,8.33 79.97,8.53 81.81,8.53 82.54,7.8 83.28,7.8 83.91,8.42 83.91,8.88 84.32,9.29 84.63,9.29 84.97,8.95 ; v2(304.12,5.46) 304.12,6.47 303.39,7.19 292.05,7.19 291.08,6.22 287.91,6.22 287.02,7.11 283.89,7.11 282.97,8.04 258.4,8.04 257.38,7.01 245.55,7.01 243.05,4.51 235.9,4.51 235.21,3.81 215.36,3.81 210.15,9.02 189.1,9.02 188.22,8.13 187.64,8.13 186.25,9.53 184.24,9.53 183.65,8.94 176.69,8.94 175.46,7.71 170.62,7.71 170.46,7.54 v2(167.31,7.54) 166.8,7.04 165.3,7.04 164.99,7.35 160.3,7.35 159.26,6.31 157.67,6.31 156.66,7.32 153.95,7.32 152.59,8.68 152.16,8.68 150.85,9.98 149.3,9.98 148.79,9.47 147.03,9.47 146.42,10.07 138.73,10.07 138,10.81 135.47,10.81 134.81,11.47 132.73,11.47 132.19,12 124.73,12 124.29,11.56 119.64,11.56 118.05,13.15 113.98,13.15 113.24,12.4 112.27,12.4 110.45,10.58 108.4,10.58 108.19,10.78 105.67,10.78 105.37,10.49 105.37,9.72 104.8,9.15 104.36,9.15 103.16,7.95 101.98,7.95
  IN3 w0.091: v2(304.12,5.46) 304.12,5.77 306.2,7.85 306.2,11.05 305.41,11.84 304.65,11.84 304.43,12.05 304.43,13.48 305,14.05 305,15.46 v2(304.36,16.1)
  BOTTOM w0.089: v2(78.53,6.43) 78.65,6.54 UH2.BC42
  BOTTOM w0.14: JAPS.4 177.12,8.23 176.61,8.74 176.61,10.06 175.92,10.74 175.92,11.28 175.64,11.56 170.88,11.56 170.6,11.28 170.6,10.37 170.12,9.89 169.66,9.89 v2(167.31,7.54)
SIO_SLP_SUS#: length 315.7
  TOP w0.14: RE111.2 310.72,13.59 311.01,13.88 v2(311.01,13.97) ; v2(127.04,10.21) 127.04,10.28 127.99,11.23 RZ1952.1 ; RH5871.2 v1(249.3,7.57) 249.75,7.57 v2(252.22,5.1) ; RZ1133.1 59.57,8.13 v2(59.7,8.26)
  IN2 w0.089: 75.06,1.91 78.15,1.91 v2(79.67,3.42)
  IN2 w0.099: v2(127.04,10.21) 125.3,10.21 123.83,8.74 119.82,8.74 117.87,6.78 117.87,4.89 116.27,3.29 v2(116.26,3.29) ; v2(59.7,8.26) 59.7,8.26 59.14,7.71 59.14,5.19 60.04,4.29 60.04,3.68 60.61,3.11 61.2,3.11 61.38,2.93 61.58,2.93 62.05,2.46 63.83,2.46 64.07,2.22 67.25,2.22 67.76,1.72 73.67,1.72 73.86,1.91 75.06,1.91
  IN3 w0.089: 101.98,4.23 100.38,4.23 99.82,3.67 99.82,3.21 99.45,2.84 97.87,2.84 97.27,3.44 96.11,3.44 95.88,3.21 95.4,3.21 94.72,3.89 92.12,3.89 91.8,4.2 91.52,4.2 91.15,4.57 90.87,4.57 90.57,4.28 89.43,4.28 89.3,4.41 87.66,4.41 87.44,4.64 85.57,4.64 85.33,4.87 84.6,4.87 83.41,3.68 83.12,3.68 82.36,2.93 80.16,2.93 v2(79.67,3.42)
  IN3 w0.091: v2(311.01,13.97) 310.91,13.97 310.42,13.48 310.42,12.19 311.12,11.48 311.77,11.48 312.44,10.81 312.44,9.71 309.95,7.22 308.72,7.22 306.96,5.46 306.96,4.83 306.57,4.43 302.22,4.43 302.01,4.64 299.62,4.64 299.47,4.48 299.09,4.48 298.82,4.75 297.03,4.75 296.82,4.54 294.95,4.54 294.7,4.79 287.35,4.79 287.1,4.54 274.02,4.54 273.72,4.24 273.34,4.24 272.95,4.64 267.95,4.64 266.99,5.59 263.33,5.59 262.41,4.67 259.16,4.67 258.79,5.05 252.27,5.05 v2(252.22,5.1) 251.48,5.84 240.54,5.84 239.02,4.32 214.38,4.32 210.59,8.11 206.22,8.11 204.84,6.72 204.84,5.21 204.49,4.87 198.55,4.87 198.27,4.87 197.83,4.43 188.48,4.43 187.5,5.41 182.63,5.41 182.35,5.14 177.84,5.14 177.32,5.66 176.8,5.66 176.59,5.45 174.37,5.45 172.96,4.04 168.81,4.04 167.42,5.43 158.23,5.43 157.63,4.83 150.92,4.83 149.52,6.22 149.52,6.93 149.14,7.3 148.28,7.3 148.03,7.05 146.23,7.05 144.96,8.32 142.22,8.32 140.53,6.63 140.53,6.14 139.89,5.5 139.89,4.47 139.07,3.64 134.66,3.64 134.23,3.21 133.73,3.21 133.69,3.25 131.23,3.25 130.88,2.91 125.36,2.91 124.86,3.4 116.38,3.4 v2(116.26,3.29) 111.8,3.29 110.93,4.15 107.69,4.15 107.07,3.53 102.93,3.53 102.24,4.23 101.98,4.23
  BOTTOM w0.089: v2(79.67,3.42) 79.73,3.49 79.73,4.86 79.88,5 79.88,5.42 80.02,5.56 80.08,5.56 80.21,5.7 80.21,5.93 UH2.BD39
SIO_SLP_SUS#_R: length 7.5
  TOP w0.14: UE3.N4 303.9,12.83 305.14,12.83 305.55,12.42 307.6,12.42 307.87,12.69 307.87,13.17 v1(308.06,13.36) 308.29,13.59 RE111.1 RE300.2
SIO_SLP_WLAN#: length 331.3
  TOP w0.089: RZ1149.2 79.59,5.68 79.59,6.78 v6(79.58,6.79)
  TOP w0.14: v2(311.05,4.67) 311.3,4.67 v1(311.75,5.12) ; v2(296.16,17.37) UE3.D9
  IN1 w0.099: v2(334.62,42.2) 335.41,41.4 336.3,41.4 338.2,39.5 338.2,34.55 337.72,34.06 331.2,34.06 328.15,31.01 328.15,27.41 327.79,27.05 324.67,27.05 318.88,21.26 317.63,21.26 314.49,18.12 314.49,16.87 313.53,15.91 313.53,13.61 312.43,12.52 312.43,6.06 v2(311.05,4.67)
  IN5 w0.089: v6(79.58,6.79) 79.58,6.79 80.22,6.15 82.02,6.15 82.19,5.97 85.7,5.97 86.35,5.32 89.27,5.32 89.7,5.75 93.55,5.75 93.78,5.52 98.45,5.52 99.33,4.64 100.32,4.64 100.59,4.9 100.59,5.54 101.65,6.61 101.98,6.61
  IN5 w0.099: 101.98,6.61 104.13,6.61 105.69,5.04 110.68,5.04 111.73,6.09 117.86,6.09 120.56,3.39 125.96,3.39 126.81,2.54 130.81,2.54 131.44,3.17 135.32,3.17 135.81,3.66 139.88,3.66 140.6,4.38 140.6,6.15 142.43,7.98 144.89,7.98 147.65,5.22 155.97,5.22 156.8,4.4 159.31,4.4 160.32,5.4 170.19,5.4 171.37,4.22 177.64,4.22 178.07,4.65 181.77,4.65 182.79,5.67 187.34,5.67 188.3,4.71 195.59,4.71 198.24,7.35 203.93,7.35 205.59,9.02 210.4,9.02 214.92,4.5 242.65,4.5 244.81,6.66 257.24,6.66 258.24,5.66 263.15,5.66 263.67,6.17 267.87,6.17 269.08,4.97 270.13,4.97 270.79,5.63 274.18,5.63 275.07,4.74 280.27,4.74 280.41,4.59 283.35,4.59 283.35,4.53 283.71,4.17 284.21,4.17 284.57,4.53 284.57,4.59 284.57,4.59 284.91,4.94 288.79,4.94 289.33,4.41 296.6,4.41 297.63,5.43 297.63,5.53 v2(297.64,5.54) 297.65,5.55 298.51,5.55 299.87,6.91 303.87,6.91 304.55,6.22 305.06,6.22 305.56,6.73 306.34,6.73 307.09,5.98 309.11,5.98 310.41,4.67 v2(311.05,4.67)
  BOTTOM w0.076: v2(296.16,17.37) 296.16,17.29 296.55,16.9 296.55,16.37 296.79,16.13 297.37,16.13 297.5,16 298.83,16 298.96,15.88 298.96,14.86 299.24,14.57 299.54,14.57 299.75,14.36 299.75,11.19 299.79,11.15 299.79,9.74 299.64,9.59
  BOTTOM w0.089: v6(79.58,6.79) 79.58,6.77 79.32,6.5 79.32,6.31 79.1,6.09 UH2.BD42
  BOTTOM w0.14: QR105.1 334.08,42.74 v2(334.62,42.2) ; v2(297.64,5.54) 297.64,5.57 298.98,6.91 298.98,8.93 299.64,9.59
SIO_SLP_WLAN#_R: length 4.3
  BOTTOM w0.14: DN3.2 334.53,45.27 QR105.3 333.3,45.24 RZ1141.1 v1(332.13,45.85)
SLEEVE: length 13.7
  IN2 w1.016: 14.48,54.67 14.48,46.8 12.52,44.84 11.87,44.84 11.11,45.59 9.75,45.59
  vias: v1(7.93,45.48) v2(9.27,44.74) v2(9.27,44.16) v2(13.46,58.59) v2(13.92,58.03) v2(14.1,58.57) v2(14.57,58.07)
SLEEVE_L: length 2
  TOP w1.016: JHP1.4 3.2,45.88
  vias: v5(2.96,45.61)
SLP_WLAN#_GATE: length 53.9
  TOP w0.14: v1(314.47,19.94) 314.13,20.27 v2(314.13,20.34) ; v2(310.58,26.25) 310.54,26.25 310.41,26.12 RE305.2
  IN3 w0.091: v2(310.58,26.25) 310.58,24.03 312.05,22.55 312.05,19.2 312.76,18.49 312.76,17.05 313.51,16.29 313.86,16.29 314.48,16.91 314.48,19.99 v2(314.13,20.34)
  IN6 w0.099: v2(314.13,20.34) 314.13,21.52 318.77,26.16 318.77,31.45 319.41,32.09 319.41,35.18 321.31,37.09 326.19,37.09 328.88,39.78 328.88,42.51 v2(331.27,44.9)
  BOTTOM w0.14: v2(331.27,44.9) 331.47,44.69 RE275.1 332.23,44.27 QR105.2
SLP_WLAN#_GATE_R: length 12.4
  TOP w0.076: UE3.K10 v2(301.77,18.18)
  TOP w0.14: RE305.1 309.46,25.36 RE306.1 309.46,24.45 v2(308.87,23.85) 308.87,23.41 v1(308.8,23.34)
  IN2 w0.099: v2(308.87,23.85) 308.43,23.42 307.98,23.42 305.77,21.21 304.8,21.21 v2(301.77,18.18)
SM_PG_CTRL: length 204.9
  TOP w0.14: RH525.2 120.95,55.24 121.69,55.24 121.93,54.99 v2(122.01,54.99) 122.02,54.97 123.03,54.97 UC1.4
  IN3 w0.091: 253.94,21.15 254.13,21.34 256.29,21.34 256.67,20.96 259.91,20.96 260.3,21.35 268.06,21.35 268.51,21.79 277.43,21.79 281.39,25.75 v2(281.39,29.84) ; 226.95,19.18 202.74,19.18 201.28,20.64 183.81,20.64 183.31,21.14 163.21,21.14 162.94,21.4 162.94,25.02 162.94,25.73 157.56,30.54 132.97,46.18 v2(130.72,48.43)
  IN3 w0.099: 253.94,21.15 250.76,21.15 249.62,20 227.78,20 226.95,19.18
  BOTTOM w0.127: v2(122.01,54.99) 123.04,54.99 127.79,50.24 127.79,49.61 128.97,48.43 v2(130.72,48.43)
  BOTTOM w0.14: v2(281.39,29.84) 282.34,28.9 282.34,27.61 282.69,27.26 282.69,26.4 284.73,24.36 290.57,24.36 293.54,27.32 293.54,29.06 PR608.1
SML0_SMBCLK: length 3.6
  TOP w0.089: RH501.2 86.74,5.06 86.23,4.55 86.23,4.06 86.57,3.73 v6(86.65,3.73)
  BOTTOM w0.089: v6(86.65,3.73) 86.68,3.73 86.96,4 86.96,4.79 87.25,5.09 UH2.BF25
SML0_SMBDATA: length 3.3
  TOP w0.089: v6(87.17,3.63) 87.17,3.56 87.04,3.44 RH502.2
  BOTTOM w0.089: UH2.BE24 88,5.78 88,5.14 87.95,5.08 87.95,4.77 87.78,4.59 87.78,4.02 87.39,3.64 87.25,3.64 87.25,3.63 v6(87.17,3.63)
SML0ALERT#: length 3.7
  TOP w0.089: v1(89.47,4.76) 89.33,4.62 RH503.2 88.13,4.62 87.67,4.16 87.35,4.16 v2(87.34,4.15)
  BOTTOM w0.089: UH2.BF24 87.72,5.24 87.72,4.8 87.47,4.55 87.47,4.25 87.37,4.15 v2(87.34,4.15)
SML1_SMBCLK: length 239.7
  TOP w0.076: UE3.D8 v2(296.16,16.57)
  TOP w0.089: v2(85.85,3.56) 85.89,3.52 RH460.2
  IN2 w0.089: 92.44,1.91 92.26,2.09 91.31,2.09 91.22,2.19
  IN2 w0.099: v2(85.85,3.56) 85.85,3.52 85.98,3.4 85.98,3.35 86.37,2.96 87.73,2.96 87.93,2.76 87.93,2.28 88.4,1.81 89.77,1.81 90.29,2.32 91.08,2.32 91.22,2.19 ; v2(286.51,5.72) 286.11,5.31 285.08,5.31 284.6,4.83 277.58,4.83 276.43,5.97 268.16,5.97 267.55,6.59 262.47,6.59 261.75,5.86 247.41,5.86 244.15,2.59 214.91,2.59 209.69,7.81 205.55,7.81 202.69,4.95 188.72,4.95 187.58,3.81 184.87,3.81 182.9,5.78 179.85,5.78 178.83,6.8 176.47,6.8 176.16,6.49 171.36,6.49 170.05,5.19 162.49,5.19 160.96,3.66 154.76,3.66 153.61,4.82 151.7,4.82 149.94,3.06 148.48,3.06 148.47,3.07 148.13,3.07 148.12,3.06 147.18,3.06 146.07,1.95 140.06,1.95 138.54,3.47 135.24,3.47 134,2.23 134,2.13 133.42,1.55 125.33,1.55 123.89,3 122.48,3 122.3,2.82 116.92,2.82 116.63,2.53 115.28,2.53 114.81,3 111.33,3 111.07,3.25 108.17,3.25 106.57,1.65 106.5,1.65 106.43,1.58 95.94,1.58 95.87,1.65 95.8,1.65 95.44,2.01 94.51,2.01 94.26,1.77 92.58,1.77 92.44,1.91
  IN3 w0.076: 294.89,16.97 295.76,16.97 v2(296.16,16.57)
  IN3 w0.091: 294.89,16.97 294.09,16.17 293.46,16.17 292.5,15.2 292.5,14.72 292.05,14.27 292.05,11.41 290.78,10.14 290.78,8.4 291.63,7.55 291.63,6.79 291,6.16 289.24,6.16 288.9,6.5 286.8,6.5 286.39,6.09 286.39,5.84 v2(286.51,5.72)
  BOTTOM w0.089: v2(85.85,3.56) 85.85,3.7 86.14,3.98 86.14,4.58 86.06,4.66 UH2.BF27
SML1_SMBDAT: length 243.3
  TOP w0.089: v2(85.78,4.17) 85.79,4.16 85.83,4.16 86.23,3.76 86.23,3.62 86.46,3.39 RH461.2
  TOP w0.14: v2(297.76,18.97) UE3.E11
  IN2 w0.089: 92.72,2.12 92.48,2.37 92.1,2.37 92.03,2.44 91.47,2.44
  IN2 w0.099: v2(85.78,4.17) 86.31,3.64 86.31,3.52 86.57,3.26 87.93,3.26 88.28,2.91 88.28,2.43 88.55,2.16 89.63,2.16 90.18,2.72 91.19,2.72 91.47,2.44 ; v2(285.88,5.72) 285.37,6.22 282.96,6.22 282.32,5.59 278.86,5.59 278.41,5.13 277.7,5.13 276.56,6.27 268.29,6.27 267.67,6.89 262.35,6.89 261.62,6.16 246.02,6.16 242.75,2.9 215.04,2.9 209.82,8.12 205.43,8.12 202.57,5.26 188.6,5.26 187.47,4.13 184.98,4.13 183.02,6.08 179.98,6.08 178.96,7.1 176.34,7.1 176.04,6.79 171.23,6.79 169.93,5.49 162.36,5.49 160.89,4.01 154.84,4.01 153.73,5.12 151.58,5.12 149.87,3.41 148.62,3.41 148.61,3.42 147.98,3.42 147.98,3.41 147.04,3.41 145.92,2.3 140.2,2.3 138.68,3.82 135.1,3.82 133.65,2.37 133.65,2.28 133.28,1.91 125.48,1.91 124.03,3.35 122.33,3.35 122.16,3.17 116.78,3.17 116.49,2.88 115.43,2.88 114.96,3.35 111.47,3.35 111.22,3.61 108.03,3.61 106.3,1.88 96.07,1.88 95.58,2.37 94.36,2.37 94.12,2.12 92.72,2.12
  IN3 w0.076: 294.64,17.21 295.21,17.77 297.12,17.77 297.76,18.41 v2(297.76,18.97)
  IN3 w0.091: 294.64,17.21 293.95,16.51 293.32,16.51 292.15,15.34 292.15,14.79 291.76,14.4 291.76,11.53 290.43,10.21 290.43,8.25 291.28,7.4 291.28,6.93 290.86,6.51 289.39,6.51 289.04,6.85 286.66,6.85 286.04,6.23 286.04,5.88 v2(285.88,5.72)
  BOTTOM w0.089: v2(85.78,4.17) 85.82,4.22 85.82,5.38 86.06,5.62 UH2.BE27
