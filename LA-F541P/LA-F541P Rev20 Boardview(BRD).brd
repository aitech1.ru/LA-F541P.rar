# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1V_MPHY_MPHYPLL:
  vias: v1(70.24,26.62)
+1V_PCH: length 119.6
  TOP w0.279: v2(129.76,96.06) 129.31,96.51 JXDP.43 ; v2(124.11,96.58) 124.03,96.51 JXDP.44 121.4,96.51 121.32,96.43 120.81,96.43 120.27,95.89 119.66,95.89 RH492.1
  IN1 w0.508: v2(124.11,96.58) 124.11,96.91 124.76,97.56 127.38,97.56 128.88,96.06 v2(129.76,96.06)
  IN4 w0.508: v2(124.11,96.58) 124.11,96.79 124.75,97.43 127.16,97.43 129.41,95.17 130.67,95.17 131.03,95.53 132.05,95.53 133.37,94.22 133.37,92.73 133.05,92.42 133.05,85.01 130.81,82.76 130.81,81.2 128.91,79.3 128.91,67.17 123.83,62.09 123.83,58.5 124.14,58.18 124.14,57.24 123.88,56.97 123.88,54.92 125.07,53.72 125.07,49.89 117.49,42.31 113.15,42.31 111.71,40.87 111.71,39.84 108.24,36.37 108.24,35.19 103.16,30.11 v2(103.16,28.25)
  BOTTOM w0.203: UH2.C2 98.8,26.1 UH2.C1 ; UH2.B3 98.53,26.78 UH2.B2 98.93,26.73 UH2.B1 99.06,27.22 v2(99.3,27.46)
  BOTTOM w0.254: UH2.B1 UH2.C1
  BOTTOM w0.305: v2(84.55,18.65) 84.55,18.62 84.52,18.62 84.15,18.25 UH2.W31
  BOTTOM w0.457: CH3.1 121.76,97.09 122.24,97.58 122.87,97.58 123.56,96.89 123.8,96.89 v2(124.11,96.58) ; v2(74.74,25.36) 74.74,25.37 74.61,25.49 73.25,25.49 73.03,25.28 LH3.1
  BOTTOM w0.508: LH4.1 104.59,22.6 v2(104.6,22.61)
  vias: v2(83.66,15.89) v2(84.46,16.26) v2(84.48,15.51) v2(85.32,18.69) v2(86.09,18.66) v2(86.86,18.66) v2(88.41,18.56) v2(89.17,18.54) v2(89.96,18.59) v2(103.81,28.27) v2(104.4,28.25) v2(110.99,11.74) v2(112.03,14.96) v2(112.52,15.3) v2(113.09,15.3) v2(114.4,15.5) v2(115.09,15.5) v2(116.05,15.5) v2(116.89,15.5) v2(117.51,15.5) v5(89.36,30.25)
+1V_PCH_AZPLL: length 4.5
  TOP w0.356: v2(99.99,25.87) 100.03,25.83 CH203.1 CH3322.1 101.26,24.91 LH2.2
  BOTTOM w0.254: v2(99.99,25.87) 99.48,25.36 UH2.E1 UH2.D1
+1V_PCH_CLK5: length 0.9
  BOTTOM w0.089: v1(101.14,22.04) 101.17,22.06 101.17,22.42 101.51,22.76
+1V_PCH_CNVI: length 2.2
  TOP w0.381: RH5856.2 91.97,16.75 91.44,16.22 v2(91.44,15.93)
  BOTTOM w0.203: UH2.AE17 91.29,15.5 91.44,15.65 v2(91.44,15.93)
+1V_PCH_PRIM:
  vias: v2(85.29,16.27) v2(85.27,15.55) v2(85.99,15.52) v2(86.06,16.3) v2(87.63,14.82) v2(88.37,17.03) v2(88.38,16.32) v2(89.21,16.33) v2(114.52,14.31) v2(115.1,14.31) v2(115.74,14.31) v2(116.33,14.31) v2(116.92,14.33) v2(117.55,14.33) v2(118.12,14.33) v2(118.72,14.33) v5(85.37,16.98)
+1V_VCCDSW: length 4.4
  BOTTOM w0.254: UH2.BG45 UH2.BG46 76.79,4.53 76.46,4.19 76.35,4.19 75.84,3.68 75.84,3.48 74.96,2.59
  BOTTOM w0.381: 74.96,2.59 CH3329.1
+1VALW: length 59.3
  IN4 w1.524: 192.55,58.8 192.41,58.8 191.52,59.69 191.52,77.68 184.74,84.46 183.71,84.46
  BOTTOM w2.032: 180.46,32.22 179.57,33.11 179.57,38.08 193.36,51.87 193.36,55.44
  vias: v2(182.8,86.18) v2(182.8,85.6) v2(183.39,85.6) v2(183.97,85.6) v2(192.14,57.1) v2(192.43,57.65) v2(192.76,57.11) v5(183.63,84.7)
+1VALW_PG: length 206.3
  TOP w0.14: v1(314.31,16.97) 314.24,16.89 v2(313.61,16.89) RT5840.2
  IN2 w0.099: v2(138.27,2.64) 139.57,1.34 150.72,1.34 152.28,2.9 172.05,2.9 174.26,5.11 175.57,5.11 176.53,4.14 181.73,4.14 182.82,3.05 188.34,3.05 189.22,3.93 203.85,3.93 206.12,1.65 244.35,1.65 247.27,4.57 252.41,4.57 253.09,5.25 262.23,5.25 262.94,5.96 266.84,5.96 268.58,4.22 284.93,4.22 285.41,4.7 298.63,4.7 299.84,3.48 301.75,3.48 302.19,3.93 306.27,3.93 306.96,3.24 309.08,3.24 310,4.17 312.64,4.17 313.26,4.79 313.26,5.73 312.91,6.08 312.91,6.92 315.49,9.5 315.49,10.95 315.04,11.41 310.78,11.41 310.57,11.62 310.57,14.91 312.55,16.89 v2(313.61,16.89)
  BOTTOM w0.14: PR521.2 137.57,3.34 v2(138.27,2.64)
+1VS_GFX: length 10.2
  TOP w0.14: v5(195.19,86.18) 195.64,86.63 v2(195.64,87.12)
  TOP w0.457: CV859.1 199.65,75.41 v2(199.85,75.62)
  TOP w0.508: v2(201.03,73.28) 200.97,73.22 CV860.1 ; v2(195.64,87.12) 196.41,87.12 CV869.1 ; CV865.1 200.36,77.67 200.16,77.87 200.16,77.9 v2(199.94,78.12) ; v2(195.05,59.79) 194.86,59.98 194.86,61.61 CV866.1
  BOTTOM w0.254: UV18.AH21 199.54,75.3 v2(199.85,75.62) ; UV18.AG19 200.58,73.55 200.85,73.28 v2(201.03,73.28) ; v2(199.85,75.62) 200.27,75.2 UV18.AG21 ; v2(199.85,75.62) 200.29,76.05 UV18.AG22 ; UV18.AH25 199.54,78.52 v2(199.94,78.12) 200.34,77.72 UV18.AG24
  vias: v2(223.5,117.23) v2(223.5,116.6) v2(224.09,117.23) v2(224.09,116.6)
+1VSP: length 13.9
  TOP w0.254: v2(133.04,2.32) 133.04,1.98 132.72,1.65 129.74,1.65 v1(128.89,2.51) 127.51,3.89 127.51,4.7 126.67,5.54 124.64,5.54 123.7,4.6 PC510.1
  BOTTOM w0.254: PC506.1 133.2,2.48 v2(133.04,2.32) 133.1,2.26 PR504.1
  vias: v2(120.31,6.47) v2(120.89,6.47) v2(121.48,6.47) v2(122.09,6.47) v2(122.7,6.47) v2(123.32,6.47) v2(124.78,4.87) v2(124.78,4.28) v2(125.36,4.87) v2(125.36,4.28) v2(125.95,4.87) v2(125.95,4.28) v2(126.24,6.45) v2(126.53,4.87) v2(126.53,4.28) v2(126.82,6.45)
+2.5V_MEM: length 83.3
  TOP w0.508: v2(250.13,29.27) v2(250.13,29.91) 250.13,30.05 249.49,30.68 CD31.1 CD30.1 246.11,30.67 CD27.1 CD28.1
  IN5 w1.016: 178.44,29.74 182.86,34.16 246.57,34.16 249.94,30.8
  vias: v2(176.1,29.06) v2(176.71,29.08) v2(177.27,28.88) v5(180,25.03)
+2.5V_MEM_PG: length 1.4
  TOP w0.14: PT201.1 177.64,13.84 PR1851.2
+2.5VSP_ON: length 4.5
  TOP w0.254: PR1801.2 v1(179.36,9.15) 178.82,9.69 PC1800.1 179.35,10.29 180.03,10.96 PU1800.6
+3.3V_1.8V_ESPI: length 122.4
  TOP w0.254: RH518.2 109.75,1.86 109.98,1.63 116.01,1.63 117.77,3.38 118.62,3.38 119.15,3.91 119.46,3.91 119.59,4.04 119.59,5.63 v2(118.87,6.35) v1(118.87,7.7) 118.87,8.42 RH597.2 120.03,9.06 RH1943.2 ; RH5838.2 83.95,5.31 84.74,4.51 v2(84.75,4.51)
  IN1 w0.254: v2(84.75,4.51) 84.75,4.52 85.1,4.87 87.56,4.87 87.76,4.66 88.96,4.66 90.07,5.77 94.35,5.77 94.6,5.52 96.52,5.52 96.73,5.73 98.32,5.73 98.88,6.29 99.5,6.29 100.19,6.97 100.92,6.97 101.69,6.2 103.59,6.2 104.95,4.85 107.88,4.85 108.48,4.25 117.68,4.25 118.65,5.23 118.65,6.13 v2(118.87,6.35)
  IN3 w0.254: v2(84.75,4.51) 84.69,4.51 83.92,3.74 83.92,2.9 83.69,2.67 82.14,2.67 81.48,2.01 80.88,2.01 80.54,2.36 77.59,2.36 76.85,3.09 74.83,3.09 73.73,1.99 66.65,1.99 65.86,2.78 64.38,2.78 62.94,4.22 62.94,4.6 62.18,5.36 62.18,6.9 62.47,7.19 62.94,7.19 64.88,9.13 64.88,9.85 65.84,10.82 65.84,12.06 64.92,12.98 v2(64.92,13.56) ; v2(83.38,12.09) 83.26,12.09 82.8,11.63 80.29,11.63 79.79,11.13 79.19,11.13 78.54,10.48 77.12,10.48 75.82,11.78 74.69,11.78 70.66,15.8 70.66,16.93 v2(69.75,17.85)
  IN5 w0.254: v2(69.75,17.85) 69.32,17.42 69.32,17.17 68.85,16.7 67.44,16.7 66.71,15.98 66.71,14 65.75,13.03 65.23,13.03 64.92,13.34 v2(64.92,13.56)
  BOTTOM w0.254: UH2.AN32 83.97,11.51 v2(83.38,12.09)
+3.3V_1.8V_PGPPA:
  vias: v1(118.77,12.93)
+3.3VDX_SSD: length 15.1
  TOP w0.254: v5(271.15,5.08) 270.8,5.42 v2(269.95,5.42)
  TOP w0.508: v2(269.32,22.43) 268.99,22.1 CD36.1 ; v2(269.34,5.42) 269.22,5.42 268.68,5.97 CD41.1 ; v2(269.84,13.54) 269.83,13.54 v2(269.2,13.54) 268.63,13.54 RD7.1 268.48,12.78 268.59,12.66 v5(268.59,11.05) 268.43,10.89 RD8.2 268.8,9.78 269.08,10.06 269.74,10.06 270.05,9.75 v2(270.05,9.47) ; v2(269.24,19.37) 269.24,19.81 268.99,20.07 CD38.1 CD39.1 ; CD40.1 268.75,4.64 269.49,4.64 269.95,5.09 v2(269.95,5.42)
  vias: v2(269.24,12) v2(269.84,12) v2(270.45,12) v2(278.51,10.67) v2(279.15,11.3) v2(279.15,10.67) v2(279.78,11.3) v2(279.78,10.67) v5(279.15,9.91)
+3V_PCH: length 336.6
  TOP w0.254: RH546.2 86.11,8.64 v2(86.03,8.72) ; CH204.1 CH82.1 90.3,7.06 90.97,7.73 RH5875.1
  TOP w0.356: UZ20.5 112.67,51.19 112.91,50.94 UZ21.5 112.54,50.71 112.41,50.58 112.41,50.14 v2(111.98,49.71)
  TOP w0.381: v2(115.8,50.68) 115.81,50.7 118.1,50.7 118.35,50.95 UZ12.5 ; LH1.1 91.71,7.39 91.37,7.73 RH5875.1 ; 89.14,5.54 RH503.1 87.94,5.54 87.68,5.79 RH505.1 87.42,5.88 RH501.1 86.27,5.88 RH504.1 ; 89.14,5.54 89.36,5.54 90.08,6.26 CH82.1 ; 89.14,5.54 RT5857.1 ; UZ31.5 249.81,50.53 250,50.34 v2(250,49.99) ; CH3321.1 87.86,10.25 87.96,10.15 v2(88.31,10.15) 88.81,10.15 RH523.1
  TOP w0.406: RZ84.1 120.51,60.76 120.24,60.48 UZ19.5
  TOP w0.457: v2(107.76,8.81) 107.76,8.81 108.06,8.81 108.48,9.24 RH566.1
  TOP w0.508: v2(258.64,7.24) 258.64,11.25 259.89,12.5 259.89,23.06 259.68,23.28 259.68,28.13 258.83,28.98 v2(258.83,31.43) ; v2(107.76,8.81) 107.76,8.65 109.27,7.14 109.27,7.03 ; RH524.1 102.31,5.54 101.98,5.21 ; v2(86.03,8.72) 86.03,8.13 RH130.1 86.18,8.12 86.49,7.81 86.49,6.61 86.06,6.17 RH504.1 ; v2(165.76,3.96) 165.76,4.32 167.93,6.49 167.93,7.96 164.99,10.91 162.37,10.91 161.72,11.56 161.72,12.84 160.95,13.62 154.32,13.62 RE86.1 ; RZ84.1 120.51,61.69 v2(119.5,62.71)
  IN2 w0.508: v2(178.32,5.61) 178.09,5.38 176.45,5.38 175.9,5.93 171.72,5.93 169.73,3.95 168.2,3.95 167.53,4.62 166.13,4.62 165.76,4.25 v2(165.76,3.96) ; v2(258.83,31.43) 257.37,31.43 253.94,34.87 253.94,41.21 251.28,43.87 251.28,48.19 250,49.47 v2(250,49.99)
  IN3 w0.508: v2(88.31,10.15) 87.73,10.15 86.3,8.72 v2(86.03,8.72) ; v2(69.44,15.37) 69.44,14.02 71.08,12.39 71.08,9.42 70.65,8.99 70.33,8.99 70.29,9.03 v2(70.27,9.03)
  IN4 w0.381: v2(100.85,3.04) 100.85,2.24 101.52,1.56 112.29,1.56 v2(112.94,2.21)
  IN4 w0.508: v2(88.38,19.5) 88.38,20.47 89.26,21.35 89.26,22.07 90.12,22.94 96.41,22.94 97.08,23.61 97.08,25.44 97.21,25.57 97.21,25.64 97.87,26.3 97.87,27.05 97.44,27.48 97.44,28.01 97.64,28.21 97.64,29.55 95.53,31.66 95.53,34.2 99.06,37.72 99.06,38.86 100.36,40.16 104.74,40.16 105.54,40.96 105.54,46.32 104.46,47.4 104.46,48.61 105.64,49.79 107.06,49.79 107.42,50.14 110.77,50.14 111.2,49.71 v2(111.98,49.71) 112.15,49.71 112.98,50.54 115.65,50.54 v2(115.8,50.68) 114.66,51.82 114.66,52.79 115.61,53.75 v2(116.4,53.75)
  IN5 w0.508: v2(178.32,5.61) 178.46,5.47 181.45,5.47 182.45,6.48 187.67,6.48 188.63,5.52 193.6,5.52 195.95,7.88 197.11,7.88 198.5,9.27 202.57,9.27 203.52,10.23 210.75,10.23 213.74,7.24 235.33,7.24 235.84,7.75 258.14,7.75 v2(258.64,7.24) ; v2(81.59,17.23) 81.03,17.23 80.21,16.42 75.86,16.42 75.64,16.21 73.62,16.21 73.32,16.51 71.1,16.51 69.95,15.37 v2(69.44,15.37) ; v2(88.31,10.15) 87.67,10.15 86.03,11.79 v2(85.9,11.79) 84.09,11.79 83.79,11.49 82.89,11.49 82.72,11.66 82.72,12.42 82.89,12.6 82.89,13.6 82.47,14.02 82.47,15.79 82.31,15.95 v2(82.28,15.95)
  BOTTOM w0.254: 87.38,10.67 87.58,10.47 88.02,10.47 88.31,10.18 v2(88.31,10.15) ; UH2.AT44 78.11,10.39 v2(78.11,10.92) 77.95,11.07 UH2.AN44
  BOTTOM w0.305: RH74.1 70.88,9.03 v2(70.27,9.03) ; v2(88.38,19.5) 88.38,19.47 88.02,19.12 UH2.V23 ; JAPS.1 178.62,6.24 178.47,6.09 178.47,5.77 v2(178.32,5.61)
  BOTTOM w0.33: v2(91.06,1.25) 90.91,1.4 RH110.2
  BOTTOM w0.356: RH571.2 105.36,10.08 105.86,9.58 RH458.1 107.15,9.58 107.76,8.97 v2(107.76,8.81)
  BOTTOM w0.381: v2(62.27,4.13) 62.46,3.94 RH586.2 ; RH5857.1 91.21,1.4 v2(91.06,1.25)
  BOTTOM w0.508: v2(119.5,62.71) 119.5,56.63 120.28,55.85 120.28,54.25 119.37,53.34 117,53.34 116.6,53.75 v2(116.4,53.75) ; v2(61.21,11.35) 61.14,11.42 61.14,12.29 RH585.2 60.75,12.69 DH2.2 ; RH513.2 69.7,15.62 v2(69.44,15.37)
  vias: v2(64.38,1.5) v2(64.95,1.5) v2(81.3,15.9) v2(95.25,7.88) v2(95.7,7.43) v2(96.32,2.62) v2(113.1,8.92) v5(59.73,9.45)
+3V_PCH_AZIO: length 1.8
  TOP w0.089: v1(91.82,5.02) 91.82,5.58 92.34,6.1
  BOTTOM w0.254: v2(92.72,6.65) 92.87,6.8 UH2.BB14
+3V_PCH_BR:
  vias: v1(56.3,3.26)
+3V_PCH_CT: length 2.9
  TOP w0.14: v1(54.26,2.27) 54.5,2.52 54.7,2.52 55.37,3.19 CZ20.1
  TOP w0.254: CZ20.1 55.37,3.76 55.44,3.83 UZ4.6
+3V_PCH_DSW: length 112.1
  TOP w0.381: RH515.2 75.44,7.11 74.85,6.53 74.85,5.24 v2(74.45,4.83) ; RH453.2 70.85,7.3 v2(70.13,7.3)
  TOP w0.508: v2(143.69,18.39) 143.69,18.09 146.48,15.29 146.48,14.99 ; v2(81.3,2.46) v5(80.34,1.5) 78.17,1.5 77.84,1.83 RH533.2 77.8,2.19 77.06,2.19 RH545.2 RH2.1 ; v2(129.16,18.33) 129.16,16.98 131.96,14.18 131.96,11.37 v2(133.02,10.31)
  IN5 w0.381: v2(114.92,2.22) 114.92,1.73 114.4,1.21 93.88,1.21 93.27,1.82 90.53,1.82 89.92,1.21 84.14,1.21 83.57,1.78 83.57,2.08 83.19,2.46 v2(81.3,2.46)
  IN5 w0.508: v2(74.45,4.83) 74.46,4.83 75.21,5.59 75.21,7.01 74.68,7.54 73.42,7.54 72.98,7.1 70.54,7.1 70.37,7.27 70.16,7.27 v2(70.13,7.3)
  IN6 w0.508: v2(115.4,5.54) 115.4,5.71 116.48,6.79 116.77,6.79 119.32,9.34 123.96,9.34 125.49,10.87 129.1,10.87 129.66,10.31 v2(133.02,10.31)
  BOTTOM w0.254: v2(74.45,4.83) 74.55,4.83 75.07,5.35 75.34,5.35 UH2.BE49 75.61,5.44 UH2.BE48
  BOTTOM w0.508: v2(115.4,5.54) 115.4,5.07 114.92,4.6 v2(114.92,2.22) ; v2(81.3,2.46) 81.34,2.41 RH5837.1 RH5842.2 ; v2(143.69,18.39) 143.02,17.72 141.73,17.72 141.68,17.78 139.95,17.78 139.89,17.72 129.77,17.72 v2(129.16,18.33) ; v2(74.45,4.83) 74.3,4.68 74.3,3.26 v2(73.75,2.72)
+3V_PCH_DSW_RR: length 1.9
  TOP w0.14: QH1.1 v1(141.86,10.53)
+3V_PCH_ME_SW: length 2.4
  TOP w0.14: SW4.1 113.32,4.76 113.02,5.07 112.4,5.07 111.98,5.49 RH536.2
+3V_PS8723: length 1.1
  TOP w0.381: v2(317.37,34.29) 317.63,34.04 RI22.2
  vias: v1(328.47,34.21) v2(318.19,37.75) v2(327.79,38.1) v2(327.79,37.21) v2(328.68,38.1) v2(328.68,37.21)
+3V_ROM: length 67.4
  IN3 w0.089: 82.49,1.97 82.42,1.91
  IN3 w0.508: 83.57,1.53 83.76,1.33 84.01,1.33 84.01,1.33 88.9,1.33 89.22,1.66 89.98,1.66 90.36,2.03 92.5,2.03 92.87,1.66 94.92,1.66 95.26,1.31 106.94,1.31 v2(108.4,2.77) ; 82.42,1.91 81.81,1.3 80.64,1.3 80.3,1.64 77.19,1.64 76.51,2.33 75.31,2.33 74.28,1.3 66.28,1.3 65.47,2.11 64.1,2.11 63.58,2.63 62.19,2.63 61.65,3.18 61.65,3.62 61.66,3.63 61.66,4.93 61.08,5.51 61.08,6.66 60.31,7.42 60.31,9.08 62.26,11.02 62.26,11.96 63.21,12.92 v2(64.07,12.92)
  BOTTOM w0.508: UH8.8 61.49,10.42 62.29,11.22 62.29,12.1 RH585.1 62.45,12.38 DH2.1 63.01,13.53 63.62,12.92 v2(64.07,12.92)
  vias: v1(108.41,3.71)
+3V_TBT: length 13.3
  TOP w0.356: RT21.1 32.4,48.55 RT202.1 32.45,48.03 v2(32.46,48.02)
  IN3 w0.254: 23.42,44.71 25.12,44.71 25.71,45.29 28.36,45.29 30.9,47.83 32.27,47.83 v2(32.46,48.02)
  BOTTOM w0.127: v1(18.09,40.96) 17.99,41.05 CT54.1
  BOTTOM w0.254: v2(24.76,40.87) UT1.H9
  vias: v2(20.58,44.3) v2(21.17,44.3)
+3V_TBT_S0: length 23.8
  TOP w0.089: v2(20.92,34.41) v1(20.92,33.87)
  TOP w0.254: v2(28.66,38.92) 28.66,39.2 CT163.1
  IN1 w0.508: v2(20.92,34.41) 21.52,35 26.77,35 27.41,34.37 v2(27.41,33.76)
  IN2 w0.508: v2(20.92,34.41) 20.89,34.37 20.18,34.37 18.97,33.16 16.71,33.16 15.79,34.07 15.79,36.58 15.14,37.23 15.14,40.36 v2(15.46,40.68)
  BOTTOM w0.254: UT1.R13 28.66,38.92 v2(28.66,38.92)
  BOTTOM w0.508: LT14.1 16.22,41.22 15.74,40.74 15.52,40.74 v2(15.46,40.68)
+3V_TBT_SPI: length 30.9
  TOP w0.14: RT15.1 CT47.1 39.52,24.07 v1(39.3,24.29) 39.04,24.55 v2(39.04,25.27) 39.04,26.44 RT16.1
  TOP w0.381: RT243.2 42.08,31.1 RT17.1 41.66,31.75 v2(41.48,31.57) ; v2(38.6,31.64) 38.75,31.64 38.82,31.71 RT18.1
  TOP w0.508: RT242.2 35.62,41.68 v2(36.52,41.68)
  IN1 w0.508: v2(41.48,31.57) 41.42,31.64 v2(38.6,31.64)
  IN5 w0.508: v2(36.52,41.68) 36.36,41.52 36.36,39.35 42.02,33.68 42.02,32.12 v2(41.48,31.57)
  BOTTOM w0.381: UT2.8 39.63,26.42 38.36,27.68 38.36,31.4 v2(38.6,31.64)
  BOTTOM w0.508: v2(39.04,25.27) 39.63,25.86 UT2.8
+3V_VC: length 205.4
  TOP w0.254: PU200.8 25.47,3.13 25.2,2.87 PC200.2
  TOP w0.381: PR231.1 27.37,19.69 v5(27.25,19.57) 25.91,18.23 ; v2(17.78,6.91) 18.13,6.91 18.37,7.15 PU203.8 ; PR248.2 24.77,15.03 24.03,15.77 PR259.1 23.96,16.55 v2(24.32,16.91) 24.43,16.91 25.33,17.81 25.5,17.81 25.91,18.23 ; 25.91,18.23 25.59,18.54 PC213.1 23.8,18.54 23.56,18.78 23.55,18.78 22.84,19.49 PU202.5 22.06,19.49 21.92,19.64 PR236.1 ; v2(29.39,12.13) 29.68,11.84 29.68,10.91 PR244.1
  TOP w0.508: v2(16.8,28.71) 16.43,28.34 PR246.2 ; PR251.1 22.86,5.34 23.24,4.95 23.24,3.43 23.81,2.87 v2(24.01,2.87) PC200.2 ; v2(77.78,31.14) 77.78,31.56 PR266.2 ; PR212.1 v2(34.79,1.93) ; v2(28.86,2.24) 29.51,1.6 PR208.1
  IN1 w0.508: v2(16.8,28.71) 16.8,29.76 17.34,30.3 17.34,33.52 v2(16.91,33.95)
  IN2 w0.508: v2(69.94,28.61) 70.09,28.75 74.76,28.75 75.46,29.45 76.42,29.45 77.78,30.8 v2(77.78,31.14)
  IN3 w0.508: v2(22.43,29.3) 22.43,28.84 21.96,28.37 17.12,28.37 16.8,28.69 v2(16.8,28.71)
  IN4 w0.508: v2(24.32,16.91) 24.29,16.88 24.29,15.42 24.68,15.03 25.3,15.03 28.19,12.13 v2(29.39,12.13)
  IN5 w0.508: v2(69.94,28.61) 65.6,28.61 64.86,27.86 49.87,27.86 48.77,26.76 48.77,23.62 49.11,23.28 49.11,20.97 49.75,20.33 52.62,20.33 53.05,20.76 v2(53.05,21.45) ; 16.59,24.11 14.94,22.45 14.94,20.35 17.17,18.11 18.85,18.11 20.12,16.84 20.12,15.62 18.45,13.95 18.45,7.52 17.83,6.91 v2(17.78,6.91) 21.83,2.87 v2(24.01,2.87) 28.24,2.87 v2(28.86,2.24) 31.15,2.24 31.55,2.64 34.08,2.64 v2(34.79,1.93) 34.79,2.06 35.27,2.54 37.31,2.54 37.69,2.16 42.23,2.16 42.75,2.69 44.85,2.69 51.03,8.87 55.25,8.87 56.02,9.64 56.02,10.17 56.57,10.72 56.57,12.55 56.11,13.01 55.19,13.01 54.76,13.44 v2(54.76,14.18) 55.53,14.18 57.63,16.28 59.46,16.28 60.22,17.04 60.37,17.04 60.48,17.15 v2(61.09,17.15) ; 16.59,24.11 16.4,24.29 16.4,28.31 v2(16.8,28.71) ; 16.59,24.11 17.55,24.11 19.24,22.42 19.24,19.88 20.58,18.54 26.16,18.54 27.81,16.9 27.81,13.71 v2(29.39,12.13)
  BOTTOM w0.254: PR224.2 18.85,29.72 18.98,29.85 19.56,29.85 19.85,29.57 22.16,29.57 v2(22.43,29.3)
  BOTTOM w0.381: PR274.2 60.61,19.79 60.27,19.45 60.27,19.16 v2(60.22,19.11) ; v2(16.91,33.95) 16.91,34.15 PC204.1 16.03,34.57 16.03,33.84 PU201.5 ; PR273.2 57.99,21.97 v2(58.41,21.54)
  BOTTOM w0.508: v2(53.05,21.45) 53.05,20.16 53.86,19.35 PR279.2
+3VA_TBT: length 23.3
  TOP w0.381: RT5848.1 RT5847.1 RT23.1 30,47.91 29.79,48.12 29.79,48.13 v2(29.4,48.52) ; v2(24.09,42.17) 24.18,42.09 24.18,41.64 CT143.1
  BOTTOM w0.203: v2(24.09,42.17) 24.42,41.85 UT1.F8
  BOTTOM w0.254: 18.37,52.73 18.39,52.71 19.15,52.71 19.85,52.01 21.02,52.01 21.59,51.44 23.88,51.44 24.51,50.8 24.51,49.51
  BOTTOM w0.305: 25.06,48.48 25.26,48.68 26.12,48.68 27.33,47.47 RT35.1 27.43,47.12 27.94,47.12 28.07,47.25 RT36.1 28.83,48.07 29.27,48.52 v2(29.4,48.52) 29.47,48.52 30.1,47.88 RT22.1
  BOTTOM w0.381: 17.78,52.58 17.18,53.18 RT167.1 ; 24.51,49.51 24.51,49.02 25.06,48.48 25.06,47.6 25.02,47.57 RT1145.1
  vias: v1(23.79,51.75) v2(20,50.02) v2(20.07,48.83) v2(22.16,49.28) v2(22.42,49.91)
+3VA_TBT_LC: length 28
  IN1 w0.254: v2(35.45,44.59) 34.61,44.59 33.26,45.94 32.45,45.94 31.66,45.15 31.31,45.15 30.42,46.04 30.42,48.02 29.92,48.52 29.92,48.88 29.34,49.47 28.53,49.47 25.96,52.03 24.93,52.03 24.54,51.64 24.54,49.46 25.46,48.54 25.46,47.36 26.12,46.69 26.12,45.37 25.91,45.16 25.91,44.92 28.65,42.18 v2(28.66,42.18)
  BOTTOM w0.203: UT1.R6 v2(28.66,42.18)
  vias: v5(35.99,44.48)
+3VALW: length 601
  TOP w0.254: v2(304.77,5.44) 304.77,4.99 305.2,4.55 306.56,4.55 306.82,4.81 UE5.5 ; v2(237.24,6.61) 236.73,6.1 236.73,4.89 236.02,4.18 UZ6.5 ; v2(220.66,120.14) 220.67,120.13 220.67,118.19 220.27,117.78 RV103.1 ; v2(164.54,120.97) 164.88,120.63 165.08,120.63 165.55,120.17 RV1809.1 ; v2(120.7,62.5) 121.38,63.18 UE7.5
  TOP w0.381: v2(121.67,65.03) 121.56,65.14 UZ22.5 ; v2(132.72,4.5) 132.72,5.39 133.25,5.92 PR506.1 133.09,6.18 130.82,6.18 130.28,6.72 130.28,8.5 131.14,9.36 133.88,9.36 134.52,10 134.52,10.45 133,11.98 v2(133,12.35) ; v2(108.89,53.89) 108.86,53.86 UZ23.5
  TOP w0.508: v2(122.04,55.87) 120.55,55.87 120.44,55.75 111.2,55.75 110.56,55.11 109.73,55.11 108.89,54.26 v2(108.89,53.89) ; PR258.2 PR257.2 27.77,12.45 v2(29.19,13.87) ; v2(51.21,21.31) 51.12,21.22 PR1926.1 ; v2(151.82,4.19) 150.78,3.16 148.19,3.16 147.78,3.57 147.78,6.05 147.49,6.34 147.49,6.91 144.81,9.59 141.06,9.59 139.31,11.33 139.31,11.7 ; v2(18.97,3.58) PR112.2 ; v2(7.21,32.67) 7.66,32.67 RA100.1 ; R5832.1 145.29,14.31 RH5864.1 144.49,14.22 144.25,13.97 143.78,13.97 143.19,13.39 142.44,13.39 142.05,13.78 141.64,13.78 QH1.3 ; RV111.1 254.26,43.78 v2(254.27,43.77) ; v2(20.73,90.17) 21.13,89.76 PR101.1 ; v2(313.53,12.31) 313.63,12.41 RZ1136.1 ; v2(203.2,12.45) 203.2,11.85 195.8,4.45 v5(195.56,4.45) 191.77,4.45 ; RH5867.2 136.15,13.59 137.22,12.51 ; RE52.1 288.84,4.99 288.84,3.47 288.44,3.07 283.36,3.07 283.1,3.34 RE56.1 283.1,4.79 v2(283.85,5.54) ; RZ1138.1 165.37,9.49 164.69,10.16 v2(164.23,10.16) ; PR1800.2 177.19,14.7 176.21,13.73 176.21,12.03 177.06,11.18 v2(177.06,10.85) ; PR715.1 182.12,120.41 v2(182.12,120.02) ; PR223.2 PR222.2 16.43,32.72 16.1,33.06 v2(15.78,33.06) ; RV12.1 253.95,51.26 253.47,50.78 v2(252.86,50.78) ; PR1643.1 247.91,106.07 v2(248.57,105.41) ; v2(348.74,117.23) CE15.1 349.51,119.19 UE2.2 ; v2(330.03,108) 330.57,107.46 RE3.1
  IN1 w0.508: v2(15.78,33.06) 15.78,32.67 15.72,32.62 15.72,28.68 15.65,28.61 15.65,22.71 16.26,22.1 19.84,22.1 19.94,22 19.94,19.04 21.46,17.52 21.46,15.86 23.45,13.87 v2(29.19,13.87)
  IN2 w0.508: v2(121.67,65.03) 120.7,64.06 v2(120.7,62.5) 120.7,60.27 119.64,59.2 119.64,56.44 120.22,55.86 122.03,55.86 v2(122.04,55.87) ; v2(104.22,66.45) 104.22,66.26 104.68,65.79 107.07,65.79 108.71,64.15 v2(108.71,64.09) 108.86,63.94 108.86,56.66 109.63,55.89 109.63,55 108.89,54.26 v2(108.89,53.89)
  IN2 w1.016: 81.73,32.73 81.73,32.74 81.73,32.83 79.86,34.7 73.01,34.7 71.46,33.15 69.37,33.15 68.73,32.51
  IN3 w0.508: v2(23.62,104.99) 22.86,104.23 22.86,98.41 23.81,97.46 v2(23.88,97.46) 22.45,96.04 22.45,91.9 v2(20.73,90.17) ; v2(29.19,13.87) 28.47,14.58 28.47,15.72 29.45,16.7 31.03,16.7 33.81,19.48 39.55,19.48 40.59,20.53 43.48,20.53 43.93,20.98 47.07,20.98 48.26,19.79 50.7,19.79 51.21,20.3 v2(51.21,21.31) ; v2(128.57,49.49) v2(128.57,25.27) ; v2(138.22,4.25) 137.36,4.25 135.89,5.72 133.94,5.72 v2(132.72,4.5)
  IN4 w0.254: v2(220.66,120.14) 220.67,120.13 220.67,120.09 221.12,119.65 221.82,119.65 222.16,119.99 224.12,119.99 225.3,118.81 225.3,115.44 226.02,114.71 228.53,114.71 231.1,112.14 237.11,112.14 237.62,112.65 v2(239.9,112.65) 240.74,111.81 241.78,111.81 242.7,110.9 v2(242.7,110.34) 242.82,110.34 244.74,108.42 246.11,108.42 246.9,107.64 247.89,107.64 248.62,106.9 248.62,105.47 v2(248.57,105.41) 248.57,104.04 v2(247.27,102.74) 247.27,101.56 248.18,100.65 248.18,95.33 248.82,94.69 248.82,93.83 251.02,91.63 251.02,79.59 248.97,77.55 245.9,77.55 244.43,76.07 244.43,72.01 246.38,70.05 249.81,70.05 250.77,69.09 250.77,58.5 251.11,58.16 251.11,55.55 252.67,53.99 252.67,50.97 v2(252.86,50.78)
  IN4 w1.016: 257.81,20 258.19,20.38 259.27,20.38 260.03,21.15 260.03,32.32 259.11,33.25 259.11,35.66 260.5,37.06 260.5,41.5 260.76,41.76 ; 80.37,31.73 79,31.73 78.7,32.02 77.19,32.02 76.21,31.05 76.21,30.1 74.28,28.17 72.67,28.17 69.5,25 69.5,24.21 68.47,23.18 67.74,23.18 66.7,22.14 66.7,20
  IN5 w0.254: v2(164.54,120.97) 164.77,120.97 166.14,119.6 172.43,119.6 173.48,120.65 175.34,120.65 176.71,119.28 181.57,119.28 182.12,119.83 v2(182.12,120.02) 183.01,120.91 187.9,120.91 188.6,120.21 189.38,120.21 190.08,120.91 193.04,120.91 194.69,119.25 198.12,119.25 199.77,120.91 208.15,120.91 208.66,120.4 215.39,120.4 215.94,120.94 220.26,120.94 220.66,120.54 v2(220.66,120.14)
  IN5 w0.508: v2(20.73,90.17) 19.91,90.17 19.17,89.43 16.57,89.43 15.21,88.07 15.21,87.41 14.27,86.47 13.76,86.47 13.56,86.27 13.56,78.36 13.92,78 13.92,76.86 11.9,74.85 11.9,70.65 14.11,68.44 14.11,60.86 15.62,59.35 15.62,56.65
  IN6 w0.381: v2(76.44,1.53) 76.44,1.75 75.92,2.26 75.4,2.26 74.68,1.54 67.65,1.54 67.46,1.73 67.46,3.76 66.38,4.84 66.38,5.16 v2(66.33,5.21)
  BOTTOM w0.203: PU900.15 240.66,112.77 240.41,112.52 PC912.1
  BOTTOM w0.254: PC812.1 109.32,64.34 109.32,63.97 108.84,63.49 PU800.15 ; v2(132.72,4.5) 132.72,4.36 PC512.1 132.21,3.92 132.21,4.67 132.64,5.11 PU500.15 ; PC1612.1 247.91,103.09 247.71,103.28 247.71,103.69 247.55,103.85 PU1600.15 ; v2(4.34,9.91) 3.72,10.53 3.72,11.02 4.34,11.64 UA3.4
  BOTTOM w0.305: v2(177.06,10.85) 177.06,8.99 177.62,8.43 JAPS.3 ; v2(175.36,10.87) 175.62,10.61 JAPS.7
  BOTTOM w0.381: v2(19.43,53.62) 19.25,53.62 18.8,53.16 17.98,53.16 17.81,53.34 17.81,53.85 17.76,53.9 16.97,53.9 16.63,54.24 RT1095.1
  BOTTOM w0.457: v2(16.49,51.13) 16.17,51.13 CT189.1 ; CI21.1 19.74,104.32 19.83,104.41 UI4.5 21.23,104.41 21.81,104.99 v2(23.62,104.99)
  BOTTOM w0.508: v2(242.7,110.34) 242.83,110.47 PR909.1 ; PC1612.1 247.73,101.93 247.27,102.39 v2(247.27,102.74) ; v2(122.04,55.87) 122.46,55.45 123.22,55.45 128.57,50.1 v2(128.57,49.49) ; RI31.1 RE275.2 v2(332.26,43.36) ; v2(138.22,4.25) 138.02,4.45 PR500.1 ; v2(23.88,97.46) RI5.1 22.84,97.46 22.41,97.88 22.41,98.77 23.01,99.37 RI4.1 ; PR1606.1 249.51,104.93 249.02,105.41 v2(248.57,105.41) ; PR807.1 104.06,66.3 v2(104.22,66.45) ; v2(108.71,64.09) 108.71,64.44 PC812.1 ; PC912.1 240.08,111.96 239.9,112.14 v2(239.9,112.65) ; v2(76.44,1.53) 78.91,1.53 RZ38.2 ; v2(326.48,42.72) RI30.1 ; RE141.1 152.05,4.78 151.82,4.55 v2(151.82,4.19) ; RI9.1 RI10.1 329.06,59.74 329.06,59.03 v2(328.96,58.93)
  vias: v2(10.96,5.29) v2(16.5,51.86) v2(56.94,6.92) v2(56.94,6.32) v2(66.38,19.15) v2(66.97,19.15) v2(68.13,31.62) v2(68.71,31.62) v2(81.24,31.78) v2(81.81,31.79) v2(137.4,11.79) v2(180.07,10.06) v2(180.67,10.06) v2(181.28,10.06) v2(181.87,10.06) v2(254.3,43.12) v2(256.96,19.11) v2(257.25,18.62) v2(257.54,19.11) v2(262.74,40.92) v2(263.2,40.51) v2(263.2,39.93) v2(275.08,12.57) v2(276.35,10.8) v2(276.35,10.16) v2(276.99,11.43) v2(276.99,10.8) v2(276.99,10.16) v2(321.58,28.09) v2(321.65,27.51) v2(321.93,28.64) v2(321.95,27) v2(322.23,27.67) v2(322.41,28.3) v2(322.54,29.06) v2(322.65,27.2) v2(323.01,28.27) v2(323.14,27.65) v2(323.16,28.85) v2(323.22,27.05) v2(324.74,53.09) v2(338.76,101.47) v2(338.76,100.89) v2(339.08,102.15) v2(340.36,57.74) v2(340.36,57.13) v2(341.1,88.65) v2(341.4,87.48) v2(341.96,88) v5(66.8,31.75) v5(138.69,12.19)
+3VALW_5105: length 79.6
  TOP w0.254: UE3.M9 302.97,16.97 303.35,17.34 305.04,17.34 v2(305.54,16.83) ; RP19.8 283.9,11.32 v2(283.66,11.56) 283.91,11.82 RP19.7 ; UE3.G8 298.54,15.75 295.43,15.75 295.05,15.37 UE3.B7 294.56,14.97 294.03,14.97 293.83,15.16 292.72,15.16 292.39,14.84 292.39,14.14 v2(292.48,14.05)
  TOP w0.305: CE20.1 300.51,7.12 300.51,8.67 300.15,9.03 300.15,9.78 299.76,10.17 UE3.H1 ; v2(301.77,10.95) UE3.K2
  TOP w0.381: v2(292.48,14.05) 292.33,14.05 292.2,14.17 CE26.1 ; v2(289.76,22.94) 289.79,22.91 RE25.2 ; v2(311.02,13.13) 310.72,12.83 RE300.1 ; v2(305.54,16.83) 305.54,18.16 305.58,18.19 305.58,18.3 305.88,18.61 CE24.1 ; RH5861.1 299.64,5.59 v2(300.2,6.15)
  TOP w0.406: v2(296.23,8.43) 296.29,8.43 296.98,7.74 CE25.1
  TOP w0.457: RE295.2 289.13,14.5 v2(289.13,14.96) 289.13,15.34 RE296.2 ; RE66.1 v2(302.62,6.06) ; v2(295.73,6.09) 295.73,6.12 295.92,6.32 295.92,6.62 RE72.1
  TOP w0.508: RE20.2 296.42,26.7 v2(296.97,26.15) 297.33,25.78 RE59.1 ; v2(308.12,11.16) 308.09,11.16 307.98,11.05 RE22.2 RE23.2 ; v2(294.52,6.2) RE145.1 RE294.2 RE293.2 ; RE67.2 301.76,23.8 v2(301.55,24) ; RE298.1 v1(301.44,30.1) 299.85,28.51 299.85,26.8 RE68.1 300.58,26.51 300.58,27.1 v2(300.61,27.13) ; v2(307.35,7.7) CE27.1 ; RE284.2 RE283.2 296.08,4.05 v2(297.66,4.05) ; v2(300.2,6.15) 300.2,6.81 CE20.1 ; v2(285.49,9.78) 286.06,9.22 RE95.2 ; v2(296.91,24.03) 297.18,23.77 RE99.2 296.77,23.32 RE21.2 ; v2(307.99,20.53) 307.99,20.96 307.8,21.15 RE41.1 ; RE71.1 303.95,23.48 v2(303.95,24.39) ; v2(283.97,8.45) RE94.2 ; RE301.1 v2(278.49,11.3) ; RE307.2 270.31,22.11 v2(269.97,22.45) ; v2(308.2,23.9) 308.05,23.75 RE19.2
  IN2 w0.457: v2(278.49,11.3) 278.49,11.66 278.77,11.94 281.05,11.94 282.11,10.88 283.19,10.88 283.66,11.35 v2(283.66,11.56)
  IN4 w0.508: 288.8,22.76 288.66,22.62 278.1,22.62 277.93,22.45 v2(269.97,22.45)
  vias: v2(308.8,16.89) v2(311.41,27.78) v2(312.11,27.79) v2(312.71,27.82)
+3VALW_5105_VTR_PLL: length 5.1
  TOP w0.254: 298.02,9.02 298.16,9.16 UE3.F1
  TOP w0.381: 298.02,9.02 CE19.1 298.25,7.24 CE18.1 RH5861.2
+3VALW_KB: length 3.4
  TOP w0.508: RZ1138.2 163.91,8.93 162.79,8.93 v5(162.73,8.99) 162.71,8.99 162.53,9.17 v2(162.53,9.57)
  BOTTOM w0.305: JKB.3 162.3,9.8 v2(162.53,9.57)
+3VALWP: length 44.5
  TOP w0.254: v2(348.87,24.07) PR401.1
  IN6 w0.254: v2(348.87,24.07) 348.74,24.19 348.74,25.4 347.73,26.42 347.73,30.61 345.38,32.96 330.09,32.96 328.33,31.2 328.33,27.29 326.01,24.96 326.01,24.89 v2(325.95,24.83)
  BOTTOM w0.254: PR428.1 345.5,24.91 347.08,26.48 349.25,26.48 349.57,26.16 349.57,24.77 v2(348.87,24.07) 348.88,24.05 PC401.1
  vias: v5(328,28.89)
+3VLP: length 117.1
  TOP w0.508: RE304.1 281.43,12.66 281.83,12.26 v1(281.83,11.01) 281.83,10.27 282.46,9.64 282.46,8.07 282.24,7.85 282.23,7.85 281.69,7.3 D322.2 281.69,6.83 282.03,6.83 282.51,6.35 282.51,5.53 282.4,5.41 282.4,4.51 281.17,3.28 v2(279.57,3.28) ; v2(293.63,3.1) 293.63,4.01 RE43.2
  IN1 w0.508: v2(349.57,23.05) 349.57,24.34 348.26,25.64 348.26,32.23 347.72,32.77 341.1,32.77 340.66,32.34 330.33,32.34 328.9,30.9 328.9,27.14 328.04,26.29 324.77,26.29 318.76,20.28 317.9,20.28 315.27,17.64 315.27,16.37 314.69,15.8 314.69,13.31 315.5,12.5 315.5,8.12 314.67,7.28 314.67,5.42 313.21,3.96 311.74,3.96 311,3.23 307.14,3.23 305.18,3.23 304.45,3.96 302.27,3.96 301.4,3.1 293.79,3.1 293.79,3.1 v2(293.63,3.1)
  IN2 w0.508: v2(293.63,3.1) 293.63,3.75 293.47,3.91 289.72,3.91 289.09,3.28 279.58,3.28 v2(279.57,3.28)
  BOTTOM w0.254: v2(349.57,23.05) 349,22.48 PR400.1
+3VLP_EC: length 10.3
  TOP w0.14: RE44.1 294.49,4.07 RE43.1 293.6,5.11 293.88,5.39 293.88,6.12 293.69,6.32 292.26,6.32 291.96,6.62 v1(291.96,7.84) 293.35,9.23 294.03,9.23 294.96,10.16 UE3.B1
+3VLP_P: length 2.5
  TOP w0.14: RH590.2 280.8,8.26 281.08,8.53 D322.1 281.69,9.53 v1(281.71,9.55)
+3VS: length 657
  TOP w0.254: PR1114.1 113.92,113.16 v2(113.86,113.22)
  TOP w0.356: PR852.1 105.15,60.01 105.15,59.51 105.37,59.28 106,59.28 v2(106.1,59.39) ; RH5840.2 79.69,10.99 80.33,10.35
  TOP w0.381: v2(200.14,119.89) 199.18,119.89 PR703.1 ; v2(98.96,32.81) 98.46,32.81 98.08,33.19 RE100.1 ; QE18.5 285.68,7.37 285.93,7.62 v2(286.18,7.62) 286.4,7.62 286.65,7.37 QE18.2 287.83,7.37 RE137.1 ; RE81.1 v2(101.92,36.49)
  TOP w0.457: RE136.1 284,9.17 284,9.63 v2(283.82,9.81)
  TOP w0.508: v2(187.45,114.81) 189.15,114.81 PR705.2 ; RE137.1 288.16,7.69 288.39,7.46 288.77,7.46 v2(288.8,7.43) ; v2(249.38,115.83) 247.7,115.83 247.57,115.95 PR951.1 ; v2(64.6,4.4) 64.61,4.39 64.71,4.39 65.34,3.76 RH572.2 ; v2(121.99,54.29) 121.85,54.29 121.4,54.74 RH525.1 ; RH563.1 103.69,2.41 v2(103.82,2.54) 104.3,2.54 105.58,3.82 RH561.1 RH562.1 105.58,7.41 103.82,9.16 ; 242.24,16.68 228.49,16.68 RD6.1 ; RE129.1 159.93,12.17 v2(161.11,12.17) ; v2(240.18,41.87) 240.32,41.87 240.92,42.47 240.92,42.9 RV1133.2 241.67,43.65 241.67,44.96 RF1.1 ; RD3.1 152.93,18.31 153.52,17.73 154.23,17.73 154.47,17.97 ; 79.12,6.38 79.12,5.07 78.63,4.57 78.63,3.65 79.54,2.74 80.7,2.74 81,3.05 81.04,3.05 81.05,3.05 81.54,3.05 81.55,3.05 81.59,3.05 82.44,2.2 82.44,1.93 v2(82.87,1.5) ; v2(250.31,26.4) 250.71,25.99 CD35.1 CD34.1 ; 154.47,17.97 154.47,17.91 154.84,17.54 159.67,17.54 162.33,14.87 v2(162.33,12.17) ; 154.47,17.97 v2(154.47,18.37) ; v2(294.04,28.38) 293.35,27.69 292.23,27.69 292.04,27.88 PR609.1 ; RV658.1 204.97,43.96 209.79,43.96 v2(210.64,44.81) ; RH569.2 99.49,8.41 100.37,8.41 100.61,8.16 101.7,8.16 101.89,8.36 ; RF3.1 v2(238.44,45.52) ; v2(25.81,64.42) 25.91,64.52 RM15.2 ; v2(113.82,53.69) 113.82,53.49 113.31,52.99 111.48,52.99 110.35,51.85 104.52,51.85 103.75,51.08 103.75,43.39 105.46,41.67 105.46,40.03 v2(101.92,36.49)
  IN1 w0.508: 193.42,118.62 198.25,118.62 199.52,119.89 v2(200.14,119.89) 200.14,120.26 200.51,120.63 207.86,120.63 208.47,120.02 218.8,120.02 219.43,119.39 221.47,119.39 222.1,120.02 223.54,120.02 224.37,119.18 224.77,119.18 225.24,118.71 225.24,117.8 225.55,117.5 225.55,115.2 226.17,114.58 228.85,114.58 231.03,112.4 236.02,112.4 236.48,111.94 246.66,111.94 247.9,113.18 247.9,114.35 v2(249.38,115.83) ; 193.42,118.62 193.42,118.37 192.25,117.19 ; 193.42,118.62 192.56,119.48 v2(191.51,119.48) ; v2(120.28,91.36) 120.28,90.71 120.64,90.36 121.38,90.36 122.8,91.77 122.8,93.06 124.15,94.41 v2(124.15,94.64) ; 190.37,115.95 189.23,114.81 v2(187.45,114.81) 187.45,116.46 186.31,117.6 184,117.6 182.58,116.18 181.92,116.18 181.33,116.77 175.88,116.77 v2(174.99,115.88)
  IN2 w0.508: v2(124.15,94.64) 123.91,94.64 123.25,95.31 122.7,95.31 121.45,96.56 120.41,96.56 120.02,96.17 117.96,96.17 117.36,96.76 115.72,96.76 115.19,97.3 115.19,100.09 114.57,100.71 114.57,101.75 114.97,102.16 114.97,102.92 113.86,104.04 v2(113.86,113.22) ; v2(25.81,64.42) 24.88,65.34 22.56,65.34 21.3,66.6 19.99,66.6 19.38,65.99 17.42,65.99 16.77,65.33 16.77,63.95 16.26,63.44 16.26,58.32 15.88,57.94 15.88,50.62 16.26,50.24 16.26,45.26 16.79,44.73 16.79,44.32 16.79,44.31 ; v2(113.82,53.69) 114.61,53.69 116.14,55.22 117.73,55.22 118.66,54.29 v2(121.99,54.29) ; v2(255.79,3.81) 256.5,3.81 256.63,3.94 262.51,3.94 263.68,5.11 266.34,5.11 267.11,4.34 v2(267.11,3.34)
  IN2 w0.762: 50.25,22.19 50.11,22.05 49.45,22.05 48.67,21.26 33.69,21.26 32.72,22.23 32.72,23.12 30.05,25.78 27.24,25.78 24.42,28.6 24.42,28.73 23.1,30.05 23.1,33.48 21.38,35.21 19.94,35.21 19.22,34.49 18.51,34.49 17.68,35.32 17.68,35.89 15.96,37.6 15.96,40.01 16.2,40.25 16.2,42.71 16.21,42.71
  IN3 w0.508: v2(161.11,12.17) v2(162.33,12.17) ; v2(64.6,4.4) 64.6,4.39 64.39,4.39 64.03,4.75 64.03,5.95 66.23,8.16 66.23,9.09 66.73,9.59 67.57,9.59 68.71,10.73 68.71,17.54 v2(68.35,17.89) ; v2(288.8,7.43) 288.62,7.61 286.18,7.61 v2(286.18,7.62)
  IN4 w0.508: v2(249.38,115.83) 249.38,115.77 250.08,115.08 250.08,107.16 249.33,106.41 249.33,103.65 248.85,103.18 248.85,95.69 249.63,94.91 250.32,94.91 251.56,93.67 251.56,58.39 251.61,58.34 251.61,55.73 254,53.34 254,49.7 256.01,47.69 256.01,44.35 ; v2(120.28,91.36) 120.07,91.57 115.5,91.57 113.8,93.28 113.21,93.28 113.01,93.07 112.01,93.07 111.57,92.63 106.27,92.63 105.23,91.6 105.23,84.08 104.68,83.53 104.68,82.44 105.74,81.38 105.74,78.82 104.78,77.86 104.78,70.21 106.72,68.26 106.72,59.88 106.23,59.39 v2(106.1,59.39) 106.1,58.5 106.17,58.42 106.17,55.2 108.94,52.43 111.82,52.43 111.82,52.45 112.51,53.14 113.46,53.14 113.87,53.54 113.87,53.64 v2(113.82,53.69) ; v2(57,29.8) 57,26.49 56.35,25.85 54.11,25.85 51.77,23.51 51.04,23.51
  IN5 w0.508: 334.29,52.39 334.29,51.52 334.05,51.28 v2(333.49,51.28)
  IN5 w0.762: 51.78,23.62 61.01,23.62 61.41,23.23 61.41,22.3 62.05,21.65 64.59,21.65 64.99,21.26 70.91,21.26 70.97,21.32 v2(71.03,21.32)
  IN5 w1.016: 349.2,40.06 349.2,42.06 338.87,52.39 331.36,52.39 330.76,51.79 325.5,51.79 324.74,51.03 323.69,51.03 322.45,49.8 322.45,48.64 321.44,47.63 321.44,46.23
  IN6 w0.508: v2(103.82,2.54) 103.75,2.47 100.42,2.47 99.8,3.1 99.8,3.58 99.46,3.91 99.39,3.91 98.71,4.6 97.71,4.6 97.43,4.32 96.14,4.32 96.05,4.41 93.82,4.41 93.32,3.92 92.61,3.92 92.53,3.99 91.75,3.99 91.21,3.45 91.21,3.39 90.63,2.81 89.61,2.81 v2(89.51,2.91) ; v2(64.6,4.4) 64.6,4.39 64.4,4.39 63.28,3.27 v2(62.42,3.27)
  BOTTOM w0.305: JKB.4 161.8,11.37 161.11,12.05 v2(161.11,12.17) ; 249.18,27.85 249.18,26.74 249.52,26.4 v2(250.31,26.4) ; v2(172.76,29.25) 172.89,29.12 172.89,28.86 JDIMM1.255
  BOTTOM w0.356: v2(333.49,51.28) 333.54,51.23 RE101.1 ; v2(103.63,10.41) 102.98,10.41 RH1146.2 RH91.1
  BOTTOM w0.381: QH4.5 107.91,10.16 v2(107.72,10.36) ; RH510.2 69.89,14.86 69.76,14.73 69.19,14.73 68.81,15.11 ; v2(333.49,51.28) 331.22,51.28 329.77,49.84 329.77,47.78 330.91,46.64 332.3,46.64 333.3,47.64 RE83.1 ; 68.81,15.11 68.81,15.84 69.32,16.35 69.59,16.35 69.74,16.5 RH512.2 ; 68.81,15.11 68.3,15.11 68.19,15.23 67.77,15.23 67.29,14.75 RH527.2 ; PR1019.2 173.14,114.01 173.33,113.82 173.71,113.82 174.35,114.45 174.35,115.24 v2(174.99,115.88) ; UH14.5 62.09,3.44 62.24,3.29 62.41,3.29 v2(62.42,3.27) ; v2(191.51,119.48) 191.19,119.48 PR1522.2
  BOTTOM w0.457: v2(124.15,94.64) 123.77,94.64 123.5,94.92 RH5.1 ; DV12.5 56.51,29.07 57,29.57 v2(57,29.8)
  BOTTOM w0.508: v2(267.11,3.34) 267.11,3.59 267.76,4.24 272.83,4.24 273.15,3.91 280.04,3.91 280.67,3.28 288.33,3.28 288.79,3.74 288.79,4.07 ; RH527.2 66.74,17.22 v2(67.84,18.33) ; v2(255.79,3.81) 256,3.81 256.27,4.08 RD10.1
  vias: v2(15.89,44.28) v2(15.89,43.58) v2(50.11,22.95) v2(50.69,22.95) v2(87.63,1.97) v2(94.62,28.46) v2(95.26,28.57) v2(105.33,29) v2(105.35,28.12) v2(105.87,28.59) v2(111.16,10.5) v2(169.93,18.42) v2(170.54,18.41) v2(242.05,18.35) v2(242.63,18.35) v2(243.59,42.29) v2(244.35,18.34) v2(252.72,24.28) v2(252.72,23.6) v2(257.05,42.8) v2(257.05,42.17) v2(257.56,42.48) v2(300.23,31.75) v2(300.83,31.76) v2(307.21,34.16) v2(307.85,34.16) v2(323.85,43.69) v2(323.85,43.05) v2(349.25,37.36) v2(349.25,36.77) v5(68.73,19.74)
+3VS_AUDIO: length 23.6
  IN5 w0.254: v2(5.08,46.74) 4.05,46.74 3.55,46.24 3.55,38.36 2.45,37.26 2.45,35.56 3.3,34.71 3.3,31.23 4.43,30.09 v2(4.43,28.2)
  BOTTOM w0.356: RA17.1 4.04,28.82 4.43,28.43 v2(4.43,28.2)
  BOTTOM w0.381: RA82.1 4.97,45.53 5.08,45.64 v1(5.08,46.18) v2(5.08,46.74)
  vias: v2(4.43,27.61) v2(12.57,7.8) v2(12.57,7.21) v2(15.06,16.31) v2(15.65,16.31)
+3VS_CAM: length 10.8
  IN1 w0.508: v2(55.63,32.39) 57.15,33.91 v2(57.15,34.47)
  BOTTOM w0.254: v2(57.15,34.47) 57.23,34.55 JEDP1.22
  BOTTOM w0.508: v2(55.63,32.39) 55.63,31.61 v1(55.32,31.31) 55.32,30.23 CV183.1 55.17,29.29 55.04,29.16 CZ44.1 53.71,29.16 CV184.1 53.23,29.15 53.14,29.24 RZ37.2
+3VS_CAM_R: length 5.4
  BOTTOM w0.14: v1(56.69,26) 56.63,25.93 QZ9.1
  BOTTOM w0.508: RZ37.1 52.58,27.05 53.7,25.93 QZ9.1
+3VS_CR: length 2.2
  BOTTOM w0.203: 336.74,36.45 336.95,36.45 337.49,36.99 UR1.11
  BOTTOM w0.457: 336.74,36.45 335.92,36.45
  vias: v1(346.9,34.93) v2(332.26,37.72) v2(332.26,37.14) v2(346.65,36.13) v2(346.65,35.43)
+3VS_CT2: length 1.8
  TOP w0.14: UZ1.10 260.02,39.32 259.08,40.26 CZ6.1
+3VS_DTH: length 45.1
  TOP w0.254: RM16.1 25.71,67.54 25.71,66.5 26.04,66.17 ; RM20.1 25.01,64.92 24.42,65.51 23.97,65.51 23.82,65.65 23.21,65.65 22.37,66.49 RM6.1
  TOP w0.356: RM7.1 27.23,95.2 26.67,95.76 v1(24.36,95.76) v2(23.75,95.76)
  TOP w0.381: 26.29,65.91 26.29,65.53 25.88,65.13 25.44,65.13 RM20.1 ; RM5.2 27.23,78.34 27.59,78.7 28.1,78.7 28.47,78.32 v2(28.47,78.08)
  IN3 w0.508: v2(28.5,68.71) 28.5,68.91 27.69,69.72 27.69,77.45 28.32,78.08 v2(28.47,78.08) 28.47,79.26 27.89,79.85 27.89,83.57 28.09,83.77 28.09,94.36 26.7,95.76 v2(23.75,95.76)
+3VS_FFS: length 3
  TOP w0.254: UF1.9 235.32,48 v2(235.08,47.75) 235.33,47.5 UF1.10 ; UF1.2 237.61,48 v2(237.87,48.26) 237.63,48.5 UF1.3
  vias: v1(239.59,47.4) v2(239.78,47.88) v2(240.32,47.65)
+3VS_FP: length 3.9
  TOP w0.14: v2(314.07,32.39) v5(313.25,33.21)
  BOTTOM w0.14: Q6.2 312.12,33.28 314.07,33.28
+3VS_FP_R:
  vias: v5(317.37,26.67)
+3VS_TP: length 35.8
  TOP w0.127: QE2.2 v5(196.87,9.98)
  TOP w0.254: RE9.2 196.5,14.07 196.87,13.71 QE2.5
  TOP w0.381: QE2.5 196.87,12.75 196.63,12.52 v2(196.63,12.41) 196.63,12.03 196.87,11.8 QE2.2
  IN5 w0.508: v2(190.76,12.42) 191.62,13.29 196.22,13.29 196.63,12.87 v2(196.63,12.41)
  BOTTOM w0.508: v2(190.76,12.42) 190.65,12.52 190.65,14.07 190.93,14.35 RE26.1 ; RE24.1 195.76,14.35 196.63,13.48 v2(196.63,12.41) 196.63,11.78 195.8,10.95 194.06,10.95 189.97,6.86 v2(189.61,6.86) 188.3,8.17 185.78,8.17 185.51,8.43 185.51,9.77 186,10.26 JTP.8
+3VS_TPM_VHIO: length 27.8
  TOP w0.14: v1(157.86,8.71) 157.76,8.81 v2(157.76,9.32)
  TOP w0.254: v2(157.76,9.32) 157.76,9.37 157.63,9.5 U32.8 ; U32.22 151.08,7 150.8,6.72 v2(150.51,6.72)
  TOP w0.381: v2(150.51,6.72) 150.15,6.35 150.07,6.35 CE85.1 149.81,6.09 CE84.1
  TOP w0.508: RE129.2 CE76.1 158.18,10.3 158.56,9.92 158.56,9.54 CE75.1 158.34,9.32 v2(157.76,9.32)
  BOTTOM w0.508: v2(157.76,9.32) 158.48,9.32 159.79,8.01 159.79,4.37 158.62,3.2 152.31,3.2 151.86,2.76 151.15,2.76 150.51,3.39 v2(150.51,6.72)
+3VS_TPM_VSB: length 10.4
  TOP w0.127: v2(158.5,4.83) v1(158.5,4.26)
  TOP w0.254: U32.1 158.52,6 CE11.1
  TOP w0.381: v2(158.5,4.83) 158.5,5.45 158.55,5.5 CE11.1
  BOTTOM w0.508: v2(158.5,4.83) 154.06,4.83 RE141.2 CE83.1
+3VS_TS: length 11.8
  IN6 w0.508: v2(350.01,60.07) 349.12,60.07 348.26,59.21 v2(344.98,59.21)
  BOTTOM w0.127: v5(351.19,61.39) 350.61,60.81 C3003.1
  BOTTOM w0.381: v2(341.38,46.36) 341.63,46.1 RH5891.2
  BOTTOM w0.508: RC184.1 RC183.1 v2(341.31,41.78) ; RC5835.1 345.95,46.41 C3004.1 JTS1.1
  vias: v2(344.27,59.18)
+3VS_VDD: length 8.7
  TOP w0.203: CE3323.1 202.57,52.01 203.07,52.52 203.84,52.52
  TOP w0.508: RV658.2 202.27,46.65 202.27,48.69 v1(202.29,48.71) 202.29,51.09 202.5,51.31 202.5,51.93 CE3323.1
+3VS_WLAN:
  vias: v2(330.84,95.72) v2(330.84,95.06) v2(330.84,94.28) v2(345.37,89.52) v2(345.47,88.89) v2(346.04,89.53) v2(346.06,88.9) v5(334.95,96.57) v5(345.35,92.01) v5(345.76,90.04)
+5V_CHGUSB_1: length 3.8
  BOTTOM w0.127: CI17.1 331.43,70.63 329.76,72.3 v5(329.76,73.13)
  vias: v2(332,68.95) v2(332.01,68.37) v2(331.99,67.78) v2(331.99,67.2) v2(331.99,66.61)
+5V_CHGUSB_2: length 0.6
  TOP w0.127: v2(27.33,101.99) v5(26.72,101.99)
  vias: v2(19.01,107.82) v2(19.2,109.2) v2(19.59,107.86) v2(20.17,107.85) v2(20.75,107.85) v2(27.49,101.42) v2(27.78,100.87) v2(27.95,101.82) v2(28.2,101.3)
+5VALW: length 306.3
  TOP w0.127: v5(314.62,7.6) 314.62,7.54 v2(315.28,6.88)
  TOP w0.203: v2(10,5.03) 10,5.1 9.49,5.61 UA4.4 ; UZ1.4 263.47,38.92 v2(263.53,38.86)
  TOP w0.254: UZ4.4 54.94,7.42 54.74,7.62 CZ11.1 ; v2(193.56,6.85) 193.56,6.49 193.11,6.04 UE6.4 ; v2(123.98,16.39) 125.57,16.39 126.49,15.47 UZ29.4 ; 191.01,42.67 190.5,42.17 188.09,42.17 187.4,42.86 UZ16.3 ; v2(230.51,9.91) 231.19,9.22 UZ33.4 ; v2(250.32,53.72) 246.44,53.72 245.67,52.95 UZ30.4 ; v2(338.7,104.4) 338.67,104.36 UN3.4
  TOP w0.305: CZ97.1 180.82,87.08 180.82,86.09 180.27,85.53 UZ15.3
  TOP w0.457: CI1.1 27.85,95.92 v2(28.35,96.42)
  TOP w0.508: v2(348.18,106.72) 348.21,106.69 LED1.2 ; LED4.2 v2(348.13,95.89) ; 288.04,25.68 288.92,25.68 289.02,25.77 PR603.1 ; 288.04,25.68 v2(288.04,25.67) ; 288.04,25.68 288.04,26.31 288.69,26.97 288.69,27.64 v2(288.8,27.75) ; PR104.2 25.35,86.96 26.82,88.43 26.82,89.07 25.63,90.26 25.48,90.26 24.56,91.17 v2(23.55,91.17) ; CZ11.1 54.43,8.38 v2(53.98,7.93) ; LED5.2 v2(348.11,92.29) ; v2(184.53,112.02) 184.99,111.56 187.56,111.56 PR700.2 ; LED3.2 v2(348.2,99.49) ; LED2.2 v2(348.12,103.09) ; 191.01,42.67 191.77,43.44 191.77,45.94 190.59,47.12 189.32,47.12 186.74,49.7 v2(186.74,51.52) ; RV657.1 v2(247.75,47.12) ; v2(179.87,86.55) 180.02,86.55 180.37,86.89 180.37,87.09 CZ97.1
  IN2 w0.508: v2(249.49,94.2) 249.49,94.46 247.91,96.05 247.91,105.87 247.24,106.53 247.24,107.41 246.43,108.23 246.43,109.56 247.59,110.72 v2(248.91,110.72)
  IN4 w0.508: v2(208.81,48.72) 208.62,48.91 208.62,50.42 206.91,52.13 205.21,52.13 203.34,50.27 202.44,50.27 201.15,51.56 195.3,51.56 190.23,56.63 v2(190.23,59.96) 190.23,60.6 187.86,62.96 181.32,62.96 180.96,63.33 180.96,64.15 181.32,64.5 181.32,76.19 182.21,77.08 182.21,80.12 180.56,81.77 180.56,85.95 179.96,86.55 v2(179.87,86.55) ; v2(248.91,110.72) 248.91,110.78 248.11,111.58 248.11,114.33 244.45,117.98 242.23,117.98 240.46,116.21 235.84,116.21 233.81,118.24 229.74,118.24 229.11,118.87 227.59,118.87 225.64,120.82 215.94,120.82 215.39,120.27 208.66,120.27 208.03,120.91 199.75,120.91 197.97,119.13 194.06,119.13 192.28,120.91 190.18,120.91 188.28,119 183.15,119 181.43,117.28 181.43,116.52 181.99,115.95 182.5,115.95 183.14,116.59 184.02,116.59 184.53,116.08 v2(184.53,112.02)
  IN5 w0.508: v2(190.23,59.96) 190.23,55.43 186.74,51.94 v2(186.74,51.52)
  IN5 w1.016: v2(249.49,94.2) 249.49,92.17 251.32,90.34 251.32,78.79 250.57,78.04 245.94,78.04 244.29,76.39 244.29,71.69 245.75,70.23 250.64,70.23 251.21,69.66 251.21,57.02 251.52,56.71 251.52,55.69 ; 252.16,53.72 252.35,53.72 254.83,51.25 254.83,47.18
  BOTTOM w0.203: v2(288.8,27.75) 288.67,27.88 PU600.12
  BOTTOM w0.254: UZ5.4 340.64,62.92 340.44,63.12 340.44,63.32 340.69,63.58 v2(340.95,63.58)
  BOTTOM w0.305: v2(163.17,9.58) 163.3,9.71 JKB.1 ; CZ86.1 181.62,84.57 181.82,84.37 UZ9.3
  BOTTOM w0.508: v2(288.04,25.67) 288.04,25.78 288.17,25.91 PC607.2 ; CZ86.1 181.04,84.57 180.56,85.05 180.56,86.02 180.02,86.55 v2(179.87,86.55)
  vias: v2(10.25,3.92) v2(10.19,2.67) v2(10.26,3.3) v2(27.73,52.82) v2(27.83,51.12) v2(27.85,52.26) v2(27.85,51.69) v2(28.08,50.61) v2(28.27,98.03) v2(28.3,97.26) v2(28.45,52.28) v2(28.44,51.7) v2(28.45,51.13) v2(28.72,97.66) v2(28.73,96.86) v2(28.67,50.6) v2(31.62,11.95) v2(31.62,11.31) v2(31.62,10.68) v2(31.62,10.04) v2(31.62,9.39) v2(31.62,8.76) v2(31.62,8.13) v2(31.62,7.49) v2(31.62,6.86) v2(32.2,12.58) v2(32.2,11.95) v2(32.2,11.31) v2(32.2,10.68) v2(32.2,10.04) v2(32.2,9.39) v2(32.2,8.76) v2(32.2,8.13) v2(32.2,7.49) v2(32.2,6.86) v2(32.78,10.68) v2(32.78,10.04) v2(32.78,9.39) v2(32.78,8.76) v2(32.78,8.13) v2(33.37,10.68) v2(33.37,10.04) v2(33.37,9.39) v2(33.37,8.76) v2(34,10.04) v2(34,9.39) v2(34.64,10.04) v2(183.15,10.07) v2(209.41,48.52) v2(229.36,12) v2(230,12) v2(230.63,12) v2(247.78,46.48) v2(263.7,37.79) v2(263.73,37.15) v2(264.28,37.8) v2(264.32,37.18) v2(315.28,6.24) v2(315.28,5.58) v2(315.28,4.95) v2(315.28,4.28) v2(315.32,3.69) v2(315.38,3.11) v2(315.91,6.9) v2(315.91,6.27) v2(315.91,5.61) v2(315.91,4.97) v2(315.91,4.31) v2(315.96,3.72) v2(316.02,3.14) v2(316.53,6.89) v2(316.53,6.26) v2(316.53,5.6) v2(316.53,4.96) v2(316.53,4.3) v2(316.57,3.71) v2(316.63,3.13) v2(332.03,62.56) v2(332.02,59.62) v2(332.06,61.98) v2(332.06,61.39) v2(332.06,60.81) v2(332.08,60.2) v5(9.6,2.87) v5(229.62,11.05)
+5VALWP: length 57.9
  TOP w0.508: v2(349.56,19.43) PR402.2
  BOTTOM w0.254: PC402.2 349.56,19.58 v2(349.56,19.43) 348.98,18.86 348.98,11.85 345.29,8.15 345.29,6.75 341.64,3.1 326.42,3.1 v2(325.96,3.56)
  BOTTOM w0.508: v2(341.89,20.45) 341.35,20.45 340.78,19.88 340.78,18.64 338.83,16.69 332.42,16.69 330.18,14.45 330.18,9.83 v2(330.91,9.1)
  vias: v1(326.82,3.76) v2(319.23,5.16) v2(319.25,4.5) v2(319.25,3.81) v2(319.81,5.72) v2(320.12,3.53) v2(320.55,5.72) v2(320.98,3.53) v2(321.13,5.72) v2(321.74,3.56) v2(322,5.72) v2(322.58,3.53) v2(322.91,5.72) v2(323.32,3.53) v2(323.8,5.72) v2(324.18,3.53) v2(324.77,5.72) v2(325.07,3.56) v2(325.65,5.69) v2(325.96,4.17)
+5VS: length 270.1
  TOP w0.508: v2(232.91,44.56) 232.93,44.54 RF2.1 ; v2(20.52,92.58) 20.73,92.38 v5(20.73,91.59) 20.3,91.16 19.48,91.16 19.11,91.54 UV16.1 v2(20.02,91.95) ; v2(103.8,40.88) 102.61,42.07 102.61,46.93 102.42,47.12 102.42,49.27 102.61,49.46 102.61,53.88 102.26,54.23 102.26,56.95 103.11,57.8 103.11,60.76 103.24,60.89 103.24,62.42 103.43,62.61 103.43,69.52 103.7,69.8 v2(103.92,69.8) ; v2(161.13,18.37) 161.13,16.94 162.99,15.07 v2(162.99,12.18)
  IN1 w0.508: v2(112.72,93.71) 112.89,93.71 113.77,94.59 113.77,98.72 115.05,100 115.05,103.53 114.49,104.09 114.49,110.36 v2(117.55,113.42) ; 243.84,40.01 242.34,41.5 242.34,42.39 241.41,43.32 235.01,43.32 233.77,44.56 v2(232.91,44.56)
  IN2 w0.508: v2(120.63,37.2) 124.2,33.63 127.46,33.63 130.51,30.58 v2(130.51,30.1) ; v2(117.55,113.42) 118,112.98 118.87,112.98 119.96,114.07 132.92,114.07 v2(134.37,112.62)
  IN3 w0.508: v2(161.13,18.37) 161.13,19.54 160.58,20.09 159.84,20.09 157.79,22.14 157.79,26.05 156.07,27.76 132.13,27.76 130.72,29.17 130.72,29.88 v2(130.51,30.1) ; v2(112.72,93.71) 111.82,92.81 106.44,92.81 105.3,91.67 105.3,79.91 105.06,79.67 v2(104.65,79.67) 104.65,70.52 v2(103.92,69.8)
  IN5 w1.016: 314.85,31.1 315.04,31.29 323.89,31.29 324.61,32.01 324.61,33.15 326.65,35.18 326.65,38.36 327.41,39.12 329.31,39.12 330.61,40.42 330.61,43.02 332.55,44.96 332.55,47.82 333.27,48.54 333.27,49.55 332.71,50.11
  IN6 w1.524: 289.3,24.87 288.9,24.87 287.86,23.83 280.79,23.83 278.94,21.97 273.31,21.97 272.03,23.26 272.03,24.97 271.72,25.27 270.38,25.27 269.19,26.47 263.56,26.47 262.5,25.41 261.9,25.41 260.03,23.55 260.03,23.07
  BOTTOM w0.254: PU1300.14 105.77,79.76 105.96,79.58 105.96,79.24 PC1302.2 ; UZ25.4 15.48,66.23 15.6,66.35 15.85,66.35 v2(16.03,66.17) ; PU1202.15 155.84,116.97 PC1294.1 ; PU1200.3 136.13,112.94 135.89,113.18 PC1200.1 ; v2(148.99,119.85) 148.99,119.81 148.77,119.59 PU1201.3 ; PC1336.2 105.46,71.12 105.01,71.57 PU1301.14 ; PU1302.6 112.98,94.95 v2(112.78,94.74)
  BOTTOM w0.305: PU1201.15 145.94,117.59 PC1293.1 ; PU1202.3 157.96,119.42 v2(157.94,119.44) ; JKB.2 162.8,11.47 162.99,11.66 v2(162.99,12.18)
  BOTTOM w0.381: v2(103.92,69.8) 103.99,69.86 104.78,69.86 105.46,70.54 PC1336.2 ; PC1288.1 148.51,120.45 148.52,120.44 148.52,120.34 148.99,119.87 v2(148.99,119.85) ; PC1290.1 v2(157.94,119.44)
  BOTTOM w0.508: PC1293.1 145.8,117.76 146.38,118.34 v2(146.38,118.38) ; PC1200.1 134.93,113.18 v2(134.37,112.62) ; v2(117.55,113.42) 117.54,113.41 PR1101.1 ; PC1294.1 155.49,118.31 v2(155.75,118.31) ; v2(104.65,79.67) 105.06,79.25 105.06,79.15 PC1302.2 ; v2(191.52,118.87) 191.83,118.87 192.34,119.38
  vias: v2(12.47,62.34) v2(12.48,61.7) v2(24.31,30.71) v2(24.96,30.43) v2(54.17,31.62) v2(54.74,31.62) v2(86.26,36.54) v2(86.69,37.02) v2(104.48,40.77) v2(135.89,108.61) v2(166.68,109.68) v2(167.31,109.68) v2(244.03,38.23) v2(244.03,37.59) v2(244.67,38.23) v2(244.67,37.59) v2(256.9,38.02) v2(256.95,37.44) v2(257.25,36.86) v2(257.67,21.95) v2(257.96,36.84) v2(258.05,36.25) v2(258.15,22.72) v2(258.61,23.08) v2(305.68,32.25) v2(306.37,32.28) v2(331.76,49.99) v2(331.76,49.4)
+5VS_AUDIO:
  vias: v2(4.98,9.49) v2(5.6,9.49) v2(14.25,38.41) v2(14.35,37.71) v5(14.83,38.19)
+5VS_AUDIO_PVDD1: length 1.1
  BOTTOM w0.14: LA3.1 v1(16.26,39.92)
+5VS_AUDIO_PVDD2: length 0.9
  TOP w0.14: LA1.1 11.61,36.83 v1(11.46,36.68)
  vias: v2(13.34,38.23)
+5VS_CT1: length 1.6
  TOP w0.14: UZ1.12 259.67,38.52 259.67,38.53 CZ4.1
+5VS_HDD: length 8.6
  TOP w0.203: v5(238.63,13.59) 238.75,13.47 v2(238.75,11.99)
  TOP w0.254: v5(237.49,15.37) 237.87,14.99 237.87,13.21 237.49,12.83 237.49,12.05 v2(237.55,11.99) ; v5(241.43,10.42) 239.14,10.42 238.68,10.87 CS14.1
  vias: v2(238.14,11.99)
+AVDD1: length 1.7
  TOP w0.14: LA2.2 14.42,41.26 15.47,41.26 v1(15.81,41.61)
  vias: v2(12.97,40.75)
+AVDD2: length 8
  TOP w0.508: RA2.2 2.91,34.18 v2(2.8,34.29)
  IN2 w0.508: v2(2.8,34.29) 2.8,34.54 2.61,34.73 2.39,34.95 2.39,37.33 3.54,38.48 3.54,38.86 v2(4.32,39.63)
  vias: v1(4.17,40.41)
+DVDD: length 8
  BOTTOM w0.305: v2(11.32,32.54) 11.18,32.69 RA15.1
  BOTTOM w0.356: RA15.1 12.16,33.16 13.42,34.42 14.03,34.42 14.76,35.14 14.76,35.35 v1(15.2,35.79) 15.72,36.32 RA12.1
  BOTTOM w0.381: RA13.1 7,33.24 6.55,32.79 v2(6.55,32.66)
  vias: v2(6.08,27.42) v2(6.06,26.82) v2(9.06,34.3)
+DVDDIO: length 9.7
  TOP w0.508: RA18.1 4.65,30.56 4.96,30.87 4.96,31.68 5.64,32.36 CA39.1 v1(6.63,33.95) 6.63,35.55 CA40.1 5.42,36.15 4.04,37.53 v2(3.75,37.53)
+VBUS_1: length 48.9
  TOP w0.127: v2(26.36,59.5) v1(26.87,59.5)
  TOP w0.508: v2(62.17,20.82) 62.17,21.05 63.35,22.23 63.35,23.85 PD204.2
  IN1 w0.508: v2(25.26,54.84) 25.26,58.4 v2(26.36,59.5) ; v2(31.78,27.5) 32.25,27.5 32.63,27.88 38.01,27.88 38.84,27.05 38.84,25.96 38.43,25.55 38.43,24.91 40.41,22.93 45.23,22.93 46.04,23.74 49.04,23.74 50.01,24.72 53.16,24.72 53.64,25.2 54.07,25.2 54.34,25.47 55.08,25.47 55.73,24.82 55.73,24.35 57.88,22.2 61.76,22.2 62.17,21.79 v2(62.17,20.82)
  BOTTOM w0.254: UT4.B10 UT4.A10 25.12,54.99 v2(25.26,54.84)
  vias: v2(8.75,65.11) v2(8.84,67.64) v2(9.37,67.95) v2(9.36,64.89) v2(9.83,68.33) v2(9.88,64.57) v2(12.26,65.41) v2(12.83,65.66) v2(12.83,65.09) v2(12.83,64.52) v2(13.46,64.96) v2(13.46,64.39) v2(28.53,67.97) v2(28.53,67.39) v2(28.53,66.79) v2(28.53,66.18) v2(28.53,65.6) v2(28.54,65.02) v2(28.57,64.45) v2(28.63,63.87) v2(30.74,26.23) v2(30.78,26.88) v2(31.34,25.65) v2(31.37,26.87) v2(31.36,26.24) v2(31.78,28.7) v2(31.78,28.12) v2(31.94,25.71) v2(31.95,26.88) v2(31.96,26.3) v5(32.28,30.65)
