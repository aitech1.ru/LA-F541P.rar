# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
XDP_PREQ#: length 124.7
  TOP w0.089: v2(136.78,81.06) 136.35,81.06 v5(136.2,80.9)
  TOP w0.14: JXDP.3 130.03,86.51 130.63,87.11 v2(131.22,87.11)
  IN2 w0.089: 101.98,13.5 101.82,13.34 100.83,13.34 v2(100.44,12.95) ; 134.62,81.56 134.88,81.3 136.65,81.3 136.78,81.17 v2(136.78,81.06)
  IN2 w0.099: v2(131.22,87.11) 132.06,87.11 132.87,86.3 132.87,83.31 134.62,81.56 ; 101.98,13.5 103.06,14.58 103.84,14.58 104.05,14.78 108.51,14.78 108.69,14.96 109.23,14.96 111.72,17.45 113.14,17.45 114.43,18.73 114.85,18.73 v2(115.28,18.3)
  IN4 w0.089: 134.62,77.73 137.52,77.73 138.29,78.5 138.29,80.58 137.81,81.06 v2(136.78,81.06)
  IN4 w0.091: 134.62,77.73 133.47,77.73 132.03,76.29 132.03,72.26 133.08,71.21 133.08,66.95 133.92,66.12 133.92,65.46 133.9,52.86 122.05,41.01 121.07,41.01 112.12,32.06 112.12,30.12 112.21,30.04 112.21,28.39 111.76,27.94 111.76,21.34 112.14,20.96 112.65,20.96 113.08,20.52 113.08,20.5 v2(115.28,18.3)
  BOTTOM w0.076: UH1.BL30 140.31,81.15 136.86,81.15 v2(136.78,81.06) 136.65,80.94 134.68,80.94 134.62,80.88
  BOTTOM w0.089: v2(100.44,12.95) 100.44,12.95 100.06,12.57 99.6,12.57 99.45,12.41 98.54,12.41 UH2.AL2
  BOTTOM w0.14: 134.62,80.88 134.5,80.75 132.1,80.75 RH156.2
XDP_PWRGOOD: length 7.8
  TOP w0.14: RH481.2 CD3328.1 v1(131.57,91.21) ; RH481.2 129.99,92.81 129.99,93.8 129.52,94.26 129.52,95.19 129.2,95.51 JXDP.39 ; RH481.2 RH482.2
XDP_TDI: length 26.5
  TOP w0.14: v2(120.98,99.2) 121.08,99.2 121.39,99.51 JXDP.56 ; v5(135.46,99.06) 136.02,98.5 v2(136.18,98.5)
  IN3 w0.091: v2(120.98,99.2) 121.97,99.2 123.55,97.62 124.26,97.62 125,98.36 127.89,98.36 129.02,97.23 129.93,97.23 130.96,96.2 132.53,96.2 132.79,96.47 132.79,96.91 134.38,98.5 v2(136.18,98.5)
  BOTTOM w0.14: v2(120.98,99.2) 120.98,98.17 120.27,97.46 120.27,97.02 119.85,96.59 118.99,96.59 RH477.1 ; RH541.1 135.93,98.25 v2(136.18,98.5)
XDP_TDO: length 20.3
  TOP w0.14: v5(132.22,98.39) 132.4,98.57 132.4,98.85 v2(132.62,99.06) ; JXDP.52 121.39,98.51 120.98,98.1 v2(120.98,97.17)
  IN4 w0.091: v2(132.62,99.06) 132.4,98.85 132.4,98.32 131.59,97.51 129.09,97.51 128.53,98.07 125.47,98.07 124.49,99.05 122.86,99.05 v2(120.98,97.17)
  BOTTOM w0.14: v2(132.62,99.06) 132.4,98.85 132.4,98.38 132.53,98.25 RH540.1 ; v2(120.98,97.17) 120.98,96.74 RH478.1
XDP_TMS: length 23.9
  TOP w0.14: v2(121.02,99.8) 121.23,100.01 JXDP.58 ; v1(133.1,93.82) 132.16,93.82 131.68,94.29 131.68,94.48 v2(131.33,94.83)
  IN2 w0.254: v2(121.02,99.8) 121.65,99.8 122.19,99.26 122.19,98.36 123.47,97.08 124.91,97.08 125.95,98.12 127.01,98.12 130.3,94.83 v2(131.33,94.83)
  BOTTOM w0.14: RH542.1 130.79,95.37 v2(131.33,94.83) ; RH12.1 119.64,96.35 119.96,96.35 120.54,96.93 120.54,97.39 121.41,98.26 121.41,99.41 v2(121.02,99.8)
XDP_TRST#: length 24.6
  TOP w0.14: v2(119.6,97.05) 119.86,96.79 v1(120.23,96.79) 120.42,96.98 120.42,98.03 121.4,99.01 JXDP.54
  IN6 w0.099: v2(119.6,97.05) 120.05,96.6 121.12,96.6 121.12,96.59 121.75,96.59 122.32,96.02 122.32,87.86 127.5,82.69 128,82.69 v2(128,82.69)
  BOTTOM w0.14: v2(128,82.69) 128.01,82.69 128.4,82.69 RH543.1
XTAL24_IN: length 11.7
  TOP w0.089: v2(94.38,20.05) 94.38,18.24 94.86,17.76 97.07,17.76 v1(98.8,19.49) 98.85,19.53 99.6,19.53 99.77,19.36 99.99,19.36 100.29,19.06 100.29,18.89 RA96.2
  BOTTOM w0.089: UH2.U10 94.38,19.21 v2(94.38,20.05)
XTAL24_IN_R: length 4.2
  TOP w0.14: YH2.1 105.58,17.16 105.08,17.65 104.17,17.65 103.98,17.58 103.78,17.38 103.52,17.27 CH47.1 103.13,17.27 RH72.1 RA96.1
XTAL24_OUT: length 10.8
  TOP w0.089: RA97.2 101.52,18.84 v1(101.1,19.27) 100.82,19.54 99.84,19.54 99.6,19.79 98.62,19.79 96.88,18.05 95,18.05 94.77,18.28 94.77,19.55 94.9,19.69 v2(94.9,19.85)
  BOTTOM w0.089: UH2.U9 94.9,19.65 v2(94.9,19.85)
XTAL24_OUT_R: length 2.9
  TOP w0.14: RA97.1 102.26,18.39 102.59,18.39 RH72.2 102.92,18.24 103.29,17.87 CH48.1 103.53,17.87 103.77,18.1 103.77,18.26 103.86,18.35 YH2.3
XTAL_25_IN: length 1.7
  BOTTOM w0.152: YT1.1 21.59,32.77 21.78,32.58 21.88,32.58 22.07,32.39 CT43.1 22.68,32.39 RA98.2
XTAL_25_IN_R: length 2.5
  BOTTOM w0.102: RA98.1 22.73,33.63 23.12,34.02 23.12,35.07 UT1.D22
XTAL_25_OUT: length 3.1
  BOTTOM w0.152: YT1.3 20.61,31.87 20.61,31.92 20.74,32.05 21.66,32.05 21.95,31.75 CT44.1 22.73,31.75
XTAL_25_OUT_R: length 4.1
  BOTTOM w0.089: UT1.D23 23.35,33.53
  BOTTOM w0.152: 23.35,33.53 23.27,33.45 23.27,31.4 23.04,31.17 RA99.1
XTAL_OUT: length 12
  TOP w0.14: YV1.3 217.68,49.29 217.79,49.39 217.79,51.16 217.73,51.22 217.73,51.55 CV858.1 217.55,51.91 217.55,52.38 RV1833.2 217.57,52.8 217.57,53.13 v2(217.23,53.47)
  BOTTOM w0.14: UV18.H2 216.24,59.15 216.65,58.74 v3(216.65,56.43) 216.65,56.02 217.55,55.12 217.55,53.79 v2(217.23,53.47)
XTALIN: length 11.2
  TOP w0.14: v2(218.19,53.6) 217.9,53.31 217.9,52.94 RV1833.1 218.06,52.38 218.06,51.91 CV857.1 218.06,51.73 218.06,51.36 218.44,50.98 YV1.1
  BOTTOM w0.14: v2(218.19,53.6) 217.88,53.9 v3(217.88,54.64) 217.88,55.26 216.98,56.16 216.98,58.92 216.6,59.3 216.6,59.84 UV18.H3
XTALOUT: length 14.6
  TOP w0.14: RV581.1 220.79,50.99 220.12,51.66 220.12,51.76 219.72,52.17 219.72,53.69 218.63,54.78 216.92,54.78 v1(216.16,55.54) 214.92,56.78 214.92,58.51 214.51,58.93 214.51,60.09 v2(215.01,60.59)
  BOTTOM w0.102: v2(215.01,60.59) 215.42,61 UV18.J4
XTALSSIN: length 8.7
  TOP w0.14: v2(216.12,57.69) 217.22,56.59 218.81,56.59 v1(220.27,55.13) 220.71,54.69 220.71,52.9 RV579.1
  BOTTOM w0.102: UV18.H1 216.24,57.8 v2(216.12,57.69)
N04748: length 5.4
  TOP w0.203: PU1900.3 v1(45.51,15.71)
  TOP w0.254: v1(45.51,15.71) 44.98,16.23 43.79,16.23 43.35,15.79 PR1922.1 43.19,15.63 42.42,14.86 PC1935.1
N16357: length 5.2
  BOTTOM w0.14: CA20.1 2.83,43.38 2.83,43.43 2.11,44.15 v1(2.11,44.27)
  BOTTOM w0.203: CA20.1 3.63,42.57 5.26,42.57 5.55,42.86 5.83,42.86 6.04,42.66 UA1.29
N16361: length 2.4
  BOTTOM w0.152: CA21.1 5.82,43.65 6.44,43.65 v1(6.57,43.52) 6.62,43.47 6.62,43 6.84,42.78 UA1.31
N16389: length 1.5
  BOTTOM w0.203: CA15.1 3.85,40.41 4.37,40.41 4.56,40.22 UA1.25
N16393: length 1.6
  BOTTOM w0.203: CA18.1 4.07,41.59 4.63,41.03 UA1.27
N35186: length 1.7
  TOP w0.14: RA29.1 11.91,43.77 12.31,44.16 DA14.1
N35194: length 2.6
  TOP w0.14: v1(15.29,44.28) 14.88,44.28 14.75,44.16 DA7.1 14.16,44.66 14.01,44.81 13.91,44.81 13.86,44.86 RA28.1
N48197: length 3.6
  TOP w0.203: PU1100.2 113.57,108.19 113.25,108.51 113.25,108.8 v1(112.97,109.08) 112.71,109.34 v2(112.71,109.54) PC1103.2
  BOTTOM w0.254: PR1104.2 v2(112.71,109.54)
N48329: length 3.8
  TOP w0.203: PU1100.4 113.06,107.39 v2(112.93,107.52) 112.82,107.63 PC1104.2
  BOTTOM w0.14: v2(112.93,107.52) 113.35,107.52 v1(113.54,107.33)
  BOTTOM w0.254: PR1111.2 112.82,107.63 v2(112.93,107.52)
N48371: length 4.9
  BOTTOM w0.14: v5(106.82,106.17) 109.06,106.17 109.64,106.74 PC1105.2
  BOTTOM w0.254: PC1105.2 110.08,107.14 110.55,107.14 111.05,107.63 PR1111.1
N48789: length 3.8
  TOP w0.203: PR1129.1 PC1114.1 121.9,105.08 v1(121.64,105.08) 121.54,105.08 121.32,105.29 120.89,105.29 120.8,105.39 PU1100.28
N48933: length 2.8
  BOTTOM w0.14: v1(121.53,103.81) PC1117.1
  BOTTOM w0.254: PR1126.2 122.56,104.88 PC1117.1
N48941: length 4.8
  TOP w0.203: PC1115.1 122.04,106.16 122.04,105.97 v2(121.67,105.6) 121.48,105.79 PU1100.29
  BOTTOM w0.14: v2(121.67,105.6) 120.91,105.6 v1(120.89,105.59)
  BOTTOM w0.254: v2(121.67,105.6) 121.86,105.79 PR1126.1
N48965: length 3.2
  TOP w0.14: v1(126.76,107.54) 126.29,107.07 125.46,107.07 124.91,107.63 PC1116.1
  TOP w0.254: PR1124.2 PC1116.1
N48979: length 8.9
  TOP w0.203: PU1100.30 120.7,106.19 120.78,106.11 121.55,106.11 122.02,106.58 122.02,107.23 v2(122.43,107.63) PR1124.1
  BOTTOM w0.254: PR1128.1 122.43,106.87 v2(122.43,107.63) 124.27,107.63 v1(124.68,107.22) 125.1,106.81 PR1125.1
N49205: length 3.3
  TOP w0.203: PU1100.8 113.18,105.79 v2(112.78,105.39)
  BOTTOM w0.254: PC1113.2 PR1130.2 112.38,105.79 v2(112.78,105.39)
N49217: length 3
  BOTTOM w0.14: PR1127.2 109.49,105.63 v1(108.55,105.63)
  BOTTOM w0.254: PC1113.1 110.67,106.29 110.15,106.29 PR1127.2
N49289: length 4.6
  TOP w0.203: PU1100.3 113.45,107.79 113.16,108.08 112.55,108.08 PR1105.2 v2(112.78,108.59)
  BOTTOM w0.14: v2(112.78,108.59) 112.92,108.59 v5(113.39,109.06)
  BOTTOM w0.254: PR1105.2 v2(112.78,108.59)
N49471: length 3.1
  TOP w0.14: v1(125.16,111.88) 124.84,111.56 PR1117.2
  TOP w0.254: PC1108.1 124.83,110.3 PR1117.2
N49551: length 5.1
  TOP w0.203: PU1100.33 121.28,107.39 121.53,107.64 v1(121.53,108.11) 121.37,108.27 121.37,108.74 122.05,109.41 PR1115.1 PC1108.2
N49667: length 2.8
  TOP w0.14: PU1100.46 115.67,110.24 v2(115.65,110.26)
  BOTTOM w0.14: v1(114.73,110.19) 114.81,110.26 v2(115.65,110.26) 115.89,110.02 PR1103.2
N49815: length 6
  TOP w0.14: v1(123.52,112.65) 123.31,112.43 PR1116.1
  TOP w0.203: PU1100.36 120.1,108.92 120.67,109.49 120.7,109.49 122.21,111 122.99,111 PR1116.1
N50153: length 3.7
  TOP w0.203: PU1100.42 117.27,110.13 117.4,110.26 117.4,110.92 v2(117.54,111.06) PC1101.1
  BOTTOM w0.14: v2(117.54,111.06) v1(118.05,110.55)
  BOTTOM w0.254: PR1101.2 v2(117.54,111.06)
N50385: length 5.4
  TOP w0.14: PR1137.1 111.9,100.97 v1(111.61,100.67)
  TOP w0.203: PU1100.14 115.27,102.64 113.86,101.22 PC1129.1 PR1137.1
N50425: length 38.5
  TOP w0.254: PR1144.1 114.58,99.89 PR1138.2 v2(114.58,98.53)
  IN3 w0.254: v2(114.58,98.53) 115.98,99.92 119.76,99.92 120.17,99.52 120.17,99 120.49,98.67 121.94,98.67 123.27,97.34 124.37,97.34 125.04,98.01 126.83,98.01 129.45,95.39 130.38,95.39 130.79,95.8 133.81,95.8 135.84,97.83 136.21,97.83 136.9,98.52 136.9,98.59 137.84,99.52 141.05,99.52 143.56,102.03 v2(143.56,103.04)
  BOTTOM w0.254: v2(143.56,103.04) PH1104.2
N50433: length 2.8
  TOP w0.203: PU1100.15 115.67,102.48 v1(115.15,101.95) 114.75,101.55 PR1144.2
N50477: length 3.2
  TOP w0.203: PU1100.40 118.07,110.1 v1(118.49,110.52) 118.97,111 119.3,111 119.7,111.39 PR1110.1
N50505: length 5.8
  TOP w0.14: v1(121.07,113.7) 121.07,112.18 PR1109.1
  TOP w0.203: PR1109.1 120.59,111.32 119.95,110.68 119.22,110.68 118.47,109.94 PU1100.39
N50517: length 4
  TOP w0.203: PU1100.38 118.87,109.86 119.36,110.34 120.35,110.34 v1(120.59,110.59) 121.55,111.55 PR1108.1
N50567: length 6.7
  TOP w0.14: PR1107.1 122.44,111.76 122.99,112.31 v1(122.99,113.82)
  TOP w0.203: PU1100.37 119.27,109.78 119.51,110.01 120.73,110.01 122.42,111.7 PR1107.1
N50631: length 2.1
  BOTTOM w0.14: PR1141.2 114.52,100.05 v1(114.47,100.1)
  BOTTOM w0.254: PC1134.2 115.7,99.28 PR1141.2
N50639: length 3.9
  TOP w0.203: PC1131.1 v2(115.7,101.6) 115.7,102.05 116.07,102.42 PU1100.16
  BOTTOM w0.14: v1(115.7,102.34) v2(115.7,101.6)
  BOTTOM w0.254: v2(115.7,101.6) PC1131.1
N50651: length 2.5
  TOP w0.14: v1(115.63,97.93) 115.85,98.15 115.85,98.45 PC1132.1
  TOP w0.254: PC1132.1 PR1139.2
N50739: length 4
  TOP w0.203: PU1100.17 116.47,102.66 116.48,102.65 v1(116.48,102.16) 116.48,101.64 v2(116.52,101.6) 116.59,101.54 PR1139.1
  BOTTOM w0.254: PR1140.1 117.46,100.97 PR1139.1 116.59,101.54 v2(116.52,101.6)
N51003: length 3.9
  TOP w0.203: PU1100.20 117.67,102.59 117.92,102.34 v1(117.92,102.17) 117.92,101.79 v2(117.8,101.66)
  BOTTOM w0.254: PC1128.1 PR1133.1 118.37,100.97 117.8,101.53 v2(117.8,101.66)
N51011: length 4.9
  TOP w0.14: v2(118.19,97.08) 117.6,97.08 v1(117.48,96.95)
  IN2 w0.254: v2(118.19,97.08) 118.19,98.18 v2(119.44,99.44)
  BOTTOM w0.254: PC1128.2 v2(119.44,99.44) ; v2(118.19,97.08) 118.11,97.16 PR1135.1
N57527: length 49.1
  IN1 w0.254: v2(145.73,97.44) 145.96,97.21 145.96,96.05 143.74,93.83 134.64,93.83 132.74,95.73 131.38,95.73 130.35,96.76 v2(129.76,96.76)
  IN2 w0.254: v2(160.08,108.57) 160.08,108.53 159.91,108.36 155.65,108.36 154.35,109.65 147.4,109.65 146.51,108.76 146.51,100.47 145.91,99.87 145.91,97.61 v2(145.73,97.44)
  BOTTOM w0.254: v2(129.76,96.76) 129.76,96.76 129.02,97.5 PR1210.1 128.25,98.24 PR1209.1 ; v2(160.08,108.57) 160.08,109.33 PR1222.2
N3514407: length 3
  TOP w0.203: PU400.5 346.29,21.6 346.51,21.82 346.51,22.59 v1(346.97,23.05) PR405.2
N3514423: length 4.9
  TOP w0.203: PU400.3 346.6,20.8 346.85,21.06
  TOP w0.254: v2(347.31,22.11) 347.31,22.01 347.9,21.41 PC400.1 347.6,21.06 346.85,21.06
  BOTTOM w0.14: v1(347.65,21.44) 347.31,21.78 v2(347.31,22.11)
  BOTTOM w0.254: v2(347.31,22.11) 347.68,22.48 PR400.2
N3514453: length 2.4
  TOP w0.203: PC419.1 341.44,20.96 v1(341.83,20.96) 342.09,20.96 342.24,20.8 PU400.13
N13272441: length 3.3
  BOTTOM w0.254: PR809.1 PR805.1 PC806.2 107.82,64.28 108.39,63.72 PU800.14
N13347359: length 6
  TOP w0.14: PR1119.2 112.91,111.67 112.47,112.11 112.47,113.56 v1(112.52,113.62)
  TOP w0.203: PR1119.2 PR1114.2 113.92,111.34 115.27,109.99 PU1100.47
N13351923: length 5.3
  TOP w0.203: PU1100.41 117.67,110.11 117.8,110.24 117.8,110.5 118.62,111.32 PC1102.1 118.62,111.82 v2(119.06,112.27)
  BOTTOM w0.14: v1(119.64,111.86) 119.23,112.27 v2(119.06,112.27)
  BOTTOM w0.254: PR1102.2 118.85,111.67 119.06,111.89 v2(119.06,112.27)
N13352071: length 5.3
  TOP w0.14: v1(110.96,112.17) 111.46,111.67 PR1118.2 112.02,111.67
  TOP w0.203: PU1100.48 114.87,109.78 114.64,110.01 114.64,110.13 113.6,111.16 112.52,111.16 112.02,111.67
N13353452: length 12
  TOP w0.14: v5(105.8,108.47) 105.8,108.02 108.4,105.42 109.27,105.42 PR1113.2
  TOP w0.203: PR1112.2 110.33,106.74 110.64,107.06 112.8,107.06 112.88,106.99 PU1100.5
  TOP w0.254: PR1113.2 109.74,105.89 PR1112.2 109.55,106.94 PR1143.1
N16399089: length 1.6
  TOP w0.14: PD1902.1 59.79,17.08 v1(60.08,17.37)
N16404606: length 6.5
  TOP w0.14: PR1937.2 64.31,8.92 PD1903.3 63.15,10.43 61.22,12.36 v1(61.22,12.57) PR1936.1
N16404788: length 4.5
  TOP w0.14: PR1943.2 62.5,11.72 PD1903.1 62.28,12.21 PU1901.1
N17034077: length 2.9
  TOP w0.203: PR406.1 347.38,18.54 v1(347.06,18.86) 346.48,19.44 346.48,19.81 346.29,20 PU400.1
N17509431: length 4.3
  TOP w0.14: PR1927.2 45.92,18.96 v1(45.73,18.77)
  TOP w0.254: PR1927.2 46.93,19.22 PR1933.1 PR1932.1 PC1940.1
N17509921: length 1.2
  TOP w0.14: PD1903.2 61.85,9.59 62.15,9.28 PR1939.2
N17522701: length 1.4
  TOP w0.14: PR1941.2 62.93,12.88 PU1901.2
N17670003: length 7.3
  TOP w0.203: PR1934.1 44.39,19.51 v1(44.55,19.34) 44.55,19.1 45.28,18.38 47.86,18.38 48.31,17.92 PU1900.30
  TOP w0.254: PR1929.1 43.61,20.5 PR1934.1
N17765266: length 3.5
  TOP w0.203: PU1900.26 49.91,19.18 50.36,19.62 PR1928.2 PR1926.2
N18278782: length 2.7
  TOP w0.14: v1(42.71,8.54) 42.88,8.7 PC1913.1
  TOP w0.508: PR1905.1 PC1913.1
N18278998: length 3.6
  TOP w0.203: PR1917.2 53.86,17.27 53.45,16.87 v1(52.99,16.87) 52.56,16.87 51.41,15.71 PU1900.22
N18290168: length 2.5
  TOP w0.203: PR1927.1 48.03,18.96 v1(48.54,18.45) 48.71,18.28 PU1900.29
N19473413: length 4.4
  TOP w0.14: PR1804.1 v1(177.95,16.61)
  TOP w0.254: PU1800.4 180.53,15.03 PR1803.2 179.83,16.59 PC1802.2 178.96,16.6 PR1804.1
N19473637:
  vias: v1(182.09,16.05)
N26813293: length 14.4
  TOP w0.254: v2(225.43,48.9) 225.43,48.9 RV639.2 RV640.2 ; RV641.2 RV1080.2 232.63,52.72 v1(232.98,52.36) 232.98,49.65 v2(232.87,49.53)
  IN6 w0.254: v2(232.87,49.53) 226.06,49.53 v2(225.43,48.9)
N27076067: length 0.8
  TOP w0.203: PR1930.2 48.74,20.55 PC1941.1
N31483113: length 1.9
  TOP w0.254: PQ701.2 185.04,117.82 PC725.1 185.27,117.41 185.54,117.41 PR717.2
N31483116: length 1.1
  TOP w0.254: PR713.1 186.2,119.13 PQ701.3
N31483118: length 2.6
  TOP w0.254: PQ701.5 185.04,120.91 184.91,121.03 184.53,121.03 184.39,120.89 PQ701.6 183.53,120.52 PR715.2
N32073814: length 2.2
  TOP w0.203: PC711.1 193.93,119.56 PU700.8
  TOP w0.254: PC711.1 194.22,119.81 194.27,119.76 PR710.1
N32073817: length 16.9
  TOP w0.14: v1(187.83,116.97) 188.09,117.22 188.09,118.57 PR713.2 187.53,119.94 v2(187.45,120.02) 187.5,120.07 PC712.1
  TOP w0.203: v2(195.84,119.76) PR710.2 195.05,119.48 194.82,119.25 194.57,119.25 194.33,119.02 PU700.7
  TOP w0.254: PR713.2 186.78,119.88 PR712.1
  IN1 w0.254: v2(195.84,119.76) 194.06,119.76 193.04,120.78 190.12,120.78 189.36,120.02 v2(187.45,120.02)
N32074224:
  vias: v1(205.49,120.91)
N32086652: length 3
  TOP w0.203: PU700.12 191.09,117.37 190.66,116.93 PR718.1 189.7,116.93 PR711.1
N35924928: length 3.3
  TOP w0.102: RV600.2 215.36,83.04 v1(215.36,82.06) 215.36,81.38 215.77,80.96 v2(215.77,80.7)
  BOTTOM w0.102: UV18.J27 215.44,80.36 v2(215.77,80.7)
N35928308: length 4.7
  TOP w0.102: v2(216.74,80.7) 216.23,81.21 216.23,83.03 RV601.2
  TOP w0.14: v1(216.41,84.32) 216.41,83.88 215.93,83.4 RV601.2
  BOTTOM w0.102: UV18.H27 216.34,80.3 v2(216.74,80.7)
N35950826: length 3.4
  TOP w0.102: v2(216.76,78.98) 217.13,78.61 217.13,77.73 v1(217.16,77.7) 217.36,77.7 217.41,77.74 218.08,77.74 RV602.2
  BOTTOM w0.102: UV18.H25 216.34,78.55 v2(216.76,78.98)
N48708347: length 1.8
  BOTTOM w0.14: v1(283.48,26.25) 283.15,26.58 PC600.2
N48708367: length 5.8
  TOP w0.14: v2(291.07,30.7) 290.65,30.7 290.63,30.68 290.39,30.68 289.99,31.08 PR610.1
  BOTTOM w0.14: v1(292.85,28.91) 292.3,29.45 292.15,29.45 291.83,29.77 PR608.2
  BOTTOM w0.203: PU600.7 290.91,30.54 v2(291.07,30.7) 291.34,30.7 291.38,30.74 PC614.1 PR608.2
N48708425: length 3.8
  BOTTOM w0.203: PR605.2 290.91,27.35 v1(290.91,29.13) 290.91,29.21 290.38,29.74 PU600.9
N49570918: length 6.4
  TOP w0.14: v1(133.26,4) 133.46,3.8 v2(133.98,3.8)
  TOP w0.254: v2(133.98,3.8) 134.61,3.18 PR507.1
  BOTTOM w0.14: PU500.14 133.09,4.83 133.2,4.72 PC506.2 133.92,3.86 v2(133.98,3.8)
  BOTTOM w0.254: v2(133.98,3.8) 134.01,3.77 PR504.2
N52997531: length 3.2
  TOP w0.14: PL104.1 27.26,82.44 PR102.2 27.97,82.41 PD100.1 v1(28.32,80.96)
N52999986: length 10
  TOP w0.14: PL104.2 26.33,83.35 24.55,83.35 23.98,82.78 PQ100.1 ; PQ100.1 23.5,82.06 24.32,81.23 v1(24.32,80.82) ; PQ100.1 23.5,84.08 23.57,84.15 PR100.1 PR103.1
N55155823: length 1.2
  TOP w0.14: RV120.1 v1(40.51,36.37)
N55155843: length 3.3
  TOP w0.14: v1(39.02,36.06) 39.3,35.77 QV12.1
  TOP w0.508: RV120.2 39.8,34.21 39.73,34.14 QV12.1
N108873638: length 4.1
  TOP w0.203: v2(345.95,19.05) 345.7,18.8 345.31,18.8 345.2,18.91 PU400.20
  BOTTOM w0.254: v2(345.95,19.05) 346.57,19.05 v1(346.84,18.78) 347.36,18.26 347.36,17.92 347.64,17.64 PR409.1
N109970739: length 5.5
  TOP w0.14: v1(348.53,16.45) 348.03,16.94 PR410.1
  TOP w0.203: PU400.19 344.8,18.83 345.15,18.48 346.85,18.48 347.56,17.77 347.85,17.77 PR410.1
N110703687: length 1
  TOP w0.14: v1(174.04,103.73) 174.52,103.25 174.84,103.25
N116496514: length 1
  TOP w0.14: 173.57,117.31 173.57,118.21 v1(173.67,118.31)
N119328643: length 5.6
  TOP w0.203: PU1900.25 50.31,18.14 50.41,18.24 v1(50.41,18.49) 50.41,19.04 50.6,19.23 51.56,19.23 51.88,19.55 PR1924.2 52.74,19.74 PC1934.1 52.76,20.58 PR1923.1
N119942216: length 1.6
  BOTTOM w0.14: v1(25.62,85.28) 25.62,86.6 PL105.1
N120970730:
  vias: v1(145.44,114.25)
N120971346: length 1.6
  TOP w0.14: PR1204.2 v1(147.33,110.86)
N120971480: length 1.4
  TOP w0.14: 157.18,112.08 v1(155.78,112.08)
N121033373: length 2.2
  TOP w0.203: PU400.6 345.2,22.71 345.39,22.9 345.67,22.9 v2(345.77,23) 346.08,23.31 PR408.2
N121033408: length 4
  TOP w0.203: PU400.7 344.8,22.92 345.12,23.24 v2(345.12,23.37) PR407.2
  BOTTOM w0.14: v1(346.38,24.82) 345.56,23.99 PR407.2
  BOTTOM w0.254: v2(345.12,23.37) PR407.2
N121616283: length 3.3
  TOP w0.127: 192.79,8.87 192.61,8.69 UE6.6
  TOP w0.14: 192.79,8.87 193.29,9.37 CE65.1 194.07,9.78 v1(194.07,10.5)
N121617744: length 1.6
  TOP w0.14: UZ33.6 235.33,9.72 CZ37.1
N121673930: length 1.9
  TOP w0.14: PR1112.1 107.89,106.74 v1(107.82,106.68)
  TOP w0.254: PR1112.1 108.83,105.93 PC1106.2
N121674134: length 3.7
  BOTTOM w0.14: PC1130.1 116.59,97.46 v1(116.78,97.27)
  BOTTOM w0.254: PR1140.2 117.86,99.66 117.86,99.29 116.86,98.3 PC1130.1
N121674335: length 3.1
  TOP w0.14: PC1118.1 124.89,104.89 v1(124.8,104.8)
  TOP w0.254: PC1118.1 124.88,105.84 v2(124.22,105.84)
  BOTTOM w0.254: v2(124.22,105.84) 124.22,105.63 124.89,104.95 PR1125.2
N121718437: length 6.3
  TOP w0.14: DE7.1 98.4,34.93 98.2,35.13 97.97,35.13 RE82.2 97.96,37 v5(97.68,37.28) v2(97.26,37.69)
  BOTTOM w0.14: v2(97.26,37.69) 97.26,37.26 96.6,36.61 JFAN1.3
N121718548: length 12.4
  BOTTOM w0.14: JFAN2.3 338.45,56.7 339.24,55.91 339.24,53.09 337.27,51.12 RE84.2 337.27,49 337.72,48.55 DE8.1 337.72,47.28 v5(337.47,47.03)
N121981266: length 31.7
  TOP w0.14: v2(110.36,108.46) 110.36,108.6 109.6,109.36 v1(109.6,109.6)
  TOP w0.254: PR1105.1 110.49,108.59 v2(110.36,108.46)
  IN2 w0.254: v2(110.36,108.46) 108.89,106.99 108.89,103 110.41,101.47 110.41,98.6 109.09,97.28 109.09,96.06 105,91.97 105,91.39 104.53,90.91 104.53,86.48 105,86 105,85.23 v2(104.52,84.75)
  BOTTOM w0.254: v2(110.36,108.46) 109.69,107.79 PR1106.2 ; PH1100.2 v2(104.52,84.75)
N121981305: length 2.7
  BOTTOM w0.14: PR1122.2 121.37,87.08 121.37,87.97 v1(120.97,88.38)
  BOTTOM w0.254: PH1102.1 PR1122.2
N121981509: length 2.9
  BOTTOM w0.14: PH1101.2 114.59,92.15 v1(115.93,92.15)
  BOTTOM w0.254: PH1101.2 PR1121.1
N121981539: length 0.9
  BOTTOM w0.254: PR1136.1 PH1103.2
N122282431: length 4.1
  BOTTOM w0.14: UR1.28 342.53,37.79 342.73,37.59 343.6,37.59 344.51,36.68 v1(344.51,36.49) 344.81,36.2 RR9.1
N122463812: length 4.4
  TOP w0.14: JXDP.1 129.28,86.01 129.54,85.76 v2(129.54,85.33) 129.77,85.33 v1(130.09,85.65)
  BOTTOM w0.14: RH475.1 128.72,84.81 129.24,85.33 v2(129.54,85.33) 129.68,85.47 RH474.1
N122469543: length 36.8
  TOP w0.089: v2(74.35,6.84) v1(74.72,7.21) 75.1,7.6 77.9,7.6 78.13,7.37 78.13,5.97 77.93,5.77 77.37,5.77 77.17,5.97 76.51,5.97 76.19,5.65 76.19,4.88 76.44,4.62 RH6.1 76.81,4.17 76.44,3.8 RH2.2
  TOP w0.14: v2(60.66,22.85) 60.1,23.4 CH174.1
  IN2 w0.089: 74.05,6.85 74.33,6.85 v2(74.35,6.84)
  IN2 w0.099: 74.05,6.85 71.63,6.85 70.68,7.8 70.68,8.42 70.51,8.59 70.15,8.59 69.43,9.3 68.26,9.3 68.08,9.48 68.08,11.04 66.6,12.52 66.6,13.28 64.09,15.79 64.09,18.71 63.43,19.36 63.43,19.75 62.66,20.52 62.66,21.03 62.22,21.48 61.83,21.48 60.66,22.66 v2(60.66,22.85)
N122476680: length 30.7
  TOP w0.14: v5(130.15,101.32) 129.91,101.08 v2(129.91,100.6)
  IN1 w0.254: v2(129.91,100.6) 130.43,100.08 133.56,100.08 136.97,96.67 138.77,96.67 140.01,97.91 140.01,99.73 142.27,102 142.27,107.08 143.98,108.79 145.36,108.79 v2(145.54,108.97)
  BOTTOM w0.254: PR1218.2 145.54,109.86 v2(145.54,108.97) ; PR1201.1 128.79,99.75 PR1202.1 129.68,99.75 129.96,100.03 129.96,100.55 v2(129.91,100.6)
N122477585: length 50.2
  IN1 w0.254: v2(128.95,102.1) 128.34,101.49 126.35,101.49 125.45,100.59 125.45,99.16 126.18,98.43 127.9,98.43 128.66,99.19 130.15,99.19 131.31,98.02 133.24,98.02 135.99,95.28 142.91,95.28 143.49,95.85 143.49,100.43 144.27,101.22 144.27,104.54 146.53,106.8 146.53,108.43 147.46,109.36 151.53,109.36 152.36,108.52 152.8,108.52 v2(152.97,108.69)
  BOTTOM w0.254: PR1205.1 128.6,102.1 v2(128.95,102.1) 128.95,101.93 129.2,101.68 PR1206.1 ; v2(152.97,108.69) PR1220.2
N122528028:
  vias: v5(238.48,42.71)
N122706757: length 3.4
  TOP w0.14: v2(105.59,65.15) v1(104.97,65.15)
  TOP w0.254: PR811.2 PR810.1 106.22,65.79 v2(105.59,65.15)
  BOTTOM w0.254: PR809.2 106.05,65.61 v2(105.59,65.15)
N122712620: length 7.3
  BOTTOM w0.14: v1(255.09,3.44) 255.09,3.71 255.41,4.03 RD58.2 255.93,4.97 256.67,4.97 RD10.2 258.79,6.04 JNGFF2.61
N122739099: length 10.9
  TOP w0.14: v2(113.26,51.36) 113.26,51.36 113.91,50.71 RZ86.1 114.08,50.66 RZ60.1 113.59,49.41 UZ21.4 ; v1(115.77,53.39) 115.77,52.96 116.3,52.44 v2(116.33,52.44) 116.45,52.56 118.14,52.56 118.35,52.77 UZ12.1
  IN2 w0.099: v2(116.33,52.44) 116.33,52.27 115.24,51.18 113.44,51.18 113.26,51.36 v2(113.26,51.36)
N122739340: length 4.6
  TOP w0.14: RZ61.2 119.71,52.62 119.71,53.66 119.15,54.22 v1(118.96,54.22) 117.96,54.22 117.7,53.96 UZ12.2
N122774125: length 1.7
  BOTTOM w0.254: PR805.2 106.94,65.79 106.63,66.09 PR806.1 PR803.2
N123360127: length 2.4
  TOP w0.089: RT12.1 24.96,35.87 v2(25.41,36.32) 25.46,36.32 25.79,35.99 v1(25.79,35.99)
  BOTTOM w0.102: v2(25.41,36.32) UT1.H19
N123360144: length 2.2
  TOP w0.089: v2(30.61,36.96) 30.61,36.4 v1(30.72,36.29) 30.94,36.07 RT5.1
  BOTTOM w0.076: UT1.Y18 30.93,37.29 30.61,36.97 v2(30.61,36.96)
N123983992:
  vias: v2(111.63,68.58) v2(111.66,67.93) v2(112.33,68.58) v2(112.35,67.96) v2(112.95,68.59) v2(112.98,68.01) v2(113.56,68.59) v2(113.62,68.01) v5(111.05,68.35)
N123984002: length 49.7
  TOP w0.14: v5(107.48,100.88) 107.13,101.23 v2(107.13,101.66)
  TOP w0.254: v2(107.13,101.66) 107.19,101.73 PR1305.1
  IN1 w0.254: v2(107.13,101.66) 106.55,102.24 105.92,102.24 105.35,101.66 105.35,97.37 103.65,95.67 103.65,83.49 105.54,81.6 105.54,80.4 105.86,80.09 109.68,80.09 109.79,80.2 112.21,80.2 112.51,80.51 115.11,80.51 115.48,80.13 115.48,72.17 116.01,71.65 116.01,70.97 115.78,70.74 v2(115.47,70.74)
  BOTTOM w0.254: v2(107.13,101.66) 107.19,101.73 PR1306.1 ; PR1314.2 v2(115.47,70.74)
N123984012:
  vias: v1(105.5,96.79) v2(107.32,97.66) v2(107.82,96.9) v2(107.82,96.27) v2(107.95,97.66)
N123984055: length 3.1
  TOP w0.254: v2(116.9,95.28) 116.83,95.35 v1(116.35,95.35) 115.9,95.35 115.46,95.8 PR1311.1
  BOTTOM w0.254: v2(116.9,95.28) 116.73,95.45 PU1302.2
N123984061: length 10.8
  TOP w0.14: v5(108.46,91) v2(108.46,91.63)
  IN6 w0.762: 109.09,92.46 108.9,92.65 108.9,97.89 109.43,98.41 111.28,98.41 112.41,97.28 112.84,97.28
  vias: v2(109.09,91.63) v2(112.87,96.98) v2(112.87,96.34)
N123984063: length 12.1
  TOP w0.14: v2(106.55,91.8) v1(106.01,91.8)
  IN6 w0.762: 115.7,94.81 114.74,93.85 114.74,92.77 114.41,92.44 113.19,91.22 110.21,91.22 109.22,90.23 107.51,90.23 106.88,90.86
  vias: v2(107.16,91.82) v2(116.5,95.95) v2(117.1,95.95)
N123984071: length 3.1
  TOP w0.14: v1(112.85,97.84) 113.67,97.84 114.39,97.12 PC1313.2
  TOP w0.254: PC1313.2 115.44,96.91 PR1311.2
N123984081: length 30.9
  TOP w0.14: v5(105.65,100.76) 106.36,101.47 v2(106.36,101.6)
  TOP w0.254: PR1301.1 105.92,101.86 106.17,101.6 v2(106.36,101.6)
  IN1 w0.254: v2(115.66,83.23) 115.66,83.76 115.29,84.13 114.76,84.13 111.51,87.38 106.62,87.38 105.07,88.93 105.07,95.92 105.86,96.71 105.86,101.09 v2(106.36,101.6)
  BOTTOM w0.254: PR1303.1 105.98,101.98 v2(106.36,101.6) ; PR1312.2 115.41,82.98 v2(115.66,83.23)
N123984161: length 1.3
  BOTTOM w0.14: PC1365.1 104.3,92.08 v1(104.09,92.29)
N123984213: length 48.9
  TOP w0.14: v2(115.47,71.38) 115.44,71.4 v5(115.44,72.16)
  TOP w0.254: PR1304.1 v2(108.27,101.6)
  IN1 w0.254: v2(108.27,101.6) 107.19,102.68 105.73,102.68 104.97,101.92 104.97,97.63 103.3,95.96 103.3,83.34 105.18,81.45 105.18,80.26 105.71,79.73 109.83,79.73 109.9,79.8 112.38,79.8 112.64,80.06 114.96,80.06 115.09,79.93 115.09,71.76 v2(115.47,71.38)
  BOTTOM w0.254: v2(115.47,71.38) 115.7,71.38 116.27,70.8 PR1315.2
N123984281: length 29.2
  TOP w0.254: PR1309.1 125.99,104.25 v2(126.29,103.94)
  IN1 w0.254: v2(110.45,89.98) 110.45,90.34 111.11,91 115.48,91 115.95,91.47 118.65,91.47 119.3,92.11 121.23,92.11 122.02,92.9 122.02,100.82 124.53,103.33 125.67,103.33 126.28,103.94 v2(126.29,103.94)
  BOTTOM w0.254: v2(110.45,89.98) 110.45,89.52 110.2,89.27 PL1306.2
N123984351: length 1
  TOP w0.14: v5(112.62,91.33) 112.14,91.81 v2(112.14,92.15)
N123984423: length 1.7
  TOP w0.14: v5(110.36,74.35) 110.73,73.98 PC1347.1
N123984459: length 0.7
  TOP w0.14: 110.96,77.84 110.68,77.84 v5(110.41,77.57)
N123984461:
  vias: v2(111.25,80.75) v2(111.91,80.75) v2(114.63,81.05) v2(114.66,82.25) v2(114.66,81.64) v2(115.24,81.03) v2(115.27,82.27) v2(115.29,81.64) v5(112.1,83.38)
N123985122: length 31.1
  TOP w0.14: PR1302.2 v2(109.22,101.6) v5(109.22,100.97)
  IN1 w0.254: v2(116.3,83.23) 116.3,83.83 115.6,84.53 114.99,84.53 111.76,87.76 106.81,87.76 105.51,89.05 105.51,95.68 106.3,96.47 106.3,100.46 106.81,100.97 108.59,100.97 v2(109.22,101.6)
  BOTTOM w0.254: PR1313.2 116.5,82.98 116.37,83.11 116.37,83.15 v2(116.3,83.23)
N124211085: length 2.8
  TOP w0.089: v2(24.76,36.32) 24.54,36.11 24.54,35.25 RT164.2 23.65,35.09 v1(23.47,34.91)
  BOTTOM w0.102: v2(24.76,36.32) UT1.F19
N124494273: length 2.8
  BOTTOM w0.081: UT4.C10 25.36,56.13 25.36,55.98 25.36,55.98 25.36,55.27 25.7,54.94 25.7,54.65 25.64,54.59 25.64,54.45
  BOTTOM w0.14: RT181.1 25.64,54.45
N124494892: length 4.2
  BOTTOM w0.081: UT4.G2 20.87,58.13 20.44,58.13 20.32,58.24 19.76,58.24 19.5,58.51 19.09,58.51 19.03,58.57 18.9,58.57 RT191.1 18.42,60.01 v1(18.38,60.05)
N124539694: length 2.3
  BOTTOM w0.081: 26.56,58.62 25.86,58.62 UT4.G11
  BOTTOM w0.14: 26.56,58.62 27.06,58.62 27.43,58.99 RT5844.1
N124607348: length 2.3
  TOP w0.14: QV89.1 26.42,51.33 v1(26.69,51.06) 27.28,50.47 RT195.1
N124730498: length 4.1
  BOTTOM w0.081: UT4.C2 21.11,56.37 20.86,56.13 20.43,56.13 19.76,55.45 19.67,55.45
  BOTTOM w0.14: RT178.1 18.32,55.14 19.08,55.14 19.38,55.45 19.67,55.45
N124730527: length 3.6
  BOTTOM w0.081: UT4.B2 20.87,55.63 20.87,54.45
  BOTTOM w0.14: T185.1 19.9,53.15 20.32,53.58 20.32,53.79 20.46,53.93 20.74,53.93 20.87,54.05 20.87,54.45
N124752685: length 1.9
  TOP w0.14: RH211.1 v1(124.03,18.01)
  TOP w0.254: CH101.2 RH211.1
N124753277: length 2.2
  TOP w0.14: CH100.2 230.58,19.97 v1(230.32,19.71)
  TOP w0.254: RH212.1 231.31,19.03 CH100.2
N124754324: length 3.4
  TOP w0.14: RT199.1 26.8,58.17 26.7,58.27 v2(26.14,58.27) 25.71,57.84 RT189.1
  BOTTOM w0.081: UT4.F10 25.37,58.13 25.96,58.13 26.11,58.27
  BOTTOM w0.152: 26.11,58.27 v2(26.14,58.27)
N124755351: length 1.2
  TOP w0.14: v2(21.65,58.73) 21.93,59.01 T193.1
  BOTTOM w0.081: v2(21.65,58.73) 22.01,58.38 UT4.G4
N124755352: length 2.3
  TOP w0.14: T194.1 22.81,57.09 21.76,58.14 v2(21.68,58.14)
  BOTTOM w0.081: v2(21.68,58.14) 21.95,57.87 UT4.F4
N124817429: length 5.1
  BOTTOM w0.089: UH2.G3 98.29,24.73 100.75,24.73 101.08,24.4 101.08,23.97 101.68,23.37 101.98,23.37
  BOTTOM w0.14: RH581.1 101.98,23.37
N125173025: length 2.2
  BOTTOM w0.081: UT4.F1 20.53,57.96 20.37,57.96 20.25,58.08 19.7,58.08 19.43,58.34 18.85,58.34 RV1845.1
N125233563: length 2
  TOP w0.14: PC1138.2 108.59,108.64 v1(107.52,108.64)
  TOP w0.254: PC1138.2 PR1143.2
N125742089: length 1.9
  BOTTOM w0.14: RH586.1 64.11,3.96 64.88,3.96 65.14,3.7 65.14,3.38 65.22,3.3 UH7.5
N125814346: length 4.9
  TOP w0.14: v1(337.11,106.35) CN22.1 337.11,104.91 336.97,104.77 335.35,104.77 335.04,104.47 335.04,104.02 335.2,103.86 UN3.6
N125960908: length 2.4
  TOP w0.14: v1(122.25,56.91) 121.35,56.91 RZ81.2 120.89,57.37 UZ19.2
N126843005: length 17.8
  TOP w0.14: LED6.2 333.71,120.21 333.2,119.7 331.6,119.7 v1(331.15,119.25) 329.38,117.48 329.38,111.56 332.56,108.38 RE3.2
N127291407: length 5.3
  BOTTOM w0.14: CZ31.1 344.79,63.42 345.19,63.82 v1(347.47,63.82)
  BOTTOM w0.254: CZ31.1 344.28,62.93 343.76,62.42 UZ5.6
N128723349: length 1.2
  TOP w0.14: PC1521.1 188.53,103.1 v1(188.52,103.09)
N128725561: length 15.9
  TOP w0.254: PR1016.2 177.26,110.37 v1(177.05,110.58) 176.85,110.78 v2(176.85,111.16)
  IN6 w0.254: v2(176.85,111.16) 176.33,111.16 174.9,112.59 173.71,112.59 171.8,114.5 171.8,116.87 171.2,117.47 170.25,117.47 v2(170.12,117.59)
  BOTTOM w0.203: PU1001.10 168.92,117.46 169.05,117.59 v2(170.12,117.59) 170.65,117.59 PC1054.1
  BOTTOM w0.254: PC1054.1 171.03,117.21 PR1018.2
N128725563: length 0.5
  BOTTOM w0.14: 164.69,109.55 v1(164.69,109.02)
N128725569: length 1.9
  TOP w0.14: v1(172.09,118.3) 172.09,117.08 171.92,116.92 171.92,116.46
N128725595: length 3.3
  BOTTOM w0.203: PU1001.12 170.3,116.06 170.5,115.86 171.67,115.86 PC1055.1 PR1022.1
N128725605: length 3.9
  BOTTOM w0.14: v1(172.64,120.37) 172.38,120.1 172.38,118.92 PR1014.2
  BOTTOM w0.254: PR1014.2 171.4,119.42 PC1041.1 PR1013.1
N128725802: length 4.6
  TOP w0.254: v2(164.53,115.6) 165.14,116.21 PR1002.1
  BOTTOM w0.254: PR1001.1 165.7,116.29 165.93,116.06 PU1001.4 ; PR1001.1 164.83,116.78 PR1000.2 ; PR1001.1 164.83,115.91 v2(164.53,115.6)
N128726001: length 9.5
  TOP w0.14: v1(163.89,119.25) 164.16,119.25 v2(164.95,120.04)
  IN3 w0.254: v2(164.95,120.04) 165.37,119.62 169.05,119.62 v2(169.55,120.12)
  BOTTOM w0.254: PR1006.2 PR1007.1 165.52,119.51 165.38,119.37 PC1018.1 164.69,119.78 v2(164.95,120.04) ; PR1005.2 169.62,120.05 v2(169.55,120.12)
N128726023: length 2.8
  BOTTOM w0.203: PU1001.9 168.52,117.71 168.89,118.07 170.05,118.07 PR1013.2
N128726049: length 5.4
  TOP w0.14: v2(163.86,120.88) 163.98,120.88 v1(164.42,120.45)
  TOP w0.381: PR1011.1 163.3,120.88 v2(163.86,120.88)
  BOTTOM w0.254: v2(163.86,120.88) 163.95,120.88 164.35,120.47 164.67,120.47 164.72,120.52 165.25,120.52 165.61,120.17 166.79,120.17 167.04,119.91 PR1008.2
N128726112: length 16
  TOP w0.14: v1(171.5,117.12) 171.23,116.85 v2(170.31,116.85)
  TOP w0.254: PR1023.2 v2(177.46,111.13)
  IN6 w0.254: v2(170.31,116.85) 170.57,117.11 171.05,117.11 171.45,116.72 171.45,114.35 173.56,112.24 174.75,112.24 176.33,110.65 177.04,110.65 177.46,111.07 v2(177.46,111.13)
  BOTTOM w0.203: PR1021.2 171.7,116.35 PC1054.2 170.48,116.85 v2(170.31,116.85) 169.92,116.46 PU1001.11
N128727409: length 2.3
  BOTTOM w0.203: PU1501.12 188.5,118.46 188.16,118.8 188.16,119.11 ; 188.16,119.11 188.53,119.11 188.53,119.11 PR1519.1 ; 188.16,119.11 PC1532.1
N128727430: length 7.6
  TOP w0.14: PR1508.2 v1(184.29,114.48)
  TOP w0.254: v2(183.38,115.02) 183.56,115.02 184.02,115.48 PR1508.2
  BOTTOM w0.254: PR1507.1 184.45,114.69 PC1517.1 184.12,115.02 v2(183.38,115.02) 182.98,115.41 182.98,116.43 183.92,117.37 184.32,117.37 PR1505.2
N128727456: length 3.2
  TOP w0.14: 186.31,114.5 186.31,114.61 ; 186.31,114.5 PR1509.2 ; 186.31,114.5 186.31,113.29 v1(186.69,112.9)
  TOP w0.381: PR1511.1 187,115.29 186.31,114.61
N128727528: length 3.3
  BOTTOM w0.14: v1(182.86,119.96) PC1522.1
  BOTTOM w0.254: PR1515.1 184.35,118.37 184.01,118.04 PR1514.2 183.61,118.16 PC1522.1
N128727776: length 115.6
  IN2 w0.254: v2(206.86,54.15) 207.91,55.21 207.91,58.7 206.96,59.65 205.12,59.65 203.94,60.83 203.94,61.97 202.15,63.76 200.53,63.76 199.58,64.7 197.95,64.7 196.6,66.05 196.6,66.82 193.78,69.64 193.78,75.6 186.83,82.55 186.83,86.53 188.61,88.31 189.15,89.62 189.15,91.77 187.27,93.65 184.5,93.65 183.89,93.04 183.8,93.04 182.26,91.49 181.33,91.49 179.15,93.68 175.08,93.68 174.36,94.4 170.19,94.4 168.44,96.15 168.44,100.34 171.4,103.3 171.4,109.35 174.93,112.88 174.93,115.04 175.75,115.86 175.75,116.4 176.29,116.94 180.72,116.94 181.36,116.31 182.88,116.31 183.9,117.34 186.27,117.34 186.69,117.76 186.69,118.11 v2(186.44,118.37)
  BOTTOM w0.203: 186.69,117.37 186.97,117.09 PU1501.10
  BOTTOM w0.254: 186.69,117.37 186.69,118.11 v2(186.44,118.37) 186.44,119.03 PC1531.1 PR1516.2 ; PR1517.2 206.57,54.65 206.86,54.36 v2(206.86,54.15)
N128727796: length 115
  IN2 w0.254: v2(187.2,118.37) 187.07,118.24 187.07,117.6 186.42,116.96 184.06,116.96 183.03,115.93 181.2,115.93 180.57,116.56 176.45,116.56 176.13,116.24 176.13,115.7 175.31,114.88 175.31,112.72 171.78,109.19 171.78,103.14 168.82,100.18 168.82,96.31 170.34,94.78 174.51,94.78 175.24,94.06 179.31,94.06 181.49,91.87 182.1,91.87 183.65,93.42 183.73,93.42 184.34,94.03 187.43,94.03 189.54,91.92 189.54,89.54 188.93,88.09 187.21,86.37 187.21,82.71 194.16,75.76 194.16,69.8 196.98,66.98 196.98,66.21 198.1,65.09 199.74,65.09 200.69,64.14 202.31,64.14 204.35,62.1 204.35,60.96 205.28,60.03 207.12,60.03 208.29,58.86 208.29,55.05 207.64,54.4 v2(207.64,54.11)
  BOTTOM w0.203: 187.72,118.37 187.83,118.37 188.1,118.1 PU1501.11
  BOTTOM w0.254: v2(207.64,54.11) 207.64,54.99 PR1520.2 ; PR1521.2 187.25,119.39 PC1531.2 187.25,118.41 v2(187.2,118.37) 187.72,118.37
N128727911: length 3
  BOTTOM w0.203: PU1501.9 186.56,116.69 186.12,117.13 186.12,117.92 185.67,118.37 PR1515.2
N128727995: length 1.5
  BOTTOM w0.14: PR1513.1 193.74,120.08 v1(193.17,120.65)
N128735760: length 1.5
  TOP w0.14: CA125.1 9.93,8.95 9.93,8.48 9.89,8.44 UA4.10
N128735764: length 1.4
  TOP w0.14: CA124.1 8.89,9.02 9.02,8.89 9.02,8.51 9.09,8.44 UA4.12
N128861659: length 1.2
  BOTTOM w0.14: v1(104.15,85.14) 104.02,85 104.02,84.57 104.12,84.47 PC1308.2
N128861671: length 0.8
  BOTTOM w0.254: PC1308.1 104.12,82.41 PR1320.1
N128861673: length 2.5
  BOTTOM w0.14: PR1320.2 v1(104.04,80.4)
  BOTTOM w0.254: PR1320.2 104.46,81.84 PU1300.3
N128862480: length 0.8
  BOTTOM w0.254: PR1321.1 104.78,77.76 PC1337.1
N128862482: length 3.6
  BOTTOM w0.254: PU1301.3 104.08,73.96 103.81,74.23 v2(103.81,75.64) 103.81,76.7 PR1321.2
N128958711: length 3.6
  TOP w0.14: v2(241.1,112.57) v1(241.1,113.13)
  TOP w0.254: PR904.2 PC906.2 241.3,112.38 v2(241.1,112.57)
  BOTTOM w0.203: PC906.2 241.1,112.16 v2(241.1,112.57) PU900.14
N128958713: length 17.7
  TOP w0.254: PR904.1 PC906.1 241.3,110.49 v2(241.45,110.34)
  IN6 w0.254: v2(228.92,115.59) 228.92,113.29 229.81,112.4 238.51,112.4 239.07,111.84 239.95,111.84 v2(241.45,110.34)
  vias: v1(228.07,114.68) v2(227.1,115.55) v2(227.69,115.58) v2(228.29,115.59)
N128967490: length 12.7
  TOP w0.14: PR106.1 15.76,6.81 16.04,6.53 16.6,6.53 17.27,5.86 v5(18.43,5.86) 18.68,5.86 19.33,6.5 20.6,6.5 v2(20.73,6.63)
  BOTTOM w0.14: v2(20.73,6.63) 20.73,7.52 22.32,9.12 BAT100.5
N128967591: length 11.3
  TOP w0.14: v2(20.14,7.21) 20.14,7.05 19.84,6.74 19.23,6.74 18.96,6.48 17.21,6.48 16.74,6.95 v5(16.56,6.95) 16.36,7.15 15.48,7.15 15.06,7.57 PR108.1
  BOTTOM w0.14: BAT100.6 20.82,8.01 20.14,7.33 v2(20.14,7.21)
N128967644: length 8.6
  TOP w0.14: PR111.1 19.98,5.75 v5(20.96,5.75) 21.21,6.01 21.21,6.86 v2(20.07,8)
  BOTTOM w0.14: v2(20.07,8) 19.32,8.75 BAT100.7
N130300854: length 2.3
  TOP w0.14: UZ24.6 210.98,49.68 211.23,49.42 211.23,49.05 211.15,48.97 211.15,48.01 CZ98.1
N130500830: length 6.4
  TOP w0.127: v1(198.22,42.91) 199.65,42.91 RV1132.1
  TOP w0.381: v2(201.4,44.95) 201.09,44.64 QV21.5 201.09,43.49 RV1131.1 RV1132.1 ; QV21.2 201.09,45.91 v2(200.76,45.58)
  IN6 w0.381: v2(201.4,44.95) v2(200.76,45.58)
N130775721: length 2.9
  TOP w0.14: RT430.2 20.41,56.96 v2(20.19,57.18) 19.88,57.18 19.67,56.97 v1(19.55,56.97)
  BOTTOM w0.081: v2(20.19,57.18) 20.44,57.18 20.49,57.13 20.84,57.13 21.09,57.37 UT4.E2 UT4.F2
N130798734: length 3.7
  TOP w0.14: v1(216.74,46.65) 216.33,46.24 RV1083.1 216.33,44.64 216.65,44.32 QV91.1
N132000604: length 1.3
  TOP w0.508: PC1929.2 PR1914.1
N132009758: length 19.7
  TOP w0.254: v2(36.6,18.06) 37.19,17.48 v1(38.3,17.48) 40.18,17.48 40.72,16.94 41.28,16.94 PR1931.2
  IN2 w0.254: v2(29.72,24.77) 29.62,24.66 29.14,24.66 28.73,24.25 28.73,21.72 31.53,18.91 35.75,18.91 v2(36.6,18.06)
  BOTTOM w0.254: PR1910.2 30.3,24.26 29.8,24.77 v2(29.72,24.77)
N132009765: length 18.2
  TOP w0.254: PR1935.2 41.23,17.3 40.86,17.3 40.28,17.88 v1(39.65,17.88) 37.52,17.88 v2(37.31,18.09)
  IN2 w0.254: v2(29.69,24.16) 29.54,24.31 29.29,24.31 29.08,24.11 29.08,21.86 31.67,19.28 36.12,19.28 v2(37.31,18.09)
  BOTTOM w0.254: v2(29.69,24.16) 29.59,24.26 PR1910.3
N132121209: length 2.7
  TOP w0.14: RV621.2 v1(240.03,104.27)
  TOP w0.381: RV621.2 RV622.2 239.47,105.36 CV925.1
N132122697: length 6.8
  TOP w0.381: RV626.2 RV627.2 204.09,103.76 v1(203.33,103.76) 201.76,102.2 CV928.1
N132123770: length 1.3
  TOP w0.381: CV987.1 243.43,55.65 RV629.2 RV628.2
N132124417: length 3.1
  TOP w0.14: v1(241.82,92.01) 242.85,92.01 CV990.1
  TOP w0.381: CV990.1 RV637.2 RV638.2
N132190190: length 3.8
  TOP w0.14: PR1851.1 178.84,13.49 v1(178.19,12.84)
  TOP w0.254: PR1851.1 178.86,13.86 PR1800.1 179.04,14.89 179.9,14.89 180.03,14.76 PU1800.5
N132908405: length 6
  TOP w0.127: QZ14.5 221.35,118.89 221.98,119.52 v1(221.98,120.7)
  TOP w0.254: QZ14.5 QZ14.6 221.29,117.66 221.18,117.55 RV103.2 221.18,116.59 QZ18.2
N132908425: length 3.3
  TOP w0.254: QZ14.3 224.15,119.54 RV1808.2 225.17,120.56 225.92,120.56 v1(226.05,120.43)
N132908471: length 3.5
  TOP w0.127: v1(164.28,117.98) 164.92,117.98 RV1809.2
  TOP w0.254: QZ15.5 QZ15.6 165.9,118.61 RV1809.2
N132908541: length 4
  TOP w0.14: QZ17.6 252.1,44.58 252.32,44.35 252.63,44.35 252.75,44.47 QZ17.5 252.75,45.25 RV111.2 252.41,45.85 252.32,45.94 v1(252.16,45.94)
N132908575: length 2.8
  TOP w0.254: v1(170.12,118.61) RV1810.2 167.89,117.52 QZ15.3
N132908582: length 5.5
  TOP w0.254: v1(221.62,112.38) QZ18.1 221.62,113.79 222.89,115.06 222.89,116 RV112.2
N132908588: length 2
  TOP w0.14: v1(253.72,41.19) RV1811.2 253.4,42.49 QZ17.3
N132951149: length 2.9
  TOP w0.14: v1(251.56,57.93) 252.05,57.44 RV8.2 252.05,56.59 251.57,56.12 QZ6.6
N132951151: length 4.5
  TOP w0.14: QZ6.2 252.22,52.45 252.48,52.2 252.91,52.2 RV12.2 253.04,53.04 252.87,53.2 QZ6.3 v1(254.06,53.53)
N132951302: length 2.9
  TOP w0.14: v1(248.67,44.9) 249.38,45.61 RV11.2 249.56,45.98 250.4,46.82 QV3.3
N132958139: length 2.5
  TOP w0.14: RH5893.1 171.24,111.04 v1(170.82,110.62)
  TOP w0.254: RH5893.1 171.24,111.8 171.79,112.35 UV28.1
N132958145: length 4.2
  TOP w0.14: v1(174.09,109.82) UV28.4
  TOP w0.254: UV28.4 174.47,111.05 174.88,110.64 CV918.1 175.13,111.5 RV1128.1 175.11,112.13 RV1807.2
N132961365: length 5.1
  TOP w0.14: QV103.2 198.92,51.35 197.96,50.38 196.88,50.38 v1(196.6,50.1) 196.6,49.59 RV590.1
N134346262: length 3.5
  TOP w0.14: v1(245.54,45.98) 244.39,45.98 RV1112.2 243.75,47.61 QV98.2
N134965433: length 1.1
  BOTTOM w0.14: UZ25.6 14.98,62.63 CZ100.1
N134966636: length 3.5
  TOP w0.14: UM1.C6 21.15,72.08 20.73,71.66 20.73,68.93 RM4.1
N134966683: length 3
  TOP w0.14: UM1.F2 24.76,75.01 25.61,75.01 25.92,75.32 26.68,75.32 RM19.1
N134967484: length 3
  BOTTOM w0.14: v1(20.45,93.45) RM10.2 20.58,94.49 UM2.7
N135073509: length 1.3
  TOP w0.089: v2(80.54,10.94) 80.91,11.32 T2.1
  BOTTOM w0.089: v2(80.54,10.94) 80.41,10.94 80.11,11.24 UH2.AN40
N135644152: length 3.4
  BOTTOM w0.14: v1(135.48,117.63) PC1201.2
  BOTTOM w0.254: PC1201.2 136.08,116.05 136.08,115.13 136.27,114.94 PU1200.7
N135654499: length 2.3
  BOTTOM w0.14: v1(153.23,120.99) 151.72,120.99 151.19,120.47 PC1289.1
N135654501: length 4.7
  BOTTOM w0.14: PC1289.2 152.56,120.42 152.6,120.46 152.63,120.46 152.78,120.61 154.33,120.61 v1(154.59,120.87)
  BOTTOM w0.254: PU1201.7 150.77,119.49 151.09,119.81 151.53,119.81 152.11,120.39 PC1289.2
N135656021: length 3.5
  BOTTOM w0.14: v1(162.23,120.99) 162.17,121.06 160.14,121.06 159.75,120.68 PC1291.1
  BOTTOM w0.254: PR1226.2 PC1291.1
N135656023: length 2.6
  BOTTOM w0.14: v1(160.74,120.42) 160.49,120.17 160.07,120.17 159.74,119.84 PC1291.2
  BOTTOM w0.254: PC1291.2 159.96,119.54 PU1202.7
N135670058: length 3.7
  BOTTOM w0.254: PU500.9 135.64,6.45 135.91,6.18 135.91,5.64 v1(136.14,5.4) 136.65,4.9 PR500.2 136.65,4.45 PR521.1
N135673289: length 2.8
  BOTTOM w0.14: 110.35,64.86 110.35,65.58 110.75,65.98 110.75,66.93 v1(110.36,67.31)
N135676145: length 5.9
  BOTTOM w0.14: PR903.2 245.42,110.88 v1(244.56,110.03)
  BOTTOM w0.254: PR903.2 245.27,111.05 245,111.32 245,111.44 244.47,111.96 PC911.1 PR906.1 243.59,112.27 243.33,112.52 242.7,112.52 242.45,112.77 PU900.11
N135676149: length 2.3
  BOTTOM w0.254: PR907.2 246.13,112.02 PR902.2 245.37,112.7 245.37,112.02 PR903.1
N135676155: length 1
  BOTTOM w0.14: v1(237.64,113.34) PC905.1
N135689071: length 0.9
  BOTTOM w0.508: PR1603.2 249.76,100.57 PR1605.2
N135689238: length 3.9
  BOTTOM w0.254: PR1605.1 249.75,102.33 PC1606.2 248.8,102.86 PR1608.1 248.43,103.13 248.07,103.48 248.07,104 247.77,104.3 PU1600.14
N135689294: length 4.5
  BOTTOM w0.14: PR1602.2 248.08,107.95 v1(247.84,107.71)
  BOTTOM w0.254: PR1602.2 PR1604.1 PC1611.1 248.29,106.3 247.64,105.65 PU1600.11
N135689304: length 1.2
  BOTTOM w0.14: v1(246.5,100.52) 246.84,100.86 PC1605.1
N135767612: length 13.1
  TOP w0.381: PQ202.1 9.37,22.74 9.01,22.74 7.88,23.87 PR205.1 8.31,24.26 v2(8.8,23.77)
  BOTTOM w0.14: v1(8.4,24.56) 8.4,24.17 v2(8.8,23.77)
  BOTTOM w0.381: PR201.2 9.46,19.39 PQ201.4
  BOTTOM w0.508: PR201.2 9.37,18.52 PC202.2 8.64,18.8 8.64,19.63 8.8,19.79 v2(8.8,23.77)
N135767628: length 6.4
  TOP w0.381: PR204.1 14.45,20.85 PR200.2 13.21,21.24 v1(12.46,21.24) 12.29,21.24 12.07,21.46 10.63,21.46 9.29,20.12 PQ202.2
N135767648: length 2.7
  TOP w0.14: PR204.2 13.77,21.74 v1(13.55,21.96)
  TOP w0.381: PQ203.6 14.48,22.23 PR204.2
N135767654: length 4
  TOP w0.14: PR205.2 5.69,25.17 v1(5.34,25.53)
  TOP w0.381: PR205.2 8.63,25.17 PQ204.1
N135767682: length 2.3
  TOP w0.254: PQ203.3 15.91,24.4 16.23,24.72 PR210.2 16.12,24.98 15.76,24.98 PR206.2
N135767749: length 2.7
  TOP w0.508: PR213.1 12.28,22.24 11.83,22.24 10.95,23.12 PQ204.2
N135767765: length 1.1
  BOTTOM w0.508: PR209.2 14.87,31.37 14.52,31.72 PQ205.1
N135767870: length 4.3
  BOTTOM w0.381: PR216.1 12.82,31.19 13.21,31.58 13.21,31.74 13.98,32.51 14.86,32.51 15,32.37 PU201.4
N135767884: length 2.8
  TOP w0.254: PQ206.1 17.42,29.72 17.64,29.51 v2(17.64,29.04)
  BOTTOM w0.254: PR215.1 17.78,30.15 17.83,30.1 PR224.1 17.64,29.52 v2(17.64,29.04)
N135767963: length 2.7
  TOP w0.381: PQ203.5 14.45,23.75 14.86,24.16 14.86,24.82 14.61,25.07 PR218.1
N135767967: length 5.1
  TOP w0.14: PR221.2 v1(18.09,32.5)
  TOP w0.254: PR221.2 PR222.1 15.05,29.2 PQ206.3
N135767977: length 2.2
  TOP w0.14: v1(14.78,32.49) PR223.1
  TOP w0.254: PR223.1 14.78,30.64 PQ206.2
N135768200: length 0.9
  TOP w0.254: PQ203.2 16,23.75 16.05,23.8 PR210.1
N135770596: length 3.9
  BOTTOM w0.14: v1(60.72,21.03) 59.75,20.07 PR274.1
  BOTTOM w0.254: PQ223.2 58.4,20.36 58.27,20.22 58.27,20.07 58.63,19.71 PQ223.3 59,19.71 59.36,20.07 PR274.1
N135770632: length 19.6
  BOTTOM w0.254: PQ223.6 56.75,21.12 PR273.1 55.65,21.97 PR283.2 55.57,22.58 56.41,23.42 61.09,23.42 61.47,23.04 v1(61.47,22.38) 61.47,20.64 62.02,20.09 62.02,19.52 61.09,18.59 59.32,18.59 58.8,18.08 58.8,16.87 57.88,15.95 PQ220.4
N135770638: length 1.6
  BOTTOM w0.14: PR283.1 54.71,21.13 54.48,20.91 v1(54.09,20.91)
N135770716: length 3.4
  TOP w0.14: v1(20.27,26.01) 20.07,25.81 PR242.1
  TOP w0.254: PR242.1 19.12,24.97 18.29,24.14 18.29,24.02
N135770748: length 2.3
  TOP w0.254: PR239.2 16.66,25.5 16.81,25.36 17.88,25.36 18.29,25.76 18.29,25.92
N135770768: length 5.3
  TOP w0.14: PR207.1 33.94,5.39 v1(34.11,5.56) ; PR207.1 33.23,4.55 PR219.1 PC206.1 31.75,4.7 31.48,4.43 PU200.3 ; PR207.1 33.94,4.55 PR211.2
N135770796: length 59.6
  TOP w0.14: v2(23.93,4.78) 23.93,4.4 v1(23.81,4.28)
  TOP w0.254: PD202.2 19.64,9.93 21.19,8.38 21.19,7.55 21.83,6.92 22.41,6.92 22.65,7.15 PU203.1 23.71,7.15 23.85,7.01 23.85,6.2 23.78,6.12 PR251.2 ; v2(19.36,29.37) 19.33,29.37 19.15,29.19 19.15,28.68 18.61,28.14 18.3,28.14 18.09,27.93 PR253.1 ; PR251.2 PC216.1 25.14,5.83 PR245.2 ; PR251.2 23.78,4.93 v2(23.93,4.78)
  IN2 w0.254: v2(11.41,4.12) 11.49,4.2 11.49,5.64 10.75,6.38 10.75,6.86 11.33,7.44 11.33,15.6 10.66,16.26 10.66,21.46 12.24,23.04 13.13,23.04 16.07,25.98 16.07,26.42 19.02,29.37 v2(19.36,29.37)
  BOTTOM w0.254: v2(11.41,4.12) 11.41,4.75 12.33,5.67 16.07,5.67 16.31,5.44 23.27,5.44 v2(23.93,4.78)
N135770798: length 7.3
  TOP w0.254: PU202.4 v1(23.77,20.68) 23.94,20.85 23.94,22.04 23.24,22.73 22.02,22.73 20.7,24.05 PR242.2
N135770815: length 12.8
  TOP w0.508: PR237.1 21.18,26.8 v2(21.87,26.11) 21.87,25.3 PR229.2 21.65,25.03 PC211.2 21.65,23.93 22.34,23.25 23.49,23.25 24.39,22.35 v1(24.63,22.35) 26.93,22.35 PQ210.1
  BOTTOM w0.381: PQ208.4 21.37,26.5 21.75,26.11 v2(21.87,26.11)
N135770837: length 3.1
  TOP w0.254: PQ215.5 20.02,29.34 19.56,28.88 19.56,28.2 19.86,27.89 PC217.1 PR253.2
N135770888: length 6.3
  TOP w0.14: v1(22.8,30.56) 22.8,30.29 22.35,29.85 PR240.1
  TOP w0.508: PR228.2 PC210.1 21.64,28.93 v2(21.79,29.08) 21.79,29.72 PR240.1
  BOTTOM w0.381: v2(21.79,29.08) 21.79,28.97 22.26,28.5 23.29,28.5 23.41,28.62 PQ207.4
N135770896: length 6.9
  TOP w0.254: PR260.1 22.53,11.69 21.81,11.69 21.17,12.32 PR262.1 20.31,14.82 PR261.1 19.69,14.2 PQ216.2
N135770915: length 4.7
  TOP w0.14: v1(30.4,24.5) 30.4,24.23 29.69,23.52 PR232.1
  TOP w0.508: PR232.1 28.8,23.52 PQ210.2 28.27,25.58 PR225.2
N135770919: length 2.5
  TOP w0.14: v1(31.67,23.9) 31.29,23.52 PR232.2
  TOP w0.254: PR232.2 29.96,22.92 PQ212.6
N135770992: length 4.3
  TOP w0.14: v1(25.79,10.73) 25.52,10.73 24.69,11.56 PR258.1
  TOP w0.254: PR258.1 24.56,11.81 23.07,11.81 PQ217.2
N135771010: length 12.3
  TOP w0.14: PR234.2 28.57,8.29 29.26,7.6 v1(29.78,7.6)
  TOP w0.254: PQ216.6 20.34,11.68 21.35,10.67 PD202.1 21.78,9.27 22.59,8.45 PU203.3 25,8.45 PR245.1 26.03,8.32 PC214.1 26.91,8.32 PR254.1 27.65,8.32 PR249.2 27.71,8.33 PR234.2
N135771120: length 8.1
  TOP w0.508: v2(22.63,22.23) 22.62,22.24 v1(21.77,22.24) 20.84,22.24 20.7,22.1 PR230.2 PC212.2 19.74,22.12 PQ211.1 18.29,23.12 PR235.1
  BOTTOM w0.381: v2(22.63,22.23) PQ209.4
N135771130: length 2.5
  TOP w0.254: PR252.1 22.99,15.5 PQ217.1 23.55,14.44 PR259.2
N135771134: length 1.9
  TOP w0.254: PR256.2 PR257.1 23.73,12.45 PQ217.3
N135771193: length 2.6
  TOP w0.254: PR246.1 17.61,28.07 PQ215.3 18.59,28.69 18.71,28.82 18.71,29.21 18.59,29.34 PQ215.2
N135771203: length 0.9
  TOP w0.381: PQ215.6 20.38,29.99 20.52,29.85 PR240.2
N135771219: length 13
  TOP w0.14: PC215.1 26.91,9.83 v1(26.67,9.59)
  TOP w0.254: v2(22.18,7.44) 22.54,7.8 PU203.2 ; PC215.1 27.65,9.84 PR255.1 28.66,9.91 PR244.2 29.59,9.48 v2(29.4,9.29)
  IN6 w0.254: v2(22.18,7.44) 24.02,9.29 v2(29.4,9.29)
N135771268: length 4.9
  TOP w0.14: v1(34.25,1.73) 34.25,2.22 33.87,2.6 PR212.2 33.09,3.7 PR220.1 32.62,3.79 32.58,3.75 PC205.1 32.18,3.75 32.14,3.78 PU200.2
N135771321: length 1.1
  TOP w0.254: PQ213.6 17.64,26.06 18.09,26.51 PR237.2
N135771386: length 5.5
  TOP w0.381: PQ211.2 16.33,19.39 17,18.72 18.59,18.72 18.97,19.1 PR226.2 20,19.44 20.08,19.44 PR233.1
N135771412: length 1.8
  TOP w0.254: PQ214.6 19.29,18.32 19.56,18.59 20.05,18.59 20.19,18.74 20.19,18.75 20.32,18.87 PR233.2
N135771419: length 2.3
  TOP w0.14: PR235.2 20.56,23.12 v1(20.64,23.04)
  TOP w0.381: PR235.2 19.64,23.37 18.99,24.02 PQ213.3
N135771459: length 3.6
  TOP w0.254: PR236.2 21.46,18.06 21.59,17.93 PR238.2 20.96,16.59 20.59,16.22 PQ214.3
N135771494: length 1
  BOTTOM w0.14: PR272.2 60.34,16.6 PQ220.2
N135771851: length 10.7
  TOP w0.14: v1(55.97,18.5) 55.56,18.1 v2(55.56,18)
  IN3 w0.091: v2(55.56,18) 57.09,16.47 57.09,15.65 v2(58.47,14.28)
  BOTTOM w0.14: PQ221.1 57.92,13.19 58.47,13.74 v2(58.47,14.28) ; v2(55.56,18) 55.45,18.12 PR279.1 53.85,18.14 PR285.2 52.61,17.66 PQ227.6
N135772460: length 1
  BOTTOM w0.14: PQ227.3 55.4,15.86 v1(55.47,15.94)
N135772468: length 1
  TOP w0.254: PU202.1 22.47,16.66 PR250.2
N135772472: length 2.2
  TOP w0.254: PR238.1 21.26,15.67 20.96,15.37 20.17,15.37 19.94,15.6 PQ214.2
N135772484: length 4.8
  TOP w0.14: v1(22.47,20.74) 22.1,20.37 PR243.1
  TOP w0.203: PQ214.5 19.94,18.01 20.32,18.39 20.8,18.39 20.96,18.55 20.96,20.14 21.18,20.37 PR243.1
