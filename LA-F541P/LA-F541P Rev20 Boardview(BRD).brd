# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VBUS_DC_SS:
  vias: v1(22.11,25.38)
+VCC0V9_CIO: length 3
  TOP w0.089: v1(33.47,41.47) 33.24,41.7 v2(32.73,41.7)
  TOP w0.381: CT101.1 31.88,43.44 32.32,42.99 CT103.1 32.32,42.19 CT102.1 32.3,42.13 v2(32.73,41.7)
  vias: v2(28.01,40.22) v2(28.66,41.52)
+VCC0V9_DP: length 1.3
  IN2 w0.254: v2(29.31,39.58) 29.31,39.58 v2(29.31,40.22) ; v2(27.36,42.17) v2(26.72,42.17)
  vias: v1(27.12,41.59) v2(26.71,40.22)
+VCC0V9_PCIE: length 0.7
  IN2 w0.254: v2(26.71,36.97) v2(27.36,36.97)
  vias: v1(27.14,36.27) v2(26.71,38.92) v2(26.71,38.27) v2(26.71,37.62)
+VCC0V9_USB: length 1.6
  TOP w0.381: v2(28.66,38.27) 28.66,37.6 CT94.1 28.55,37.22 CT93.1
+VCC_CORE: length 4.4
  IN4 w0.254: 150.46,106.81 149.81,107.47
  BOTTOM w0.508: RH197.1 143.93,95.38 144.59,96.04
  vias: v2(148.02,107.32) v2(148.02,106.68) v2(148.02,106.05) v2(148.02,105.41) v2(148.02,104.78) v2(148.02,104.14) v2(148.02,103.51) v2(148.15,102.89) v2(148.65,107.32) v2(148.65,106.68) v2(148.65,106.05) v2(148.65,105.41) v2(148.65,104.78) v2(148.65,104.14) v2(148.65,103.51) v2(148.78,102.89) v2(149.29,104.78) v2(149.29,104.14) v2(149.29,103.51) v2(149.42,102.89) v2(151.69,103.1) v2(151.69,102.44) v2(151.75,101.85) v2(151.76,101.23) v2(151.76,100.58) v2(151.77,99.96) v2(152.28,103.24) v2(152.33,102.6) v2(152.44,101.82) v2(152.45,101.21) v2(152.45,100.55) v2(152.47,99.94) v2(153,103.24) v2(153,102.61) v2(153.63,103.24) v2(153.63,102.61) v2(153.81,87.38) v2(153.82,86.54) v2(153.83,85.88) v2(153.82,85.23) v2(153.81,82.62) v2(153.93,68.37) v2(154.29,103.21) v2(154.29,102.58) v2(154.59,87.32) v2(154.63,86.56) v2(154.61,85.89) v2(154.63,85.23) v2(154.61,84.58) v2(154.61,83.93) v2(154.61,83.28) v2(154.59,82.65) v2(154.78,107.08) v2(154.84,103.79) v2(154.85,68.37) v2(154.93,103.19) v2(154.9,102.59) v2(154.86,69.09) v2(154.97,73.09) v2(154.96,72.48) v2(155.01,71.06) v2(154.99,70.14) v2(155.11,105.74) v2(155.1,105.11) v2(155.11,104.47) v2(155.19,106.38) v2(155.37,87.35) v2(155.4,85.23) v2(155.38,84.61) v2(155.4,82.63) v2(155.4,82) v2(155.51,107.03) v2(155.47,103.8) v2(155.53,103.17) v2(155.52,102.56) v2(155.59,78.07) v2(155.58,77.31) v2(155.6,76.47) v2(155.72,104.47) v2(155.65,74.28) v2(155.69,73.08) v2(155.67,72.48) v2(155.68,71.07) v2(155.66,70.15) v2(155.75,68.36) v2(155.81,106.38) v2(155.8,105.74) v2(155.76,105.12) v2(155.88,79.72) v2(156.11,103.79) v2(156.17,103.19) v2(156.17,102.55) v2(156.17,87.28) v2(156.18,85.25) v2(156.21,84.6) v2(156.21,83.94) v2(156.16,83.28) v2(156.17,82.65) v2(156.19,81.97) v2(156.34,105.19) v2(156.34,80.19) v2(156.35,76.46) v2(156.39,106.42) v2(156.39,105.8) v2(156.35,104.47) v2(156.38,78.09) v2(156.36,77.34) v2(156.37,74.27) v2(156.79,103.75) v2(156.76,103.16) v2(156.76,102.53) v2(156.97,106.44) v2(157.01,105.79) v2(156.98,105.15) v2(156.99,104.47) v2(156.99,85.88) v2(156.97,83.91) v2(157.75,83.93) v2(157.7,80.29) v2(157.78,82.01) v2(158.77,103.56) v2(158.77,102.93) v2(158.77,102.29) v2(158.77,101.66) v2(158.77,101.02) v2(158.77,100.44) v2(158.78,99.85) v2(159.34,85.24) v2(159.34,83.93) v2(159.44,76.99) v2(159.49,103.59) v2(159.49,102.96) v2(159.49,102.32) v2(159.49,101.69) v2(159.49,101.05) v2(159.49,100.47) v2(159.49,99.87) v2(159.46,78.25) v2(159.45,77.62) v2(160.03,88.27) v2(160.12,103.59) v2(160.12,102.96) v2(160.12,102.32) v2(160.12,101.69) v2(160.12,101.05) v2(160.12,100.47) v2(160.15,99.87) v2(160.62,88.04) v2(160.78,103.58) v2(160.78,102.95) v2(160.91,87.25) v2(161.06,102.41) v2(161.24,88.08) v2(161.27,69.07) v2(161.27,68.36) v2(161.39,103.58) v2(161.39,102.95) v2(161.52,101.96) v2(161.52,101.35) v2(161.55,100.61) v2(161.55,100) v2(161.47,87.51) v2(161.68,86.54) v2(161.71,85.87) v2(161.71,85.21) v2(161.69,83.27) v2(161.69,82.64) v2(161.69,73.28) v2(161.81,79.77) v2(161.8,70.31) v2(161.87,88.08) v2(161.94,74.98) v2(162.12,68.37) v2(162.24,69.16) v2(162.29,73.29) v2(162.51,88.08) v2(162.54,74.98) v2(162.48,70.28) v2(162.87,87.44) v2(162.91,79.78) v2(162.92,73.31) v2(163.14,88.08) v2(163.09,78.16) v2(163.09,77.53) v2(163.09,76.89) v2(163.09,76.26) v2(163.06,75.63) v2(163.08,68.37) v2(163.78,88.08) v2(163.79,78.19) v2(163.79,77.55) v2(163.79,76.92) v2(163.79,76.28) v2(163.77,75.65) v2(163.86,87.32) v2(164.04,85.87) v2(164.04,84.61) v2(163.95,69.13) v2(164.06,83.93) v2(164.41,88.08) v2(164.42,78.14) v2(164.42,77.51) v2(164.42,76.87) v2(164.42,76.24) v2(164.4,75.61) v2(164.85,82) v2(164.92,69.03) v2(165.05,88.08) v2(165.35,87.4) v2(165.69,88.09) v2(165.71,79.75) v2(166.01,87.4) v2(166.04,73.29) v2(166.37,88.11) v2(166.42,86.52) v2(166.43,85.85) v2(166.42,85.22) v2(166.43,84.58) v2(166.45,83.93) v2(166.62,74.96) v2(166.57,70.27) v2(166.68,79.74) v2(166.68,73.26) v2(166.76,69.03) v2(167.06,88.11) v2(167.2,85.25) v2(167.18,84.59) v2(167.21,81.99) v2(167.19,70.29) v2(167.33,73.26) v2(167.42,87.38) v2(167.44,74.86) v2(167.59,69.04) v2(167.74,79.78) v2(168.56,68.37) v2(169.53,69.16) v2(169.46,68.36) v2(169.57,87.2) v2(169.59,85.89) v2(169.55,83.29) v2(169.59,82.64) v2(170.29,69.14) v2(171.31,69.1) v2(172.31,68.17) v5(158.76,105.02)
+VCCGT: length 2.9
  BOTTOM w0.508: RH203.1 133.03,94.99 133.03,92.43
  vias: v2(116.71,81.92) v2(116.84,81.22) v2(116.84,80.58) v2(116.84,79.95) v2(116.84,79.31) v2(116.84,78.72) v2(116.97,74.93) v2(116.97,74.3) v2(116.97,73.69) v2(116.97,73.09) v2(117.34,82.06) v2(117.48,81.28) v2(117.48,80.65) v2(117.48,80.01) v2(117.48,79.38) v2(117.48,78.74) v2(117.6,74.99) v2(117.6,74.36) v2(117.6,73.72) v2(117.6,73.09) v2(118.11,80.65) v2(118.11,80.01) v2(118.11,79.38) v2(118.11,78.74) v2(118.24,74.99) v2(118.24,74.36) v2(118.24,73.72) v2(118.24,73.09) v2(118.75,80.65) v2(118.75,80.01) v2(118.75,79.38) v2(118.75,78.74) v2(118.87,74.99) v2(118.87,73.72) v2(118.87,73.13) v2(119.38,80.65) v2(119.38,80.01) v2(119.38,79.38) v2(119.38,78.74) v2(119.51,74.99) v2(119.51,74.36) v2(119.51,73.72) v2(119.51,73.13) v2(119.76,78.17) v2(119.76,77.53) v2(119.76,76.9) v2(119.76,76.26) v2(119.83,72.58) v2(119.83,71.95) v2(120.02,80.65) v2(120.02,80.01) v2(120.02,79.38) v2(120.02,78.74) v2(119.95,75.69) v2(120.21,75.12) v2(120.21,74.49) v2(120.21,73.85) v2(120.21,73.22) v2(120.4,78.17) v2(120.4,77.53) v2(120.4,76.9) v2(120.4,76.26) v2(120.46,72.58) v2(120.46,71.95) v2(120.73,75.77) v2(120.84,75.12) v2(120.84,74.49) v2(120.84,73.85) v2(120.84,73.22) v2(120.93,80.58) v2(120.93,76.57) v2(120.97,79.62) v2(120.97,78.88) v2(120.96,77.98) v2(120.96,77.2) v2(121.11,72.59) v2(121.18,71.88) v2(121.4,76.2) v2(121.36,75.52) v2(121.4,74.75) v2(121.4,74.16) v2(121.48,73.32) v2(132.95,80.34) v2(134.49,70.11) v2(134.51,69.43) v2(134.86,79.89) v2(135.08,70.15) v2(135.1,69.47) v2(135.72,70.18) v2(135.7,69.48) v2(136.4,70.2) v2(136.37,69.45) v2(137.06,70.2) v2(138.42,70.21) v2(138.92,85.39) v2(139.06,70.21) v2(139.73,70.23) v2(139.77,88.28) v2(140.41,88.28) v2(140.37,70.25) v2(140.47,85.89) v2(141.04,88.28) v2(141.32,87.32) v2(141.68,88.28) v2(142.01,87.21) v2(142.03,86.53) v2(142.02,85.92) v2(142.31,88.28) v2(142.62,79) v2(142.62,78.36) v2(142.8,86.54) v2(142.81,85.88) v2(142.8,85.23) v2(142.8,84.58) v2(142.77,83.94) v2(142.79,83.26) v2(142.8,82.63) v2(142.95,88.28) v2(143.51,80.52) v2(143.58,88.28) v2(143.58,85.2) v2(143.59,84.58) v2(143.57,83.95) v2(143.59,83.28) v2(143.6,82.62) v2(143.59,81.99) v2(144.22,88.28) v2(144.38,87.36) v2(144.38,86.54) v2(144.36,85.87) v2(144.38,85.23) v2(144.39,84.57) v2(144.38,82.63) v2(144.7,69.1) v2(144.75,68.38) v2(144.85,88.28) v2(145.16,87.19) v2(145.16,85.89) v2(145.16,85.2) v2(145.16,84.58) v2(145.17,83.94) v2(145.16,83.28) v2(145.15,82.62) v2(145.45,79.03) v2(145.45,77.34) v2(145.38,74.41) v2(145.35,71.47) v2(145.49,88.28) v2(145.95,85.23) v2(145.93,84.59) v2(145.95,83.93) v2(145.95,83.26) v2(145.95,82.63) v2(145.95,81.99) v2(145.88,69.72) v2(145.96,85.87) v2(146.05,74.39) v2(146.02,71.44) v2(146.12,88.27) v2(146.11,79.01) v2(146.11,77.31) v2(146.55,69.76) v2(146.64,71.47) v2(146.64,69.17) v2(146.74,87.19) v2(146.74,85.89) v2(146.75,85.23) v2(146.74,79.03) v2(146.74,77.34) v2(146.67,74.41) v2(146.78,88.25) v2(146.75,86.52) v2(146.75,82.65) v2(147.17,69.72) v2(147.35,79.02) v2(147.35,77.32) v2(147.28,74.4) v2(147.26,71.45) v2(147.43,88.25) v2(147.52,86.54) v2(147.54,85.87) v2(147.52,85.23) v2(147.52,84.57) v2(147.52,83.93) v2(147.52,83.28) v2(147.52,82.63) v2(147.58,69.11) v2(148.07,88.25) v2(148.31,85.2) v2(148.31,84.58) v2(148.31,83.92) v2(148.31,83.28) v2(148.32,82.63) v2(148.31,81.99) v2(149.1,86.54) v2(149.1,85.87) v2(149.1,85.23) v2(149.12,84.58) v2(149.11,83.27) v2(149.1,82.63) v2(149.7,69.22) v2(149.89,87.19) v2(149.87,86.54) v2(149.89,85.89) v2(149.88,85.24) v2(149.89,84.58) v2(149.87,83.94) v2(149.89,83.28) v2(149.89,82.63) v2(150.19,69.8) v2(150.53,79.03) v2(150.52,77.39) v2(150.49,74.42) v2(150.49,71.45) v2(150.68,85.86) v2(150.67,85.23) v2(150.67,84.59) v2(150.67,83.93) v2(150.68,83.31) v2(150.67,82.63) v2(150.68,82) v2(150.74,69.23) v2(150.87,69.8) v2(151.18,79.04) v2(151.18,77.37) v2(151.15,74.39) v2(151.15,71.43) v2(151.46,87.19) v2(151.46,86.54) v2(151.46,85.89) v2(151.48,69.8) v2(151.8,79.05) v2(151.81,77.39) v2(151.78,74.42) v2(151.78,71.45) v2(151.82,69.22) v2(152.45,69.22) v5(117.92,76.76)
+VCCIO: length 69.3
  TOP w0.127: v2(117.82,67.73) v5(117.82,68.52)
  TOP w0.508: RH483.1 130.63,98.71 131.57,97.77 134.32,97.77 v2(136.26,95.83) ; RH30.2 176.33,87.75 v2(176.16,87.92)
  IN3 w0.254: 165.14,63.92 165.14,64.53 164.45,65.22 164.45,67.33 164.05,67.73 163.42,67.73 163.54,67.62 163.54,64.17 163.79,63.92 165.14,63.92 ; 165.14,63.92 165.14,63.7
  IN3 w0.508: v2(159.42,67.75) 159.44,67.75 159.99,68.3 160.51,68.3 161.07,67.73 163.42,67.73 ; v2(172.67,53.72) 172.49,53.54 170.1,53.54 165.14,58.51 165.14,63.7
  IN4 w0.508: v2(136.26,95.83) 136.65,95.43 136.65,87.81 138.08,86.39 138.08,82.25 139.07,81.26 141.01,81.26 141.38,80.88 141.38,74.6 141.58,74.41 141.58,74.13 142.29,73.42 v2(142.66,73.42)
  BOTTOM w0.152: UH1.G21 174.18,74.74 v2(173.86,74.42)
  BOTTOM w0.203: UH1.AG12 159.07,67.4 v2(159.42,67.75)
  BOTTOM w0.381: v2(172.67,53.72) 172.72,53.77 172.72,55.08 173.81,56.17 RH24.1
  vias: v2(117.82,67.1) v2(117.82,66.46) v2(117.82,65.84) v2(118.45,67.73) v2(118.45,67.1) v2(118.45,66.46) v2(118.47,65.84) v2(119.01,66.92) v2(119.05,67.57) v2(172.29,79.3) v2(172.29,78.72) v2(172.31,73.9) v2(172.31,73.32) v2(173.86,73.64) v2(173.85,72.84) v2(173.86,71.21) v2(173.9,70.46)
+VCCSA: length 10.3
  IN5 w0.508: 128.36,99.14 128.36,100.24 132.48,104.37 134.06,104.37 134.59,103.84 v2(134.73,103.84)
  BOTTOM w0.508: RH201.2 134.73,104.31 v2(134.73,103.84)
  vias: v2(116.32,90.83) v2(116.32,90.21) v2(116.35,89.52) v2(116.35,88.89) v2(116.95,90.83) v2(116.96,90.21) v2(116.98,89.52) v2(116.98,88.89) v2(117.59,90.83) v2(117.59,90.21) v2(117.62,89.52) v2(117.62,88.89) v2(118.22,90.78) v2(118.22,90.15) v2(118.22,89.51) v2(118.22,88.88) v2(118.86,90.78) v2(118.86,90.15) v2(118.86,89.51) v2(118.86,88.88) v2(118.86,88.24) v2(166.97,93.1) v2(167.59,93.08) v2(170.93,78.98) v2(170.93,78.39) v2(170.93,77.78) v2(170.93,77.2) v2(170.93,76.51) v2(170.93,75.93) v2(170.93,75.24) v2(170.93,74.66) v2(171.13,83.94) v2(171.14,83.27) v2(171.15,82.63) v2(171.93,85.89) v2(171.93,83.28) v2(171.93,82.63) v2(171.97,84.59) v2(172.23,76.84) v2(172.25,75.23) v2(172.25,74.65) v2(172.26,77.5) v2(172.67,93.08) v2(172.72,83.28) v2(173.29,93.08) v2(173.88,93.08) v5(115.28,90.53)
+VCCST: length 415
  TOP w0.127: PC1137.1 113.51,114.97 v5(113.51,115.85)
  TOP w0.381: PR1145.1 116.16,114.5 v2(115.83,114.17)
  TOP w0.508: RE292.1 301.92,25.26 301.92,24.95 301.65,24.68 v2(301.36,24.68) ; v2(302.49,3.25) 302.13,3.61 RE69.1 ; v2(115.83,114.17) 115.38,114.17 115.05,114.5 PR1131.1 114.76,114.56 PC1137.1 ; v2(183.1,61.49) 182.12,61.49 RH164.1 ; RH152.1 RH151.1 132.84,103.47 v2(133.5,103.47)
  IN3 w0.508: v2(117.07,93.14) 117.08,93.15 117.11,93.15 117.47,93.51 118.05,93.51 118.65,94.11 118.65,95.3 117.23,96.72 114.05,96.72 112.97,97.8 111.65,97.8 110.62,98.83 110.62,100.37 109.96,101.03 109.96,101.8 108.38,103.39 106.96,103.39 106.6,103.74 106.6,104.8 107.16,105.36 109.63,105.36 111,104 112.93,104 113.77,104.83 113.77,112.12 v2(115.83,114.17) 119.04,110.96 120.36,110.96 120.59,110.73 120.59,109.14 120.36,108.91 120.36,108.15 120.15,107.93 120.15,102.57 120.62,102.1 123.14,102.1 124.16,103.13 132.55,103.13 132.89,103.47 v2(133.5,103.47) 133.93,103.9 134.47,104.44 134.98,104.44 135.34,104.09 135.34,100.04 132.14,96.85 v2(132.14,96.67) ; v2(180.11,64.15) 180.11,63.58 182.2,61.49 v2(183.1,61.49) 184.25,60.34 187.45,60.34 194.42,53.37 213.59,53.37 214.28,52.68 215.49,52.68 215.72,52.91 216.71,52.91 216.92,52.71 218.16,52.71 218.36,52.91 220.5,52.91 223.8,49.61 229.32,49.61 231.26,47.67 231.26,47.09 234.23,44.13 234.23,41.52 236.35,39.4 250.2,39.4 257.18,32.42 257.18,30.71 260.73,27.15 264.24,27.15 267.06,24.33 v2(267.06,23.89)
  IN4 w0.508: v2(301.36,24.68) 301.76,25.09 301.76,28.5 301.22,29.04 299.77,29.04 299.17,28.44 299.17,27.29 298.78,26.9 290.93,26.9 288.35,24.31 284.68,24.31 283.64,25.35 270.08,25.35 268.61,23.89 v2(267.06,23.89) ; v2(180.56,79.05) 180.72,78.89 180.72,64.76 v2(180.11,64.15) ; v2(131.14,78.03) 131.14,79.39 134.05,82.31 134.05,94.76 v2(132.14,96.67)
  IN5 w0.508: v2(321.58,25.31) 316.65,25.31 314.45,23.12 310.01,23.12 309.63,23.5 309.63,25.02 308.88,25.76 302.44,25.76 v2(301.36,24.68) ; v2(133.5,103.47) 133.43,103.47 132.44,102.48 132.44,100.8 133.13,100.11 134.65,100.11 135.07,99.7 137.06,99.7 137.47,100.11 142.17,100.11 142.86,100.8 149.67,100.8 151.26,99.21 163.06,99.21 164.58,100.74 168.8,100.74 170.07,99.47 176.05,99.47 177.3,98.22 177.3,96.22 179.88,93.63 179.88,92.82 179.76,92.7 179.76,87.29 179.17,86.7 179.17,85.65 180.93,83.9 180.93,79.55 180.95,79.53 v2(180.95,79.49)
  IN6 w0.508: v2(302.49,3.25) 302.49,3.53 302.92,3.96 306.45,3.96 307.19,3.23 308.53,3.23 311,5.69 311.93,5.69 313.76,7.52 316.24,7.52 321.05,12.34 321.05,22.7 321.58,23.24 v2(321.58,25.31)
  BOTTOM w0.203: UH1.H30 173.55,81.84 v2(173.88,81.51)
  BOTTOM w0.381: v2(131.14,78.03) 130.67,78.5 RH570.1 RH156.1 ; UH1.H28 173.39,80.21 172.92,80.21 UH1.J28 172.64,80.3 v2(172.29,79.95)
  BOTTOM w0.508: RH97.1 119.34,93.11 RH98.1 118.77,93.28 118.74,93.31 RH100.1 117.82,93.31 117.73,93.22 117.15,93.22 v2(117.07,93.14)
+VCCSTG: length 129.3
  TOP w0.127: v5(183.19,82.55) v2(182.42,82.55)
  TOP w0.254: CH106.1 174.04,83.15 173.51,82.62 v2(173.47,82.62) ; CH105.1 174.74,81.65 173.85,80.76 173.12,80.76 v2(173.12,80.76)
  IN1 w0.508: v2(173.47,82.62) 173.47,82.19 173.27,81.99 173.27,80.91 v2(173.12,80.76)
  IN4 w0.508: v2(182.26,81.94) 181.81,81.94 181.57,82.18 181.57,91.61 177.42,95.76 177.42,98.17 176.19,99.4 170.38,99.4 169.83,99.95 169.83,100.75 171.2,102.12 171.2,103.65 169.33,105.52 169.33,109.01 167.86,110.48 165.92,110.48 165.43,110.96 162.17,110.96 161,109.79 142.33,109.79 141.29,110.82 138.65,110.82 137.34,109.52 135.35,109.52 134.98,109.15 134.98,104.44 135.34,104.09 135.34,101.1 v2(136.13,100.31)
  IN6 w0.508: v2(131.9,98.95) 130.57,97.62 129.38,97.62 127.41,95.66 123.72,95.66 123.22,95.15 123.22,87.67 127.21,83.68 v2(127.74,83.68)
  BOTTOM w0.203: v2(173.47,82.62) 173.47,82.58 UH1.G30
  BOTTOM w0.254: v2(173.12,80.76) 173.2,80.76 UH1.H29
  BOTTOM w0.381: RH165.1 128.9,79.63 127.35,81.17 127.35,83.3 v2(127.74,83.68)
  BOTTOM w0.508: RH494.1 131.7,98.75 v2(131.9,98.95) 131.9,99.47 132.28,99.86 132.94,99.86 133.67,99.13 RH496.1 RH495.1 134.62,99.77 135.16,100.31 v2(136.13,100.31)
+VSS_PLL: length 4.6
  TOP w0.305: 299.64,9.02 299.64,9.75 298.96,10.44 UE3.G1
  TOP w0.381: CE18.2 299.42,6.68 CE19.2 299.42,7.77 299.64,8 299.64,9.02
AGND: length 51.8
  TOP w0.127: v5(14.26,51.94) 13.21,50.89 v2(13.21,50.56) ; v2(4.89,42) v5(4.89,42.65) ; v2(2.67,42.63) v5(2.67,43.49)
  TOP w0.356: v2(4.15,38.3) 3.95,38.1 CA26.2 ; CA14.2 2.49,40.87 CA12.2 2.5,40.24 CA17.2
  TOP w0.508: RA74.2 11.53,41.07 v2(11.35,41.25) ; v2(2.67,42.63) 2.34,42.3 CA13.2 CA14.2 ; v2(4.89,42) 5.39,41.5 RA73.1 ; CA27.2 2.73,35.97 v2(3.02,35.69) ; CA43.2 13.94,46.41 13.55,46.01 12.41,46.01 v2(12.33,45.94) ; CA44.2 v2(5.94,44.63)
  VCC w0.203: JHP1.5 12.28,47.87 ; JHP1.5 10.42,47.87 ; JHP1.5 10.42,47.2 ; JHP1.5 12.28,47.2 ; JHP1.7 9.18,47.87 ; JHP1.7 8.2,47.2 ; JHP1.7 9.18,47.2 ; JHP1.7 7.22,47.2 ; JHP1.7 7.22,47.87
  IN6 w0.508: v2(2.67,42.63) 2.67,42.09 3.57,41.19 3.57,38.51 2.59,37.53 2.59,36.05 2.95,35.69 v2(3.02,35.69)
  BOTTOM w0.203: v2(4.15,38.3) 4.22,38.22 UA1.20 ; CA24.2 12.37,43.66 11.91,43.21 11.6,43.21 11.24,42.84 UA1.42 ; v2(6.17,43.19) 6.35,43.02 6.35,42.84 6.44,42.74 UA1.30
  BOTTOM w0.305: CA29.2 2.6,36.44 2.22,36.82 2.22,38.08 CA28.2
  BOTTOM w0.356: 12.19,44.62 12.19,44.22 12.44,43.97 12.44,43.83 CA24.2
  BOTTOM w0.381: v2(3.02,35.69) 2.24,34.91 2.24,33.99 2.36,33.86 RA94.2
  BOTTOM w0.508: CA42.1 13.42,50.78 v2(13.21,50.56) ; v2(5.94,44.63) 4.99,44.63 4.67,44.31 CA21.2 3.39,43.88 CA20.2 ; CA31.2 12.19,44.62 12.23,44.66 12.23,45.84 v2(12.33,45.94) 12.66,45.61 CA25.2 13.42,45.98 CA30.2 ; v2(7.2,59.25) 7.05,59.09 CA41.1 ; CA29.2 2.8,35.91 v2(3.02,35.69) ; RA95.2 v2(2.2,58.87)
  vias: v2(14.8,43.31)
DV12S: length 13.8
  IN5 w0.508: v2(332.26,38.67) 332.73,38.67 334.75,36.65 335.8,36.65 336.42,36.03 336.42,34.99 335.96,34.54 v2(335.34,34.54)
  BOTTOM w0.14: v2(332.26,38.67) 332.26,39.19 v1(331.43,40.02)
  BOTTOM w0.203: UR1.10 337.52,36.59 336.98,36.05 336.98,35.82
  BOTTOM w0.508: v2(335.34,34.54) 335.34,34.48 335.84,33.99 CR5.1 336.17,34.18 336.17,35.01 336.98,35.82
DV33_18: length 1.1
  BOTTOM w0.178: 338.66,40.62 338.66,40.37 338.98,40.05 UR1.18
  vias: v1(338.51,40.93)
GND: length 2868.4
  TOP w0.102: v5(342.71,84.57) v2(342.71,85.6) ; CV1000.2 247.91,61.79 ; v2(27.08,91.28) v5(27.08,90.69)
  TOP w0.127: v5(166.41,11.08) 166.68,10.81 v2(166.68,10.16) ; v5(34.42,10.88) 33.87,10.88 v2(33.34,11.42) ; v2(349.06,27.31) 349.06,28.33 v5(348.67,28.73) ; v2(327,32.59) v5(327.71,32.59)
  TOP w0.152: DT13.2 10.99,68.2 10.8,68.01 10.8,67.89 v2(10.72,67.81) ; DT13.2 11.41,68.2 11.65,68.45 v2(11.77,68.45) ; DT13.2 11.51,67.87 v2(11.75,67.87) ; v2(10.64,63.49) 10.82,63.31 DT19.2 ; v2(11.69,65.13) 11.55,65.13 DT18.2 ; DT19.2 11.18,63.05 v2(11.56,62.66) ; DT19.2 11.65,63.31 v2(11.74,63.4) ; 11.18,69.62 10.86,69.62 v2(10.62,69.38) ; 11.18,69.62 11.5,69.62 11.64,69.47 v2(11.76,69.47) ; 11.18,69.62 DT12.2 11.18,69.89 10.89,70.18 v2(10.71,70.18) ; DT18.2 v2(11.18,65.49) ; DT18.2 11.38,64.75 11.49,64.64 12.04,64.64 v2(12.09,64.69) ; v2(176.44,82.27) 176.44,83.1 176.08,83.46 175.44,83.46 CH106.2 ; v2(102.57,16.38) 102.57,16.82 102.31,17.07 101.31,17.07 100.94,17.44 100.94,17.48 v2(100.93,17.49) 100.93,17.63 100.35,18.2 v2(100.31,18.2) 100.31,18.46 v2(99.77,19) 99.52,19.25 99.07,19.25 97.26,17.45 94.84,17.45 94.11,18.17 94.11,19.56 v2(93.86,19.81) 93.86,20.13 94.24,20.5 95.15,20.5 95.41,20.24 v2(95.41,20.06) 95.43,20.04 95.43,19.41 95.23,19.21 v2(95.23,18.68) 95.57,18.34 96.71,18.34 98.44,20.07 99.61,20.07 99.93,19.75 101.18,19.75 v2(102.13,18.8)
  TOP w0.178: CM44.2 18,75.68 v2(18.07,75.75) 18.8,75.02 19.73,75.02 19.96,74.79 19.96,73.5 19.87,73.41 19.13,73.41 v2(19.1,73.38)
  TOP w0.203: v2(207.65,49.23) 207.06,49.23 206.59,49.7 U33.11 ; PU700.21 194.73,117.77 PU700.5 ; v2(23.18,75.03) 23.15,75.01 v2(23.15,74.21) ; UM1.B6 21.55,71.81 21.55,72.61 v2(21.58,72.63) ; v2(219.15,52.3) 219.17,52.31 219.17,53.46 218.4,54.23 217.11,54.23 v2(216.54,53.66) 216.54,52.38 v2(216.46,52.3) ; PU700.10 v2(192.56,118.52) ; v2(293.35,9.67) 292.88,9.67 292.36,9.15 292,9.15 291.28,8.43 290.11,8.43 289.99,8.3 287.86,8.3 287.72,8.45 287.72,9.56 v2(287.53,9.75) 287.72,9.94 287.72,12.31 287.86,12.45 290.06,12.45 290.26,12.26 v2(290.72,12.26) 292.1,12.26 292.42,11.94 v2(293.17,11.94) ; v2(24.12,69.87) 23.95,70.04 23.95,70.44 23.95,70.77 23.95,70.77 23.95,70.86 23.55,71.26 UM1.B3 ; DT14.2 10.32,67.64 10.24,67.72 10.24,68.05 10.46,68.27 v2(10.46,68.33) ; v2(9.49,8.76) UA4.11
  TOP w0.254: 10.67,36.92 10.67,35.99 11.08,35.59 11.58,35.59 11.77,35.78 CA1.2 ; RM4.2 20.7,67.95 CM41.2 20.82,67.15 22.59,67.15 v2(22.76,67.31) ; 22.37,73.43 UM1.D5 v2(21.58,72.63) ; 22.37,73.43 22.75,73.05 ; 22.37,73.43 21.99,73.81 UM1.E5 ; 22.37,73.43 UM1.E4 ; v2(293.75,20.58) UE3.A13 ; v2(219.28,49.29) YV1.4 v2(218.44,48.45) ; v2(219.28,49.29) 219.28,48.6 219.12,48.45 v2(218.44,48.45) ; v2(219.28,49.29) 219.28,51.27 CV857.2 219.15,52.24 v2(219.15,52.3) ; v2(12.96,23.94) 13.04,23.94 13.33,24.23 13.44,24.23 PQ203.4 ; UF1.7 235.31,49 v2(234.95,48.64) 235.09,48.5 UF1.8 ; v2(323.2,32.62) 322.98,32.84 UI3.10 ; v2(151.54,10) 151.54,10.35 151.8,10.61 152.3,10.61 152.43,10.48 U32.16 ; CH3331.2 74.91,3.89 v2(74.91,4.42) 75.44,4.95 CH53.2 ; DT180.2 14.45,82.21 v2(14.3,82.07) ; CT158.2 23.98,58.93 24.31,59.26 v2(24.31,59.38) ; v2(210.55,48.66) 210.55,48.72 210.59,48.76 UZ24.5 ; 22.75,73.05 v2(23.12,73.41) 22.75,73.77 UM1.E4 ; 22.75,73.05 UM1.D4 ; DT17.2 10.46,65.13 10.67,64.92 10.67,64.68 v2(10.58,64.59) ; DT175.2 15.38,88.98 v2(15.2,89.16) ; PR1925.2 49.58,20.65 PC1941.2 ; 179.25,11.86 178.82,11.43 PC1800.2 ; v2(16.14,72.32) 16.03,72.43 15.91,72.43 15.56,72.78 14.59,72.78 v2(14.22,72.42) 13.88,72.76 13.84,72.76 13.66,72.94 12.8,72.94 12.68,73.06 v2(12.68,73.78) v2(12.68,74.48) 12.68,75.62 12.8,75.75 13.19,75.75 13.78,76.34 14.43,76.34 v2(14.95,75.82) 15.06,75.71 15.71,75.71 15.74,75.68 CM44.2 ; RH401.1 67.36,6.44 66.85,6.95 v2(66.85,7) ; RT3.1 25.09,49.58 v2(25.15,49.63) ; v2(248.92,82.33) 248.92,82.29 CV992.2 ; JXDP.37 127.04,95.01 v2(126.67,94.64) ; UM1.G6 21.56,75 v2(21.56,74.96) ; CE1501.1 296.93,4.93 296.71,5.15 296.71,5.86 v2(296.5,6.07) ; v2(242.76,55.12) 242.57,54.93 242.57,53.15 242.77,52.95 UZ30.5 ; v2(21.82,57) 21.35,57 RT430.1 ; CH105.2 175.96,81.65 176.44,82.13 v2(176.44,82.27) ; v2(10.72,67.81) 11.09,67.44 DT15.2 ; UZ29.5 123.85,15.47 123.39,15.93 v2(123.39,16.39) ; DT23.2 7.38,74.22 7.03,74.22 v2(7.01,74.24) ; v2(336.84,103.61) 336.09,104.36 UN3.5 ; UM1.E4 v2(23.15,74.21) ; PQ213.4 18.94,25.64 18.21,24.92 18.21,24.73 17.64,24.15 PQ213.1 17.31,24.02 16.92,23.62 16.92,23.19 16.61,22.89 v2(16.36,22.89) ; v2(122.48,60.51) 122.83,60.85 UE7.3 ; RZ32.1 194.12,8.41 193.23,8.41 193.11,8.28 UE6.5 ; v2(14.29,83.53) 14.54,83.78 DT179.2 15.23,83.78 15.32,83.86 DT182.2 ; v2(14.31,85.79) 14.33,85.77 DT178.2 ; UF1.6 236.31,49.5 v2(236.6,49.79) 236.81,49.57 UF1.5 ; v2(11.18,65.49) DT16.2 ; DT181.2 15.4,85.43 15.16,85.18 v2(14.64,85.18) ; v2(154.18,6.22) 153.9,6.22 153.43,5.75 U32.27 ; v2(218.44,48.45) 216.41,48.45 216.2,48.66 v2(216.2,50.39) YV1.2 217.04,50.87 216.88,51.03 CV858.2 216.75,51.94 216.75,52.01 v2(216.46,52.3) ; v2(6.96,72.47) 7.05,72.56 DT24.2 ; v2(155.41,85.9) 155.75,86.25 PC2045.2 ; v2(149.18,4.76) 150.28,4.76 150.45,4.92 150.45,5.67 151.27,6.5 U32.23 ; CT163.2 27.85,39.42 v2(27.36,38.92) 27.72,38.56 RT1.2 ; v2(14.16,87.31) 14.18,87.33 DT177.2 14.95,87.42 DT176.2 ; v2(80.71,13.2) 80.71,13.4 80.39,13.72 RH5844.2 ; v2(17.06,26.53) 17.22,26.53 17.35,26.65 PR241.2 ; PC712.2 v2(189.1,120.78) 189.1,119.33 PC714.2 188.8,118.87 189.66,118.87 ; RT42.1 35.58,43.58 v2(35.58,43.95) ; v2(19.1,73.38) 18.37,72.65 17.15,72.65 16.85,72.94 CM43.2 ; 34.63,41.66 34.23,41.66 33.67,41.1 32.31,41.1 31.81,41.59 31.81,42.06 CT102.2 ; UM1.G3 v2(23.18,75.03) ; RV1836.2 184.91,116.71 184.53,117.1 184.53,117.13 184.37,117.3 PC725.2 184.39,117.75 PQ701.1 184.39,118.86 184.79,119.25 185.29,119.25 185.69,119.65 PQ701.4 186.63,120.52 PR712.2 ; v2(14.21,35.38) 14.21,35.16 13.91,34.85 CA35.2 ; UI3.21 v2(322.98,38.44) ; DT25.2 v2(7.75,60.96) ; v2(18.42,30.84) 18.23,30.65 PQ215.1 ; DT22.2 4.52,73.7 v2(4.49,73.73)
  TOP w0.279: v2(129.69,92.47) 129.65,92.51 129.65,93.17 129.31,93.51 JXDP.31 ; v2(126.33,100.62) 126.47,100.48 126.55,100.48 126.63,100.39 127.06,100.39 127.18,100.51 JXDP.59
  TOP w0.305: UZ31.3 251.38,51.83 251.17,52.05 251.17,52.48 251.42,52.73 v2(251.46,52.73) ; UZ26.3 v2(109.82,47.21) ; JXDP.7 126.1,87.51 124.6,86.01 JXDP.2 121.35,86.01 120.88,86.48 120.88,87.69 v2(120.91,87.71) ; v2(126.15,89.47) 126.65,89.47 127.11,89.01 JXDP.13 ; YM1.2 15.01,73.82 14.59,74.24 14.57,74.24 14.41,74.41 14.41,74.42 13.91,74.92 YM1.4 13.73,75.51 v2(14.04,75.82) ; RM24.2 17.39,71.5 v2(17.26,71.37) ; v2(14.01,92.04) 14.09,91.96 CV178.2 ; v2(295.36,13.37) UE3.C4 ; JAUDIO.7 6.4,16.89 6.67,16.62 6.67,16.07 7.18,15.56 v2(7.23,15.56) ; v2(26.73,49.28) RT40.1 ; v2(116.27,53.07) 116.36,53.15 116.62,53.15 116.73,53.27 UZ12.3 ; v2(120.95,93.12) 121.34,93.51 JXDP.32 ; v2(120.95,93.12) 120.95,95.17 v2(121.03,95.25) 121.27,95.01 JXDP.38 ; v2(120.95,93.12) 120.97,93.09 120.97,91.61 ; JXDP.20 120.98,90.51 120.97,90.51 ; v2(126.33,100.62) 125.93,100.62 125.23,99.93 125.23,98.01 ; JXDP.14 v2(120.97,89.01) ; v2(120.97,89.01) 120.97,90.51 ; v2(120.97,89.01) 120.91,88.94 v2(120.91,87.71) ; 120.97,90.51 v2(120.97,91.35) 120.97,91.61 ; v2(120.91,87.71) 121.1,87.51 JXDP.8 ; JXDP.50 124.08,98.01 v2(124.09,98.02) 124.1,98.01 125.23,98.01 ; RT1092.1 21.6,55.62 20.99,56.23 20.99,56.64 RT430.1 ; 120.97,91.61 121.38,92.01 JXDP.26 ; C3319.2 307.34,13.22 v2(307.34,12.88) ; JXDP.25 129.3,92.01 129.69,92.4 v2(129.69,92.47) 129.86,92.3 129.86,90.89 129.47,90.51 JXDP.19 ; 125.23,98.01 JXDP.49
  TOP w0.33: C280.2 336.78,101.9 v2(336.69,101.99) ; v2(113.31,48.03) 112.64,48.03 111.26,49.41 UZ21.3 ; C1031.2 337.34,101.87 v2(337.45,101.99) 337.64,101.99 C1033.2
  TOP w0.356: RA57.2 CA19.2 3.19,29.71 3.3,29.59 v2(3.48,29.59) ; v2(25.1,33.96) 24.96,34.1 RT12.2 ; 295.17,6.08 294.7,5.61 v2(294.33,5.61) ; RM18.2 26.43,67.35 26.19,67.11 v2(26.19,66.8) ; RT164.1 23.98,34.51 v2(23.72,34.25) ; v2(79.62,18.83) 79.44,19 CH189.2 ; RT199.2 29.1,58.17 29.55,57.71 v2(29.55,57.56) ; v2(88.42,12.41) 88.5,12.33 RH5890.2 ; v4(29.96,42.8) 29.21,42.8 29.08,42.93 CT63.2 ; v2(281.88,6.03) 281.57,5.73 CH44.2 CH196.2 ; CH188.2 65.45,17.07 v2(65.45,16.81) ; CT93.2 27.97,36.36 v2(28.01,36.32) ; C135.2 148.29,9.27 148.13,9.43 147.67,9.43 147.18,9.92 147.18,10.17 v2(147.29,10.28) ; v2(26.06,38.92) 25.88,38.75 CT100.2 ; v2(26.06,36.97) 26.04,36.96 CT99.2 ; v2(26.47,92.68) 26.47,92.67 RM28.2 ; CH3323.2 102.79,25.63 v2(102.64,25.78) 102.59,25.83 CH203.2 CH3322.2 ; v2(3.75,35.54) 3.77,35.52 CA130.2 ; CA127.2 v2(12.38,4.99) ; v2(26.63,34.23) 26.48,34.23 26.2,34.51 CT80.2 ; v2(329.19,52.96) 328.8,52.96 328.13,52.28 CR15.2
  TOP w0.381: v2(252.4,43.82) 253.11,43.82 253.4,44.1 QZ17.4 ; PC2079.2 152.35,87.87 v2(153.04,87.19) ; JAUDIO.32 18.11,17.65 18.59,17.17 v2(18.59,16.71) ; CH108.2 173.86,79.8 CH107.2 ; RT43.1 29.38,47.76 v2(29.34,47.8) 29.16,47.8 28.83,48.13 RT38.1 ; CV865.2 199.44,77.79 v2(199.11,78.12) ; 275.97,24.85 276.12,25.01 Q5.4 ; 275.97,24.85 275.97,25.91 275.58,26.31 Q5.1 ; 275.97,24.85 275.97,24.21 275.63,23.88 274.07,23.88 273.75,23.56 v2(273.75,23.18) ; UE3.A6 293.73,14.57 v2(293.63,14.67) ; v4(29.96,35.7) 29.63,35.37 CT72.2 ; RV615.2 243.76,83.58 v2(244.12,83.93) ; PU202.3 v2(24.32,17.59) ; CT71.2 CT82.2 CT81.2 26.91,34.51 v2(26.63,34.23) ; v2(153.03,85.25) 152.66,85.61 PC2074.2 ; v2(19.33,57.94) 19.43,57.84 CT146.2 ; RH1152.1 306.06,22.99 305.68,22.6 v2(305.68,21.97) ; JAUDIO.31 2.29,17.65 3.06,16.89 v2(3.06,16.65) 3.65,16.65 4,17 JAUDIO.1 ; v2(24.59,57.6) 24.36,57.6 24.17,57.79 RT429.2 ; v2(245.68,64.64) 244.88,65.44 CV1018.2 ; PC2077.2 152.59,84.41 v2(153.05,83.96) ; PQ215.4 20.48,28.69 v2(20.83,29.03) ; CH205.2 94.68,13.4 CH92.2 94.13,13.31 v2(93.95,13.13) ; UC1.3 124.38,55.01 123.16,56.23 v2(123.16,56.6) ; RH568.2 98.27,6.33 98.29,6.31 ; CV1040.2 238.62,84.04 238.16,83.58 238.16,83.53 v2(237.77,83.14) ; PR1943.1 64.36,11.15 64.63,11.41 v2(64.63,11.55) ; v2(29.1,11.49) 28.59,10.99 PR255.2 28.58,10.74 PC215.2 ; v2(109.25,43.79) 108.84,44.2 RZ50.2 ; v2(194.37,120.97) 193.92,120.97 PC711.2 ; YH2.2 v2(105.58,19.15) ; RV135.2 36.51,33.58 37.31,33.58 QV12.3 ; PQ203.1 16.15,23.1 v2(16.36,22.89) ; v2(289.93,13.52) 289.93,13.41 290.32,13.02 RH5884.1 ; CT62.2 CT64.2 ; v2(27.56,55.37) 27.85,55.67 RT437.2 RT186.2 ; QZ14.1 223.61,118.24 223.66,118.19 v2(223.87,118.19) ; PC1012.2 205.48,77.99 206.2,77.27 v2(206.37,77.27) ; CA38.2 4.71,32.94 CA39.2 ; CE37.2 290.01,4 290.58,3.43 290.68,3.43 v2(290.82,3.3) ; PC1515.2 209.82,72.69 v2(210.29,72.22) 210.44,72.06 PC1512.2 ; v2(34.56,45.76) 34.49,45.7 33.95,45.7 RT107.1 RT33.1 RT34.1 ; CV1019.2 240.87,67.33 v2(241.12,67.08) ; PC710.2 197.11,119.33 197.22,119.22 PR708.2 v2(200.03,119.22) ; PC1107.2 117.9,99.69 117.9,98.9 117.21,98.21 117.21,97.61 ; CA126.2 9.39,4.04 9.39,3.94 9.42,3.9 v2(9.42,3.86) ; v2(64.21,29.16) 64.09,29.29 RZ40.2 ; v2(134.79,2.31) 133.9,2.31 133.25,2.96 PC505.2 ; PC2084.2 147.06,68.11 v2(146.62,67.67) ; RT431.1 19.99,60.63 20.38,61.02 v2(20.45,61.02) ; CE43.2 290.51,11.9 290.72,12.1 v2(290.72,12.26) ; CZ2157.2 58.42,29.68 58.41,29.67 v2(57.94,29.67) ; v2(73.69,3.71) 73.69,3.9 73.25,4.33 73.25,4.56 CH70.2 ; PQ219.1 78.3,33.21 78.8,33.21 v2(78.82,33.22) ; CT94.2 29.4,37.49 CT66.2 30.06,37.08 v2(29.96,36.97) ; QV3.1 249.1,47.42 249.33,47.65 v2(249.67,47.65) 249.67,47.87 250.4,48.59 QV3.4 ; v2(4.62,32.28) 4.73,32.39 CA39.2 ; 159.13,8.79 CE75.2 159.58,9.97 CE76.2 ; v2(41.07,12.78) 41.45,13.16 PC1935.2 PC1938.2 ; v2(143.92,67.7) 143.55,68.07 CH3333.2 ; CA128.2 v2(3.21,8.76) ; PR1918.2 54.6,23.39 v5(54.6,24.07) v2(54.6,24.84) ; v2(213.43,70.21) 212.95,70.69 PC1508.2 ; v2(210.55,48.66) 210.3,48.41 CZ98.2 ; PC221.2 70.74,23.22 70.74,23.85 70.93,24.04 v2(70.93,24.04) ; v2(145.72,67.74) 146.06,68.09 PC2081.2 ; CH80.2 73.31,2.01 73.1,2.21 73.1,2.27 v2(72.9,2.48) ; PR261.2 19.39,15.34 19.29,15.44 PQ214.1 v2(19.29,16.71) 19.32,16.74 20.16,16.74 20.59,17.17 PQ214.4 ; v2(347.32,115.75) 348.06,116.49 CE16.2 CE15.2 ; RH188.2 133.08,73.52 133.54,73.98 133.73,73.98 133.76,74 133.77,74 134.14,74.37 v2(134.14,74.54) ; CA39.2 4.73,33.62 CA77.2 ; v2(98.8,27.87) 98.59,27.67 CH207.2 ; PC1933.2 41.76,18.97 41.45,18.67 PC1943.2 ; RH5876.2 94.63,8.23 CH187.2 ; CH3321.2 87.95,9.35 v2(88.32,9.35) ; v2(237.61,103.28) 237.72,103.38 RV619.2 ; v2(174.52,79.1) 174.48,79.05 CH107.2 ; 123.83,66.88 123.52,66.88 123.08,66.44 UZ22.3 121.94,66.44 121.29,65.79 120.52,65.79 119.69,64.95 RZ87.2 ; RT1134.2 25.77,49.39 25.44,49.72 25.24,49.72 v2(25.15,49.63) ; PC2078.2 153.05,83.26 v2(153.07,83.28) ; CH201.2 87,17.03 CH183.2 ; CT65.2 26.16,39.47 v2(26.06,39.57) ; v2(102.13,18.8) 102.23,18.89 102.94,18.89 CH48.2 103.73,18.81 103.73,18.99 v2(104,19.25) 104.02,19.23 104.77,19.23 v2(104.79,19.25) 105.24,19.7 106.24,19.7 106.47,19.47 v2(106.47,18.35) 106.47,16.91 v2(106.49,16.89) 106.49,16.32 v2(106.38,16.21) 106.38,16.18 106.2,16.01 105.69,16.01 v2(105.54,16.15) 104.87,15.48 104.28,15.48 103.93,15.82 103.93,16.13 CH47.2 103.18,16.69 102.87,16.38 v2(102.57,16.38) ; UZ23.3 105.24,52.56 v2(105.23,52.56) ; RT5.2 32.54,36.64 CT68.2 CT67.2 31.41,36.79 v4(31.23,36.97) ; v2(177.11,64.95) 177.02,64.87 177.02,64.4 177.29,64.13 CH130.2 177.67,63.31 CH131.2 ; v2(96.32,19.42) 96.32,19.49 96.65,19.81 RH5850.2 ; CE85.2 149.23,6.09 CE84.2 149.23,4.81 v2(149.18,4.76) ; CH104.2 172,70.98 v2(172.38,70.61) 172.68,70.91 CH102.2 ; RM17.2 24.98,66.54 24.56,66.96 RM11.1 24.13,66.96 v2(23.8,67.29) ; v2(175.39,4.7) 175.72,5.03 RZ1151.1 175.72,6.1 C4.2 R277.2 ; CE26.2 290.81,14.4 290.32,14.89 v2(290.32,14.97) ; CE29.2 v2(288.98,19.18) ; UZ16.5 189.94,45.93 v2(190.68,45.19) ; RM1145.1 97.89,10.16 97.56,10.5 v6(97.46,10.5) ; v2(172.97,64.38) 172.97,64.82 CH3332.2 ; v2(15.75,92.9) 15.26,93.38 CV180.1 ; v2(22.51,59.39) 22.42,59.48 CT145.2 22.44,59.97 22.74,60.27 RT183.2 ; v2(20.07,52.57) 20.58,52.06 RZ1150.1 ; v2(110.36,53.09) 110.81,53.09 111.37,53.64 UZ20.3 ; CH190.2 79.86,16.92 80.14,17.2 v2(80.14,17.26) ; CH82.2 CH204.2 90.93,4.61 90.94,4.6 v2(90.94,4.09) ; QZ15.4 167.89,120.1 v2(167.88,120.11) ; v2(296.96,14.17) UE3.E6 ; v2(28.45,73.03) 28.07,73.03 RM12.1 27.79,72.77 27.51,72.49 RM9.2 27.51,71.62 RM13.1 ; UV29.3 v2(221.22,44.88) ; CM43.2 16.31,72.71 16.03,72.43 ; PQ701.1 183.78,119.23 v2(183.78,119.71) ; v2(23.46,42.17) 23.46,41.79 CT143.2 ; JUSB2.7 335.16,72.8 DI9.3 ; v2(244.12,91.07) 243.82,91.38 CV990.2 ; QZ14.4 v2(221.29,120.18) ; CH107.2 CH110.2 ; PU203.4 28.81,9.1 v2(29.16,8.76) ; v2(284.46,5.69) QE4.4 ; v2(300.16,12.57) UE3.H4 ; PU1901.3 63.58,13.84 64.46,14.72 PR1942.2 v2(64.58,14.06) ; PQ212.4 31.26,22.29 30.86,21.9 30.48,21.9 29.96,21.37 PQ212.1 ; PC2080.2 145.25,68.1 144.88,67.72 v2(144.79,67.72) ; v2(164.06,120.07) 162.87,120.07 162.31,120.63 PR1011.2 ; v2(159.13,4.83) CE11.2 ; v2(286.26,4.09) 286.54,3.81 286.94,3.81 QE4.1 ; v2(80.53,32.81) 80.48,32.81 PQ219.4 ; CZ106.2 120.39,14.57 v2(121.67,14.57) ; RH5847.2 81.02,12.48 80.72,12.17 v2(80.72,12.09) ; 252.87,56.35 v2(252.86,56.36) ; CA125.2 CA124.2 v2(8.26,9.95)
  TOP w0.406: v2(122.3,57.53) 122.05,57.53 121.54,58.04 UZ19.3 ; 68.87,27.4 68.72,27.25 68.72,26.37 v2(68.77,26.33) ; UV20.3 199.08,44.84 v2(198.79,45.13) ; QZ17.1 252.1,43.51 v2(252.4,43.82) ; v2(228.1,45.1) 228.1,44.8 227.92,44.61 UV19.3 ; 295.17,6.08 295.17,6.72 RE311.1 ; QZ6.4 252.87,56.35 ; DI7.3 20.24,102.49 20.3,102.43 v2(20.31,102.43)
  TOP w0.432: v2(251.46,52.73) 251.46,53.42 QZ6.1
  TOP w0.457: CV885.2 216.57,69.09 215.58,69.09 ; v2(205.35,74.29) 205.35,74.43 205.18,74.6 PC1516.2 ; CD71.2 148.81,22.84 v2(149.18,22.84) ; v2(190.59,3.23) 190.39,3.43 CE2.2 ; CV900.2 219.09,75.49 v2(219.22,75.62) ; CD32.2 255.23,19.03 256.29,19.03 v2(256.35,18.96) ; v2(199.06,75.67) 198.73,75.34 CV859.2 ; CV850.2 221.15,79.39 220.83,79.71 v2(220.83,79.82) ; v2(140.08,22.57) 139.48,22.57 CD74.2 ; v2(236.92,80.73) 236.9,80.71 236.9,80.14 CV995.2 ; PC1944.1 62.69,17 v2(62.56,17.13) ; CD75.2 137.18,22.44 v2(137.86,22.44) ; C2.2 172.2,3.65 172.2,4.69 v2(172.23,4.72) ; CV881.1 200.6,75.27 v2(201.19,75.27) ; CV878.2 192.58,83.21 v2(193.26,83.88) 193.27,83.9 193.27,84.48 CV924.2 ; CD6.2 142.65,22.45 v2(142.31,22.45) ; CV880.1 191.89,82.01 v2(191.72,82.18) ; CE42.2 290.99,8.92 v2(291.21,9.15) ; RZ1958.2 237.91,5.73 UZ6.3 ; v2(75,12.22) 75.35,11.88 RH565.2 ; CV893.2 223.2,62.45 v2(223.2,62.1) ; PC1031.2 213.63,72.38 v2(213.56,72.32) ; v2(221.49,48.91) 221.13,48.91 220.79,49.25 RV581.2 ; v2(206.54,67.24) 206.54,67.15 206.25,66.87 PC1010.2 ; v2(218.15,22.48) 218.95,22.48 CD24.2 ; v2(214.18,76.34) 213.67,76.34 213.49,76.52 PC1507.2 ; v2(59.06,24.52) 59.06,23.84 CH174.2 ; v2(134.28,29.58) 134.71,29.58 CD73.2 ; CD7.2 126.06,29.94 v2(125.71,29.94) ; v2(212.3,67.26) 212.47,67.44 PC1503.2 ; CV1044.2 245.94,64.47 245.85,64.57 245.76,64.57 245.68,64.64 v2(245.68,64.64)
  TOP w0.508: v2(161.18,63.15) 160.73,63.15 CH119.2 ; PC1038.2 216.63,74.08 v2(216.74,73.97) ; CV941.2 238.94,101.09 238.75,100.9 v2(238.44,100.9) 238.44,100.34 CV955.2 240.34,99.54 CV939.2 ; RI6.2 28.34,100.19 v2(28.64,99.89) ; RH186.2 132.72,72.98 RH188.2 ; v2(132.26,106.1) 132,105.84 RH498.1 ; v2(104.84,34.01) 104.34,34.51 CE66.2 ; PR247.2 27.89,14.94 28.27,15.32 PC109.2 PC110.2 28.76,16.51 29.21,16.06 v2(29.21,15.57) ; v2(349.17,89.91) 349.27,89.82 349.27,89.23 348.83,88.79 CN6.2 ; CD88.2 v2(257.87,12.83) ; CV929.2 208.68,99.62 v2(208.33,99.27) ; v2(248.81,23.81) 249.24,23.81 249.8,24.37 CD34.2 CD35.2 ; v2(154.59,81.98) 154.59,81.3 PC2009.2 ; CV969.2 215.72,110.83 v2(216.08,110.48) ; CV972.2 215.94,107.37 216.46,107.89 CV978.2 217.13,107.89 217.64,108.39 v2(217.64,108.82) 217.64,109.14 CV960.2 ; CE23.2 310.97,16.77 v2(311.06,16.85) ; CV951.2 237.68,113.91 v2(237.9,114.12) 238.38,114.12 238.95,113.55 CV937.2 ; v2(301.45,5.92) 301.45,7.09 CE20.2 ; v2(44.55,22.3) 44.55,22.06 44.39,21.89 PR1934.2 ; CT160.2 26.39,63.16 v2(26.06,63.16) 25.54,63.16 25.52,63.13 CT159.2 ; QE20.3 138.12,13.83 138.2,13.91 v2(138.46,13.91) ; v2(344.66,88.44) 344.66,88.39 344.99,88.06 CN7.2 ; v2(146.47,22.84) 146.16,22.84 CD70.2 ; v2(93.69,6.82) 93.69,7.47 93.41,7.75 RH5876.2 ; RD39.2 248.35,16.73 247.86,16.24 v2(247.86,16.19) ; PC1115.2 PC1114.2 PR1129.2 124.21,104.78 v2(124.27,104.84) ; CD84.2 228.48,22.53 v2(228.83,22.53) ; v2(220.72,21.9) 221.18,21.9 CD87.2 ; CV962.2 211.41,111.8 211.87,111.8 v2(212.25,112.18) ; v2(214.75,98.48) 214.9,98.33 CV971.2 ; PR1110.2 119.7,112.8 v2(120.16,113.26) 120.59,112.83 PR1109.2 ; 215.58,69.09 215.11,68.62 PC1036.2 ; v2(225.02,22.25) 224.52,22.25 CD86.2 ; CH128.2 174.58,64.49 175.03,64.95 v2(175.16,64.95) ; CV882.2 201.59,84.04 201.68,83.95 201.68,83.94 v2(201.68,83.94) ; QZ18.3 220.97,114.9 v2(221.24,114.63) ; PR508.2 135.66,4.03 PR507.2 ; RV632.2 245.7,89.57 v2(245.71,89.56) ; JCR.7 330.33,45.4 331.01,46.08 v2(331.33,46.08) ; PC1131.2 115.43,99.78 115.43,98.49 114.85,97.91 114.27,97.91 113.79,98.39 113.34,98.39 112.9,98.83 v2(112.9,99.42) 113.44,99.42 PR1138.1 ; CV961.2 217.93,105.72 v2(216.61,107.04) ; v2(244.25,11.98) 243.75,11.98 v5(243.32,11.56) CZ2154.2 ; v2(235.41,42.11) 235.9,42.6 QF1.4 ; CV179.2 15.39,92.54 v2(15.75,92.9) UV16.2 ; 247.91,61.79 247.91,62.29 248.02,62.41 248.02,62.91 v2(248.12,63) ; CZ19.2 63.67,5.4 v2(63.42,5.65) 63.42,6.32 63.86,6.76 CH3327.2 ; v2(240.36,96.67) 240.96,96.08 CV1030.2 ; v2(172.31,72.43) 172.59,72.71 CH103.2 ; JCR.12 349.45,55.3 v2(348.74,56.01) ; v2(258.77,16.4) 258.74,16.4 258.32,16.82 CD90.2 CD89.2 ; v2(202.81,111.49) 203.22,111.9 CV932.2 204.52,111.95 CV976.2 ; CD25.2 168.71,28.59 v2(168.05,29.26) ; RD29.2 177.47,24.71 v2(177.78,25.02) ; v2(347.44,121.16) 347.44,120.47 UE2.1 ; PC1936.2 v2(40.23,6.73) v5(40.23,8.69) PC1927.1 ; CE25.2 296.98,6.55 v2(296.5,6.07) ; RD40.2 228.36,17.68 v2(229.04,18.36) 228.35,19.05 CD29.2 ; CH120.2 170.33,61.7 169.84,61.21 v2(169.54,61.21) ; v2(245.25,84.18) 245.23,84.2 CV1035.2 ; CT89.2 24.22,47.44 v2(24.49,47.71) ; CZ11.2 56.03,8.38 v2(55.37,7.72) ; CV988.2 239.79,91.05 CV994.2 239.78,90.83 240.12,90.49 v2(240.12,90.34) ; v2(133.16,18.39) 132.56,17.79 CD3326.2 CD3327.2 CD69.2 ; v2(249.12,67.12) 250.19,67.12 250.57,67.5 CV1003.2 ; CE22.2 313.31,15.43 v2(312.94,15.43) ; PC1514.2 204.15,76.96 v2(204.41,77.22) ; v2(136.76,29.32) 136.56,29.12 CD2.2 ; CZ588.2 108.7,54.99 v2(108.72,55.01) ; CH112.2 173.65,87.47 CH113.2 172.71,87.43 CH116.2 172.57,87.29 v2(171.88,87.29) ; v2(238.33,108.87) 238.33,109.28 237.82,109.79 237.75,109.79 ; v2(68.1,24.08) 67.39,24.08 PC220.2 ; v2(298.71,24.31) 298.71,24.23 298.25,23.77 RE61.2 CE44.2 ; v2(218.41,65.65) 218.41,65.57 218.96,65.03 219.72,65.03 CV895.2 220.16,65.46 CV894.2 ; CV950.2 231.69,107.81 v2(231.63,107.88) ; CV979.2 233.91,108.54 234.41,109.04 v2(234.41,109.68) ; v2(203.39,76.16) 203.39,76.36 CV875.2 ; PC1006.2 208.22,73.28 v2(208.34,73.41) ; CD10.2 CD9.2 182.03,20.13 v2(182.11,20.21) ; CD76.2 135.33,22.23 v2(135.78,22.23) ; CV957.2 237.62,106.35 v2(237.62,105.6) 238.06,105.6 238.38,105.92 CV925.2 ; PR403.1 349.34,22.48 v2(349.57,22.25) 349.57,21.63 PC400.2 ; v2(220.23,87.2) 220.06,87.38 218.95,87.38 218.44,87.89 CV864.1 ; RE33.1 303.09,3.86 303.09,3.4 v2(303.22,3.26) ; v2(293.28,32.51) 293.28,32.29 293.83,31.74 CE48.2 ; CV977.2 203.7,108.19 v2(203.67,108.17) ; PC606.2 280.4,31.35 279.29,30.24 279.29,29.02 278.22,27.95 v2(276.61,27.95) ; v2(222.74,29.75) 222.96,29.97 CD80.2 ; v2(223.16,79.7) 223.16,80.44 CV870.2 ; CD16.2 170.9,27.63 171.02,27.52 CD17.2 171.02,26.14 169.98,25.1 v2(169.47,25.1) ; RV631.2 v2(242.7,69.56) ; CV1039.2 245.05,87.28 v2(245.32,87.01) ; CV885.2 216.79,68.18 v2(216.74,68.12) ; PR1108.2 121.55,112.8 v2(122.01,113.26) 122.44,112.83 PR1107.2 ; v2(214.18,76.34) 213.98,76.54 CV1050.2 ; v2(330.33,31.37) 330.33,32.01 331.09,32.77 331.47,32.77 ; v2(238.36,108.07) 238.66,107.77 CV954.2 CV956.2 ; v2(15.73,44.93) 14.99,45.67 DA9.2 ; RV579.2 222.36,52.84 222.38,52.86 RV656.1 222.44,52.93 222.38,52.99 v2(222.38,53.85) ; CZ97.2 179.63,87.31 179.57,87.25 v2(178.81,87.25) 178.81,86.66 CH117.2 ; CV1034.2 CV1013.2 250.64,84.42 v2(250.29,84.76) ; CV1028.2 CV1029.2 CV1027.2 v2(239.74,96.25) ; RD30.2 CD18.2 150.08,20.17 150.08,22.4 150.48,22.81 v2(150.74,22.81) ; v2(45.65,36.57) 45.2,36.11 CV169.2 ; RV601.1 216.97,83.2 v2(217.51,83.2) ; PC217.2 20.83,27.61 v2(20.83,29.03) ; CI12.2 18.39,107.13 v2(17.98,107.53) ; CH126.2 167.22,61.23 v2(167.02,61.23) ; CV974.2 214.87,99.96 v2(214.75,100.08) ; v2(49.15,7.88) 49.01,7.88 48.58,8.31 PC1911.2 PC1912.2 ; RV1128.2 176.02,110.66 CV918.2 176.04,110.36 177.25,109.15 ; UZ8.2 55.63,29.47 57.15,30.99 v2(57.15,31.62) ; v2(123.36,18.32) 123.36,18.69 123.11,18.94 RH211.2 ; v2(249.94,63.76) 250.32,63.37 CV1005.2 CV1006.2 ; PC1025.2 207.96,74.93 v2(208.34,75.31) 208.93,74.73 PC1029.2 ; RV654.1 RV652.1 228.23,53.22 v2(228.47,53.47) ; RV654.1 RV644.1 ; RV654.1 v2(229.12,53.49) ; RD38.2 246.08,18.83 v2(246.08,18.36) ; v2(111.92,2.18) 111.92,2.87 SW4.4 111.28,2.82 v2(111.28,2.18) ; JCR.15 350.11,50.75 349.85,51 v2(349.51,51) ; CV1025.2 248.88,84.29 v2(248.88,83.9) ; v2(12.97,39.18) 12.47,39.68 RA74.1 ; v2(110.43,105.79) 110.71,106.08 110.71,106.09 110.99,106.36 PC1109.2 ; v2(204.27,107.47) 204.53,107.2 CV926.2 ; v2(208.35,105.68) 208.55,105.48 RV620.2 ; v2(126.19,18.33) 125.72,18.8 RH209.2 ; v2(234.05,18.36) 233.89,18.19 RH210.2 ; PC1939.2 47.78,21.53 v2(47.78,22.1) ; RZ43.1 264.34,39.71 264.91,39.14 v2(264.97,39.14) ; CV919.2 166.1,116.91 QZ15.1 164.83,117.4 164.22,116.79 PR1002.2 164.14,116.32 163.01,116.32 162.93,116.4 PC1252.2 ; v2(239.52,50.42) 239.9,50.04 CF2.2 ; v2(69.75,5.9) 70.21,5.9 70.79,6.48 CH52.2 ; v2(208.93,110.69) 209.19,110.43 209.19,109.53 CV930.2 ; PC1007.2 210.07,77.03 v2(210.32,77.28) ; CV884.1 214.96,67.3 215.73,66.53 CV888.2 216.03,66.47 v2(216.74,66.47) ; v2(227.09,107.69) 227.09,107.7 227.53,107.7 CV980.2 ; CV899.2 223.52,86.72 v2(223.33,86.53) 222.72,86.53 CV873.1 222.12,87.12 CV863.2 ; YH2.4 104.48,16.28 v2(104.61,16.15) ; CV935.2 209.17,107.49 v2(208.56,106.88) ; v2(231.31,111.18) 231.45,111.33 CV942.2 ; QV105.3 230.59,43.45 v2(230.94,43.79) ; PC1941.2 48.67,21.57 48.67,21.88 v2(48.45,22.1) ; v2(116.1,97.61) 116.59,98.1 PC1132.2 ; C3320.2 308.4,6.86 v2(307.94,7.32) 307.41,6.78 CE27.2 ; RM13.1 27.9,71.34 28.07,71.5 v2(28.45,71.5) ; PR217.2 11.16,25.6 PQ204.3 10.7,25.15 v2(10.01,25.15) ; v2(240.86,62.99) 240.92,63.04 RV616.2 ; v2(108.97,109.73) 108.97,109.36 109.55,108.78 PC1138.1 ; v2(292.98,3.11) 292.98,3.33 292.84,3.47 292.84,3.83 CE38.2 ; v2(210.01,80.7) 209.22,79.91 CV903.2 208.43,79.1 CV921.2 ; CV927.2 224.57,110.66 RV625.2 v2(222.51,110.66) ; v2(208.25,45.12) 208.09,44.96 207.27,44.96 206.81,45.42 RV550.2 206.74,45.78 205.04,45.78 204.09,46.74 RV1844.2 ; PC1364.2 114.69,93.87 113.84,93.01 v2(113.34,92.51) ; PD102.1 v2(20.53,3.11) ; PC1937.2 v2(33.34,11.42) ; CD20.2 213.6,23.66 v2(214.12,23.66) 214.59,23.66 214.99,23.25 CD83.2 ; v2(304.68,6.99) 304.68,6.42 CE40.2 303.87,6.29 CE52.2 ; v2(249.94,60.71) CV1009.2 250.64,60.14 CV1004.2 ; CI3.2 326.85,32.44 v2(327,32.59) ; RE44.2 294.33,5.11 v2(294.33,5.61) ; CD78.2 v2(142.86,29.11) CD79.2 ; PC711.2 PC707.2 ; v2(237.15,92.63) 236.14,92.63 CV1021.2 ; CV989.2 247.97,95.89 RV636.2 v2(247.97,94.2) ; CV1008.2 247.79,54.66 v2(247.79,55.62) ; CE30.2 286.89,15.11 v2(286.77,14.99) ; PR105.2 23.2,89.32 PQ101.3 23.86,89.42 24.05,89.6 v2(24.05,90.13) ; v2(125.76,109.31) PC1110.2 125.74,108.51 PC1116.2 ; v2(331.41,118.65) SW1.4 ; PR1923.2 53.61,21.1 53.73,21.22 v2(53.73,21.44) ; v2(33.76,1.93) v2(33.14,1.93) 32.54,1.93 PC207.2 32.48,2.33 32.2,2.62 PC205.2 32.42,2.83 32.46,2.87 PR220.2 ; QV102.3 242.44,92.85 v2(242.25,92.66) ; v2(268.11,3.47) 268.11,4.08 267.51,4.67 CD40.2 CD41.2 ; v2(211.43,52.53) 211.38,52.58 CV907.2 210.76,52.29 210.14,51.66 CV817.2 ; CV860.2 198.96,73.22 v2(198.95,73.2) ; UV28.3 172.7,111.05 172.88,110.87 172.88,109.93 v2(173.06,109.75) ; v2(112.22,114.78) 112.45,114.56 PC1137.2 ; v2(211.66,80.7) 211.5,80.86 CV901.2 ; v2(248.94,56.6) 248.28,56.6 CV999.2 ; v2(247.38,68.12) 247.27,68.01 CV1002.2 ; v2(312.89,12.33) 312.45,11.89 C3321.2 ; v2(348.63,109.61) SW2.1 ; CI4.2 318.87,38.81 v2(318.5,38.44) ; v2(205.35,70.31) 205.49,70.45 PC1014.2 ; PQ212.1 27.62,20.64 v2(27.46,20.8) 26.11,19.46 PC213.2 ; CV1043.2 238.33,67.67 238.33,67.2 v2(238.52,67.01) ; PC1945.1 41.77,19.44 PC1933.2 41.14,19.43 v2(40.89,19.68) ; CE11.2 161.3,5.97 162.24,6.9 v2(162.46,6.9) 162.46,7.05 161.66,7.85 160.07,7.85 159.13,8.79 ; CZ96.2 181.98,87.33 v2(182.5,86.81) ; CD38.2 CD39.2 ; v2(216.74,71.47) 216.69,71.43 CV922.2 ; PC1056.2 173.36,114.66 v2(173.53,114.48) ; CV1015.2 249.54,65.27 v2(249.75,65.47) ; RH183.2 132.47,78.7 RH184.2 133.36,78.7 v2(133.55,78.51) ; v2(339.47,100.03) C267.1 ; CV1036.2 242.34,87.15 v2(241.71,87.15) ; v2(230.43,98.49) 230.59,98.65 CV983.2 ; QI10.3 325.63,45.92 v2(325.63,45.59) ; v2(88.67,21.85) 88.43,21.61 CH192.2 ; v2(194.5,63.56) 194.7,63.36 CV866.2 ; v2(338.02,105.93) CN22.2 ; CV906.2 214.07,54.02 v2(213.95,54.14) ; CV887.2 206.66,80.72 v2(206.67,80.74) 206.72,80.79 CV889.2 ; JRTC.3 v2(326.9,102.05) ; CD72.2 140.38,28.75 139.87,29.26 ; RV561.2 28.45,76.46 v2(28.58,76.58) ; CD82.2 218.48,29.09 v2(219.16,29.09) 219.83,29.09 CD81.2 ; v2(205.94,108.1) 206.04,108.01 206.04,107.47 CV936.2 ; CV1010.2 v2(243.97,61.91) ; PR1511.2 188.8,115.57 v2(188.9,115.67) ; v2(325.31,55.56) 325.59,55.29 RI27.2 CI22.2 ; PC1121.2 v2(124.08,108.52) ; CE3323.2 202.57,54.74 v2(202.88,55.06) ; v2(190.89,22.17) 190.89,22.16 CD21.2 ; CA131.2 86.09,13.29 v2(86.83,14.02) 86.89,14.09 CH176.2 86.89,14.92 87.56,15.59 CH206.2 87.59,15.87 CH183.2 ; v2(123.83,112.14) 124.22,111.75 PR1116.2 ; v2(60.54,4.92) 60.45,4.83 59.44,4.83 59.31,4.95 CZ18.2 ; v2(347.98,24.91) PR405.1 ; v2(146.56,29.74) 146.78,29.97 CD1.2 ; v2(223.2,63.78) 223.81,64.38 CV896.1 CV897.1 ; C3.2 169.67,4.4 169.29,4.01 v2(167.12,4.01) ; PC1027.2 207.33,77.15 206.88,77.6 PC1009.2 207.38,78.11 v2(207.57,78.3) ; CV1007.2 247.96,59.96 v2(248.12,59.8) ; v2(249.68,79.88) 249.68,79.5 CV1023.2 ; v2(150.53,29.78) 150.16,30.14 CD5.2 ; v2(231.17,105.67) 231.96,105.67 CV948.2 ; v2(14.56,35.97) 14.6,35.97 14.94,36.3 CA2.2 ; v2(175.95,62.49) 175.68,62.49 CH129.2 ; QR104.3 177.67,7.77 RE143.1 178.42,6.86 178.68,7.11 179.45,7.11 v2(179.66,7.31) 179.76,7.21 179.76,6.48 180.6,5.65 QRTC1.3 ; v2(227.07,110.88) 226.3,111.65 CV982.2 ; v2(250.38,93.41) 250.08,93.1 CV1037.2 248.11,93.47 CV1020.2 ; RV1841.2 197.56,52.95 v2(196.5,54.01) ; v2(227.09,42.46) 227.47,42.84 RV580.1 ; 139.87,29.26 139.87,29.24 139.37,28.75 CD8.2 ; 139.87,29.26 139.87,29.93 v2(139.87,29.93) ; v2(196.66,85.6) 197.08,86.02 CV879.2 ; v2(195.92,6.6) 195.92,7.19 195.52,7.58 RZ32.1 ; RV651.1 v2(223.45,53.6) ; CV940.2 226.3,98.6 CV986.2 226.3,99.6 226.86,100.15 v2(227.21,100.15) ; PC1934.2 53.89,19.53 54.36,19.53 v2(54.45,19.62) ; CV499.2 245.89,49.11 v2(246.34,49.57) ; CI1.2 27.03,96.84 26.95,96.92 v2(26.95,96.93) ; DE5.1 186.95,14.23 186.56,13.84 186.56,12.47 186.57,12.46 v2(186.57,12.41) ; PQ225.3 72.12,24.58 71.99,24.44 v2(71.99,24.34) ; CF1.2 240.75,44.65 v2(240.75,44.13) ; PC1010.2 206.25,65.55 PC1032.2 206.27,65.42 205.65,64.8 CV851.2 ; UT5.4 40.11,25.76 v2(40.11,25.22) 40.11,24.96 CT47.2 ; PC1513.2 211.46,74.42 v2(211.33,74.29) ; v2(111.1,111.23) PC1100.1 PC1103.1 ; JRTC.4 v2(333.85,97.46) ; CV1038.2 CV997.2 v2(238,92.62) ; CV953.2 237.7,101.59 v2(237.61,101.68) ; CV944.2 v2(224.68,113.79) ; PC1104.1 v2(110.36,107.63) ; v2(238.13,97.42) 237.44,98.1 CV985.2 ; CD77.2 133.33,22.64 v2(133.93,22.64) ; v2(226.45,53.44) RV643.1 RV653.1 ; CD22.2 215.86,21.45 v2(215.86,21.45) ; RH567.2 105.82,8.52 106.31,8.03 106.31,7.12 v2(106.32,7.11) ; QV101.3 v2(219.4,106.59) ; PC1928.2 PR1909.1 55.34,15.69 v2(55.61,15.42) ; v2(237.72,87.13) 237.92,86.93 CV1033.2 ; v2(227.01,109.26) 226.78,109.5 226.59,109.5 226.28,109.81 CV981.2 ; v2(240.13,11.98) 240.13,11.71 CS14.2 ; v2(214.75,101.68) 214.88,101.8 CV973.2 ; CV998.2 247.89,79.33 v2(247.27,79.95) ; v2(241.78,29.27) CD28.2 243.51,29.27 v2(243.53,29.25) 243.56,29.27 CD27.2 ; v2(308.04,18.8) 307.85,18.61 CE24.2 CE31.2 ; RI25.2 320.3,40.39 v2(320.74,40.83) ; RV642.1 v2(225.43,53.44) ; RZ1958.2 238.7,6.22 238.32,6.61 v2(237.87,6.61) ; v2(248.62,91.43) 248.66,91.39 CV1031.2 ; v2(311.09,19.81) RE30.2 ; v2(174.51,75.19) 173.82,75.19 173.1,75.91 CH109.2 ; v2(117.22,97.61) 117.21,97.61 117.36,97.77 PC1126.2 ; CV1048.2 246.51,66.6 246.92,67.01 v2(247.32,67.01) ; v2(349.56,20.32) PR404.2 ; PC222.2 69.09,23.53 PR280.2 68.08,22.52 v2(68.08,22.12) ; v2(250.13,52.9) 249.99,53.04 RV1350.2 CV920.2 ; CD23.2 216.51,28.75 v2(216.17,29.08) ; PC1940.2 45.44,21.58 v2(45.44,22.1) ; CZ2156.2 126.06,66.55 v2(124.51,66.55) 124.18,66.88 123.83,66.88 ; v2(212.08,23.6) 211.69,23.6 CD19.2 ; v2(349.06,27.31) PC335.2 ; v2(215.09,79.9) 215.04,79.95 CV902.2 213.86,79.73 CV923.2 ; CV1051.2 218.4,79.53 v2(218.4,78.89) ; CH127.2 170.63,67.74 v2(171.29,68.39) ; v2(74.64,29.74) 74.26,29.74 74.01,29.98 ; v2(219.05,109.53) 218.66,109.92 CV958.2 ; v2(236.48,117.02) 236.48,116.52 PC904.2 236.84,116.27 237.11,116.54 v2(237.11,117.04) ; CV872.2 223.65,82.81 223.37,83.08 v2(222.42,83.08) ; PC1502.2 205.05,66.65 v2(204.43,67.27) ; RI23.2 321.16,31.12 v2(321.16,30.35) ; v2(213.78,49.15) 213.78,48.99 213.06,48.26 RV1838.2 ; PR811.1 108.26,65.03 108.46,65.22 109.31,65.22 v2(110.29,66.19) ; CV991.2 247.95,83.83 v2(248.13,84.01) ; v2(56.34,24.92) 55.86,24.44 PR1920.2 55.86,23.38 PQ1906.3 ; v2(162.07,63.81) 162.6,63.28 CH123.2 ; CA129.2 11.45,7.31 v2(11.45,6.43) ; v2(173.86,67.31) 174.19,67.64 CZ49.2 ; v2(343.07,115.32) 343.19,115.44 DL1.1 ; v2(236.01,110.48) 236.48,110.95 236.48,111.67 CV938.2 ; CH132.2 172.19,63.32 v2(172.05,63.19) ; CH3320.2 92.74,5.56 93.32,5.56 CH200.2 93.78,5.15 93.78,4.12 CD3324.2 93.45,3.57 94.21,3.57 94.59,3.19 94.59,2.95 v2(94.58,2.95) ; v2(80.84,6.89) 80.84,6.87 80.9,6.81 CH198.2 RZ1149.1 ; CV1032.2 v2(244.12,91.07) ; v2(26.04,6.53) PC214.2 26.91,7.41 PR254.2 ; RE31.1 308.86,3.23 308.71,3.37 UE5.3 308.12,3.67 v2(307.72,4.07) ; CV898.2 202.85,78.21 203.52,78.88 CV890.2 203.52,80.24 203.98,80.7 v2(204.16,80.7) ; RH544.2 66.45,4.57 v2(65.66,4.57) ; PC1033.2 210.14,68.91 v2(210.43,69.21) ; v2(234.7,44.58) 234.33,44.21 QF1.1 ; v2(231.4,106.88) 231.36,106.91 230.93,106.91 230.63,106.62 CV949.2 ; PC1039.2 206.25,69.22 v2(206.33,69.3) 206.33,69.35 207.21,70.23 PC1011.2 ; CV993.2 248.13,87.36 v2(248.13,87.96) ; CE3319.2 277.52,13.44 277.78,13.18 v2(277.78,12.65) 277.75,12.62 CZ46.2 ; v2(244.12,59.8) 244.44,59.8 CV1041.2 ; RZ41.2 CE41.2 287.33,20.72 287.45,20.59 RE58.2 286.57,20.19 v5(286.01,19.63) 285.45,19.63 285.3,19.48 v2(285.3,18.74) 284.49,17.93 CE17.2 ; RZ46.1 v2(59.16,8.89) ; CE71.2 v2(284.02,15.57) ; v2(194.93,88.64) 196.29,88.64 CV869.2 ; CV946.2 v2(225.88,113.79) ; RH212.2 231.96,18 232.3,18.35 v2(232.3,18.35) ; CV1042.2 245.77,67.67 246.13,67.31 v2(246.13,67.18) ; v2(121.67,14.57) 122.02,14.93 CZ105.2 ; v2(226.72,29.82) 226.4,30.14 CD85.2 ; CV891.2 199.16,67.73 v2(199.16,68.1) ; CV852.2 201.04,61.86 CV854.2 200.98,61.48 201.33,61.13 202.32,61.13 202.55,61.35 202.55,62.18 v2(202.51,62.22) ; RV602.1 219.53,77.48 219.97,77.92 v2(219.97,78.12) ; PC1101.2 117.67,112.61 118,112.94 PC1102.2 v2(118.62,113.62) ; RV566.2 212.29,43.71 212.76,43.71 v2(212.95,43.91) ; RH187.2 132.08,75.29 132.93,75.29 RH185.2 132.96,75.02 132.86,74.93 v2(132.86,74.54) ; UZ30.9 v2(244.1,50.93) ; v2(131.14,94.24) 131.14,94.14 132.49,92.8 CD3328.2 ; CV1022.2 240.12,79.91 v2(240.12,80.73) ; RV655.1 v2(224.42,53.59) ; RE32.1 311.05,10.29 v2(311.1,10.34) ; DA4.2 3.15,44.62 v2(3.07,44.54) ; 156.72,120.27 156.39,120.6 151.4,120.6 151.13,120.33 ; PD100.2 28.32,83.97 v2(28.7,84.35) ; RZ86.2 RZ71.2 115.28,51.86 v2(115.28,52.46) ; CH197.2 120.46,53.51 120.98,52.99 v2(121.05,52.99) ; CT96.2 21.13,36.31 v2(21.05,36.23) ; PC216.2 24.89,3.8 PC200.1 v2(24.1,3.78) ; v2(329.19,52.96) 329.8,52.35 JCR.4 ; QV12.3 37.57,33.33 v2(37.57,32.69) ; CV931.2 211.4,106.73 v2(211.4,106.74) ; v2(26.29,99.32) 25.93,98.96 25.93,97.97 26.3,97.6 RI7.2 ; v2(232.93,110.57) 233.59,111.23 CV943.2 ; v2(260.53,43.05) 260.16,43.05 CZ9.2 259.28,43.93 v2(259.28,44.27) ; CZ2155.2 239.14,53.09 v2(238.76,53.47) ; v2(348.63,113.28) SW2.2 ; v2(213.15,110.48) 213.15,111.2 213.48,111.52 CV970.2 ; CE70.2 287.21,13.01 287.58,13.38 v2(287.99,13.38) ; v2(196.61,23.44) 196.62,23.42 CD26.2 ; v2(229.61,107.28) 229.69,107.36 CV952.2 ; CV917.2 172.26,113.41 172.01,113.15 v2(171.23,113.15) ; CE51.2 v2(300.91,24) ; v2(349.56,18.54) PR406.2 ; v2(339.35,105.21) RN33.1 ; v2(176.39,10.88) 175.59,11.68 175.59,14 177.29,15.7 PR1804.2 ; CV1026.2 v2(236.03,97.75) ; CV965.2 209.59,111.38 v2(209.04,111.38) 208.6,111.82 CV975.2 ; v2(184.16,21.89) 183.82,21.89 183.13,21.2 CD4.2 CD3.2 ; v2(236.92,67.01) 236.34,67.59 CV1046.2 ; CV1024.2 246.38,86.11 246.64,85.85 v2(246.71,85.85) ; CV996.2 250.65,89.27 250.14,88.76 v2(249.78,88.76) ; v2(205.35,74.29) 205.42,74.21 PC1023.2 ; v2(293.42,30.04) 293.1,29.72 PC613.2 ; v2(112.17,100.05) PR1137.2 PC1129.2 ; CR14.2 327.86,49.08 327.53,49.4 v2(327.32,49.4) ; CV945.2 v2(223.47,113.79) ; CH114.2 178.89,88.2 178.89,89.64 v2(178.75,89.78) ; v5(240.88,108.45) 240.88,109.44 v2(239.91,110.41) ; v2(349.56,17.59) PR410.2 ; CV947.2 v2(227.08,113.79) ; v2(228.09,47.93) CV853.2 ; JRTC.2 v2(331,106.17) ; CE65.2 194.88,9.37 196.61,7.64 v2(196.61,6.58)
  IN1 w0.508: v2(6.57,40.9) 6.57,41.57 3.6,44.54 v2(3.07,44.54)
  VCC w0.203: JHDMI1.20 13.1,90.7 ; JHDMI1.20 13.1,91.68 ; JHDMI1.20 10.44,90.7 ; JHDMI1.20 11.77,90.7 ; JHDMI1.20 10.44,91.68 ; JHDMI1.20 13.1,92.66 ; JHDMI1.20 11.77,92.66 ; 11.32,82.38 JHDMI1.5 ; JHDMI1.5 12.22,82.38 ; JHDMI1.5 11.32,81.48 ; JHDMI1.5 12.22,81.48 ; JHDMI1.5 12.33,81.93 ; JHDMI1.5 11.21,81.93 ; 10.44,78.16 JHDMI1.23 ; JHDMI1.23 13.1,77.18 ; JHDMI1.23 11.77,78.16 ; JHDMI1.23 13.1,78.16 ; JHDMI1.23 10.44,77.18 ; JHDMI1.8 11.13,83.43 ; JHDMI1.8 10.12,83.88 ; JHDMI1.8 10.01,83.43 ; JHDMI1.8 10.12,82.98 ; JHDMI1.8 11.02,82.98 ; JHDMI1.8 11.02,83.88 ; 11.21,87.93 JHDMI1.17 ; JHDMI1.17 12.22,87.48 ; JHDMI1.17 12.33,87.93 ; JHDMI1.17 11.32,88.38 ; JHDMI1.17 12.22,88.38 ; JHDMI1.17 11.32,87.48 ; JHDMI1.2 11.02,79.98 ; JHDMI1.2 10.01,80.43 ; JHDMI1.2 11.13,80.43 ; JHDMI1.2 10.12,80.88 ; JHDMI1.2 10.12,79.98 ; JHDMI1.2 10.57,79.87 ; JHDMI1.2 11.02,80.88 ; 11.21,84.93 JHDMI1.11 ; JHDMI1.11 12.33,84.93 ; JHDMI1.11 12.22,84.48 ; JHDMI1.11 11.32,85.38 ; JHDMI1.11 12.22,85.38 ; JHDMI1.11 11.32,84.48
  BOTTOM w0.102: v2(15.73,44.93) 15.21,44.93 v5(15.11,44.83) ; v2(85.32,3.84) 85.4,3.91 85.4,4.41 UH2.BG28 85.61,4.63 85.61,5.64 86.07,6.1 86.43,6.1 UH2.BC26 ; 80.02,9.54 v2(79.95,9.54) ; v2(241.71,87.15) 241.74,87.18 242.56,87.18 UV26.J10 ; v2(75,12.22) 75.2,12.03 UH2.AM49 ; 96.25,17.59 96.25,16.43 96.5,16.18 96.61,16.18 v2(96.98,15.81) ; v5(220.78,101.82) 220.6,101.99 v2(220.16,101.99) ; UH2.BC31 84.23,6.1 83.82,6.1 83.42,5.7 83.42,4.86 83.38,4.82 UH2.BG33 ; 106.72,72.68 106.83,72.8 ; 240.45,111.05 PC912.2
  BOTTOM w0.107: UV23.J10 v2(235.21,104.08)
  BOTTOM w0.127: v5(67.16,24.4) 67.48,24.08 v2(68.1,24.08) ; v2(112.22,114.78) v5(111.44,114.78) ; v2(323.2,32.62) 323.21,32.61 v5(324.42,32.61) ; v2(108.97,109.73) v5(108.09,109.73) ; v2(109.13,15.72) 109.51,15.72 v5(110,15.23) ; v2(327.32,49.4) v5(328.05,49.4) ; v2(80.53,32.81) v5(81.4,32.81) ; v2(127.73,84.42) 127.35,84.05 v5(126.83,84.05) ; v2(134.76,64.8) 134.77,64.8 134.77,64.79 134.88,64.9 135,64.9 136.28,66.17 137.11,66.17 137.15,66.2 137.68,66.2 137.99,65.9 UH1.BR9 ; CT189.2 15.69,53.12 15.39,53.42 v5(15.39,53.71) ; v2(95.89,28.83) 95.86,28.8 95.86,27.88 95.54,27.56 UH2.A8 ; 79.95,9.58 v2(79.95,9.54) ; v2(222.51,110.66) v5(222.51,111.3)
  BOTTOM w0.152: v2(86.83,14.02) 87.16,14.35 UH2.AG25 87.31,14.35 v2(87.64,14.01) ; v2(86.83,14.02) 87.25,13.6 UH2.AJ25 87.64,13.97 v2(87.64,14.01) ; v2(86.83,14.02) 86.5,14.35 UH2.AG27 ; v2(86.83,14.02) 86.48,13.67 UH2.AJ27 ; v2(100.03,11.83) 99.68,12.19 99.22,12.19 UH2.AM1 ; v2(74.95,20.14) 75.32,19.77 UH2.T49 75.67,19.77 75.84,19.6 76.91,19.6 ; UH2.AJ20 89.52,13.58 v2(89.1,13.99) 88.8,14.3 UH2.AG22 ; UT1.N23 UT1.N22 ; v2(81.25,4.09) 81.18,4.16 UH2.BG37 ; UH2.BG25 87.25,4.63 87.51,4.89 87.51,6.03 UH2.BC24 ; UH1.BB3 147.37,61.51 147.37,60.91 UH1.BB2 147.37,60.86 147.37,60.26 UH1.BB1 147.4,60.19 147.4,59.7 v2(147,59.3) ; UH1.BB3 147.26,61.54 146.97,61.25 v2(146.97,61.21) ; UH1.BB3 147.37,61.56 147.37,62.16 UH1.BB4 147.37,62.21 147.37,62.81 UH1.BB5 147.37,62.86 147.37,63.46 UH1.BB6 ; UH2.AG23 87.98,14.35 v2(87.64,14.01) ; v2(99.44,16.2) 99.36,16.2 UH2.AD1 UH2.AD2 ; UH1.N3 UH1.N4 UH1.N5 ; UH1.N3 UH1.N2 UH1.N1 v2(169.98,59.46) ; UH1.N3 169.86,61.54 v2(169.54,61.21) ; UH1.BE5 UH1.BE4 UH1.BE3 ; UT1.AB1 UT1.AC1 32.18,44.87 32.38,44.87 v2(32.52,44.73) 32.41,44.63 32.22,44.63 UT1.AC2 UT1.AB2 ; UT1.H1 UT1.H2 ; 174.18,78.76 173.85,79.09 173.85,79.7 174.18,80.03 UH1.G28 ; UH1.T3 UH1.T2 UH1.T1 167.47,59.72 v2(167.02,59.27) ; UH1.T3 UH1.T4 UH1.T5 ; UH1.T3 167.33,61.54 v2(167.02,61.23) ; UH2.J46 76.8,23.07 UH2.J47 ; UH2.AG1 99.55,14.22 v2(99.67,14.1) ; v2(144.39,59.27) 144.83,59.72 UH1.BE1 UH1.BE2 UH1.BE3 ; UT1.K1 UT1.K2 ; v2(74.98,22.11) 75.09,22 UH2.M49 ; UH2.AG49 75.17,14.22 75.04,14.35 v2(75.03,14.66) ; v2(74.99,17.58) UH2.AA49 ; UT1.AB6 UT1.AC6 ; UH1.BE3 144.79,61.54 v2(144.38,61.12) ; UH2.A28 85.57,27.59 85.54,27.62 v2(85.54,27.71) ; UH2.C12 93.55,25.79 UH2.D12 93.46,25.47 UH2.E13 ; UT1.R23 UT1.R22 ; UH1.AF4 UH1.AF3 UH1.AF2 UH1.AF1 v2(159.92,59.69) ; v6(88.94,4.06) 88.93,4.07 88.93,4.07 UH2.BG22 ; UH1.BJ32 UH1.BJ31
  BOTTOM w0.165: UH2.AD49 75.7,15.63 76.78,15.63 77.1,15.32 UH2.AE46
  BOTTOM w0.178: UT1.C22 UT1.C23 22.89,34.43 22.64,34.17 21.9,34.17 ; 21.9,34.17 21.62,34.45 21.62,35.09 21.82,35.3 UT1.A22 ; 21.9,34.17 v2(21.63,33.91) 21.72,33.82 22.1,33.82 ; UT1.G23 UT1.G22 ; UT1.W22 UT1.W23 ; v2(26.63,34.23) 26.57,34.29 UT1.L23 UT1.L22 ; UT1.AB22 UT1.AC22 ; UT1.AB8 UT1.AC8 ; UT1.A10 UT1.B10 ; UT1.A18 UT1.B18 ; UT1.A8 UT1.B8 ; UT1.B12 UT1.A12 ; UT1.E22 UT1.E23 23.81,34.34 v2(23.72,34.25) ; UT1.M2 UT1.M1 ; UT1.U23 UT1.U22 ; UT1.B20 UT1.A20 21.06,36.22 v2(21.05,36.23) ; UT1.AB20 UT1.AC20 ; UT1.AA23 UT1.AA22 ; UT1.J23 UT1.J22 ; UT1.AC14 UT1.AB14 ; UT1.AB18 UT1.AC18 ; UT1.AB12 UT1.AC12 ; UT1.B6 UT1.A6 ; UT1.A16 UT1.B16 ; UT1.A14 UT1.B14 ; UT1.AB16 UT1.AC16 ; UT1.AB10 UT1.AC10
  BOTTOM w0.203: UH1.BA12 147.66,67.72 v2(147.53,67.72) 147.4,67.72 UH1.BB12 146.81,67.67 v2(146.62,67.67) ; UH1.BA12 148.33,67.74 v2(148.45,67.74) 148.56,67.74 UH1.AY12 149.27,67.76 v2(149.37,67.76) 149.45,67.76 UH1.AW12 150.15,67.73 v2(150.3,67.73) 150.4,67.73 UH1.AU12 ; UH1.BA12 148.28,67.11 v2(148.45,67.11) 148.08,66.75 UH1.BA11 ; UH1.BA12 UH1.BA11 ; v2(162.16,67.11) 161.87,67.4 UH1.AD12 ; v2(162.16,67.11) 162.45,67.4 162.62,67.4 UH1.AC12 ; v2(162.16,67.11) 162.07,67.11 UH1.AD11 UH1.AD10 ; UH1.W3 UH1.W4 UH1.W5 165.6,63.49 UH1.V6 UH1.U6 167.19,64.05 UH1.T7 UH1.T8 UH1.T9 UH1.T10 ; UH1.W3 164.81,61.54 v2(164.51,61.24) ; UH1.W3 UH1.W2 UH1.W1 164.95,59.75 v2(164.51,59.31) ; v2(174.51,74.4) 174.83,74.72 UH1.F21 174.83,74.86 v2(174.51,75.19) 174.51,75.25 UH1.G22 174.13,75.53 173.53,75.53 UH1.H22 UH1.J22 ; v2(139.73,67.11) 139.4,67.43 UH1.BN12 ; v2(139.73,67.11) 140.05,67.43 UH1.BM12 140.38,67.8 v2(140.38,67.87) 140.7,68.19 UH1.BL13 ; v2(139.73,67.11) 139.73,67.01 UH1.BM11 UH1.BM9 139.96,65.8 139.96,65.21 UH1.BM8 139.98,65.04 139.98,64.4 UH1.BM7 UH1.BN7 ; UH1.AU10 UH1.AU11 ; UH1.AU10 150.99,65.84 v2(151.19,65.84) ; UH1.AU10 UH1.AU9 ; UH1.AU11 150.92,66.75 v2(151.19,66.47) 151.19,65.84 v2(151.19,65.84) ; UH1.AU11 UH1.AU12 ; v2(153.93,65.2) 153.53,64.8 UH1.AP8 153.91,64.36 153.91,63.63 UH1.AN6 154,63.44 UH1.AN5 154.33,62.51 v2(154.5,62.51) ; v2(153.93,65.2) 153.72,65.2 UH1.AP9 ; v2(153.93,65.2) v2(153.93,65.84) ; v2(151.19,65.84) v2(151.19,65.2) 150.98,65.2 UH1.AU9 ; UH1.BH9 142.57,65.45 v2(142.96,65.84) 142.7,66.1 UH1.BH10 ; UH1.BH9 UH1.BH10 ; UH1.BH9 UH1.BH8 UH1.BH7 ; UH2.AL12 93.95,12.92 v2(93.95,13.13) ; v2(174.51,65.74) 174.83,65.41 UH1.F9 174.83,65.27 v2(175.16,64.95) ; v2(174.51,65.74) 174.51,65.8 UH1.G10 ; v2(174.51,65.74) 174.51,65.67 UH1.G9 ; UH1.BM27 140.05,79.35 v2(140.38,79.68) 140.05,80 UH1.BM28 139.93,80.2 139.93,80.74 UH1.BM29 ; v2(154.5,62.51) 154.83,62.19 UH1.AM4 154.93,62.15 154.93,61.57 UH1.AM3 UH1.AM2 UH1.AM1 v2(154.89,59.69) ; v2(154.5,62.51) 154.83,62.84 UH1.AM5 ; UH1.E34 175.53,84.29 175.53,84.86 UH1.E35 175.23,85.16 175.1,85.16 UH1.F36 ; v2(95.41,20.06) 95.57,20.06 UH2.T7 ; v2(178.67,69.37) 178.58,69.28 UH1.A14 ; UH1.BN18 139.44,72.23 140.02,72.23 UH1.BM18 140.05,72.13 v2(139.73,71.81) 139.4,72.13 UH1.BN18 ; UH1.BN18 139.36,72.24 138.8,72.24 UH1.BP18 UH1.BR18 UH1.BT18 136.73,72.2 v2(136.69,72.16) ; UH1.BN18 UH1.BN19 139.24,73.15 139.24,73.61 UH1.BN20 UH1.BN21 ; UH1.R29 168.39,80.66 168.76,80.29 v2(169.58,80.29) ; UH1.BC34 146.42,84.26 v2(146.74,84.58) ; UH1.N11 UH1.N10 UH1.N9 UH1.N8 UH1.N7 169.93,63.53 UH1.N6 ; UH1.N11 UH1.N12 170.08,67.4 170.39,67.08 ; UH1.N11 170.06,66.75 170.39,67.08 ; UH1.BT4 136.99,62.25 v2(136.93,62.19) ; UH1.AC37 162.14,86.27 162.14,86.81 UH1.AC38 v2(162.09,87.39) ; UH1.F31 174.78,82.72 174.15,82.72 UH1.H32 173.59,83.28 v2(173.51,83.28) ; UH1.BJ31 141.55,82.31 v2(141.23,81.98) 141.42,81.79 141.55,81.79 UH1.BJ30 141.75,81.2 141.63,81.07 UH1.BK29 141.14,80.86 UH1.BL29 140.68,80.89 140.08,80.89 UH1.BM29 ; UH1.G26 174.18,78.76 v2(174.52,79.1) 174.52,79.2 UH1.F27 ; UH1.D16 176.78,70.2 UH1.C15 176.78,70 177.07,69.71 v2(177.13,69.71) ; UH1.G24 174.51,76.83 v2(174.51,76.76) ; UH1.AW3 UH1.AW2 UH1.AW1 149.75,60.24 v2(149.42,60.56) ; UH1.AW3 149.75,61.54 v2(149.42,61.21) ; UH1.AW3 UH1.AW4 UH1.AW5 150.26,63.24 150.45,63.24 UH1.AU6 150.7,64.12 UH1.AU7 ; v2(143.92,67.7) 144.03,67.7 UH1.BF12 144.66,67.72 v2(144.79,67.72) 145.11,67.4 UH1.BD12 145.42,67.4 v2(145.7,67.11) 145.61,67.11 UH1.BD11 ; v2(143.92,67.7) 143.62,67.4 UH1.BG12 ; v2(143.92,67.7) 143.57,68.05 UH1.BG13 ; v2(239.17,114.83) 239.27,114.94 PU900.18 ; UH1.A16 v2(178.72,70.85) ; UH1.AU12 151.09,67.76 v2(151.18,67.76) ; UH1.BF33 144.05,83.61 v2(144.38,83.93) 144.05,84.26 UH1.BF34 ; UH1.C25 UH1.D24 176.78,76.5 UH1.C23 176.94,76.36 177.11,76.2 177.11,75.97 v2(177.11,75.97) ; UH1.BG13 UH1.BG14 143.28,68.7 142.96,68.38 ; UH1.BG13 UH1.BG12 ; UH1.BK18 UH1.BJ18 142.44,72.2 v2(142.6,72.04) ; UH1.H12 173.53,67.64 v2(173.86,67.31) ; UH1.AN12 154.03,67.76 v2(153.95,67.76) 153.83,67.76 UH1.AP12 ; UH1.AN12 154.65,67.66 155.04,67.66 UH1.AM12 155.56,67.4 v2(155.77,67.6) 156.01,67.6 UH1.AL12 ; UH1.AN12 154.22,67.4 153.93,67.11 ; v2(153.94,66.47) 153.75,66.47 UH1.AP11 153.84,67.11 153.93,67.11 ; v2(153.94,66.47) 153.94,67.11 153.93,67.11 ; v2(153.94,66.47) 153.93,66.47 v2(153.93,65.84) ; UH1.BC13 UH1.BC14 146.03,68.7 145.73,69 v2(145.73,69.05) ; UH1.BC13 145.97,68.05 145.72,67.79 v2(145.72,67.74) 146.06,67.4 UH1.BC12 UH1.BC13 ; UH1.AG6 158.96,63.61 UH1.AG7 UH1.AG8 ; UH1.AG6 159.34,63.74 v2(159.5,63.74) ; UH1.AG6 UH1.AH6 UH1.AJ6 UH1.AJ5 UH1.AJ4 UH1.AJ3 ; v2(161.23,65.19) 161.49,65.45 UH1.AD9 ; UH1.BM13 139.72,67.93 v2(139.72,67.86) 139.72,67.86 139.72,67.79 UH1.BN12 ; UH1.BN12 139.36,67.43 138.8,67.43 UH1.BP12 UH1.BR12 UH1.BT12 136.88,67.47 v2(136.67,67.68) ; UH1.BJ29 142.24,80.41 v2(142.43,80.41) ; v2(175.16,64.95) 175.48,65.27 UH1.E9 ; v2(175.16,64.95) 174.83,64.62 UH1.F8 UH1.G8 173.76,64.13 UH1.J7 173.23,64.13 v2(172.97,64.38) ; UH1.BA11 148.26,66.47 v2(148.45,66.47) ; UH1.BA11 UH1.BA10 UH1.BA9 UH1.BA8 UH1.BA7 147.99,64.13 UH1.BB6 ; UH1.A12 v2(178.66,67.7) ; UH1.BG38 v2(143.59,87.19) ; v2(169.57,86.54) UH1.P38 ; UH1.AC6 UH1.AB6 163.61,63.49 164.27,64.15 UH1.Y7 UH1.Y8 UH1.Y9 UH1.Y10 ; UH1.AC6 UH1.AC5 UH1.AC4 ; UH1.AC6 162.4,63.49 v2(162.07,63.81) ; UH1.A26 178.1,78.71 178.53,78.71 v2(178.59,78.66) ; UH1.AE34 160.44,84.26 v2(160.1,83.92) 160.4,83.61 UH1.AE33 ; UH1.BH6 UH1.BG6 UH1.BF6 UH1.BE6 ; UH1.BH6 142.28,63.49 v2(141.9,63.11) ; UH1.BH6 142.32,63.96 UH1.BH7 ; UH1.AD9 UH1.AD10 ; UH1.AD9 UH1.AD8 UH1.AD7 161.74,64.15 v2(162.07,63.81) ; UH1.AD10 162.08,66.47 v2(162.17,66.47) ; UH1.BE6 145.25,63.9 UH1.BD7 UH1.BD8 ; UH1.BE6 144.79,63.45 144.79,62.88 UH1.BE5 145.16,63.16 v2(145.23,63.16) ; UH1.BE6 144.9,63.49 v2(145.23,63.16) ; 169.55,83.93 169.94,83.61 UH1.N33 ; 169.55,83.93 v2(169.53,83.93) ; 169.55,83.93 169.94,84.26 UH1.N34 ; v2(140.36,74.17) 140.05,74.47 UH1.BM21 140.05,74.63 v2(139.73,74.95) 139.4,74.63 UH1.BN21 ; UH1.BA38 147.92,86.79 147.98,86.72 147.98,86.35 147.92,86.28 UH1.BA37 147.98,86.21 v2(148.31,85.89) ; UH1.J36 173.77,84.91 UH1.H35 174.55,85.56 UH1.F36 ; UH1.M14 UH1.M13 UH1.M12 170.71,67.4 170.39,67.08 ; UH1.K1 UH1.K2 UH1.K3 ; UH1.BH12 142.67,67.4 v2(142.96,67.11) 143.25,67.4 UH1.BG12 ; UH1.BH12 UH1.BH11 ; UH1.BH12 142.37,67.4 v2(142.05,67.07) 141.68,67.44 UH1.BJ12 ; UH1.F4 UH1.G4 174.06,62.19 173.74,62.51 ; UH1.F4 UH1.E4 ; UH1.F4 174.82,61.88 174.92,61.77 UH1.F3 174.84,61.54 174.54,61.23 v2(174.54,61.2) 174.54,61.2 174.85,60.89 UH1.F2 ; v2(315.51,32.6) DI17.2 ; UH1.D20 176.78,73.35 UH1.C19 176.78,73.15 176.48,72.84 v2(176.48,72.84) ; v2(288.27,32.49) PU600.3 ; v2(81.17,28.23) 81.17,27.23 UH2.A37 ; UV18.G2 217.09,59.39 217.3,59.18 217.3,56.38 218.26,55.41 218.26,54.41 218.76,53.91 218.76,53.34 218.2,52.78 216.94,52.78 216.54,53.18 v2(216.54,53.66) 216.54,53.85 216.9,54.21 216.9,54.97 216.2,55.66 216.2,56.91 v2(216.09,57.02) ; UH1.AR13 152.88,67.73 v2(153.02,67.73) 153.14,67.73 UH1.AP12 ; UH1.AR13 152.89,68.37 v2(153.02,68.37) 152.69,68.7 UH1.AR14 152.43,68.7 v2(152.1,68.37) ; UH1.AR13 152.45,68.05 v2(152.12,67.72) ; v2(172.97,64.38) 172.74,64.15 UH1.K7 ; v2(172.97,64.38) 172.6,64.75 UH1.K8 172.66,64.85 172.66,65.39 UH1.K9 172.5,65.45 v2(172.2,65.75) 172.55,66.1 UH1.K10 172.66,66.1 v2(173.03,66.47) ; v2(151.45,83.94) 151.12,83.61 UH1.AU33 ; v2(155.4,83.93) 155.73,84.26 UH1.AL34 ; UH1.A10 178.61,66.13 v2(178.7,66.05) ; UH1.AL4 UH1.AK4 156.96,61.74 v2(156.96,61.21) 157.08,61.21 UH1.AJ3 ; UH1.Y10 164.82,66.47 v2(164.91,66.47) 164.64,66.75 UH1.Y11 UH1.Y10 ; UH1.BH7 142.96,64.6 v2(142.96,65.2) ; v2(9.93,71.76) 9.74,71.57 DT20.2 ; UH1.A3 UH1.A4 ; UH1.A3 177.51,61.49 UH1.B3 176.88,61.62 v2(176.82,61.57) ; UH1.A3 178.08,60.97 v2(178,60.89) ; v2(172.31,72.43) UH1.J18 UH1.H18 173.5,72.4 174.16,72.4 UH1.G18 ; v2(160.33,69.01) 160.19,69.01 UH1.AF14 UH1.AF13 UH1.AF12 ; UH1.BT5 136.51,63.05 v2(136.46,63.01) ; v2(78.11,15.82) 77.88,15.82 ; 77.88,15.82 77.77,15.82 77.19,16.4 UH2.AC46 ; 77.88,15.82 77.38,15.32 UH2.AE46 ; v2(198.3,60.61) 198.35,60.56 198.35,59.89 198.27,59.81 197.5,59.81 UV18.AL2 ; UH1.BN29 UH1.BM29 ; UH1.AG10 159.41,66.55 v2(159.41,66.97) ; UH2.AP4 97.31,10.65 v6(97.46,10.5) ; UH1.BA6 UH1.BB6 ; UH1.BB6 147.02,63.16 v2(146.97,63.16) 146.84,63.16 UH1.BC6 UH1.BD6 145.56,63.49 v2(145.23,63.16) ; UH1.L33 171.61,83.61 v2(171.93,83.93) 171.61,84.26 UH1.L34 ; v2(155.4,86.54) 155.07,86.86 UH1.AM38 ; UH1.D6 176.78,64.42 UH1.C8 176.78,64.62 v2(177.11,64.95) ; UH1.T10 UH1.T11 ; UH1.T10 167.57,66.47 v2(167.65,66.47) 167.38,66.75 UH1.T11 ; UH1.T10 167.45,65.84 v2(167.66,65.84) ; UH1.T11 UH1.T12 167.36,67.4 v2(167.65,67.11) 167.93,67.4 UH1.R12 ; v2(177.11,64.95) 177.43,65.27 UH1.B9 UH1.A9 ; v2(177.11,64.95) 176.78,65.27 UH1.C9 176.73,65.39 176.18,65.39 ; UH1.A22 v2(178.72,75.58) ; UH1.BM5 140.19,62.52 v2(140.19,62.31) 139.95,62.08 UH1.BM3 139.95,61.27 UH1.BM2 139.72,60.89 UH1.BN2 ; UH1.BM5 139.85,62.86 UH1.BM6 139.93,63.49 UH1.BL6 UH1.BK6 141.53,63.49 v2(141.9,63.11) ; UH1.BM5 139.87,62.76 UH1.BN4 ; v2(98.8,27.87) 98.53,27.61 98.53,27.39 UH2.A2 ; UH1.A24 v2(178.72,77.15) ; UH1.BR7 137.54,64.88 UH1.BT8 ; UH1.BR7 137.97,64.32 137.88,64.41 136.69,64.41 136.23,63.95 135.89,63.95 135.41,63.46 v2(135.08,63.46) ; UH1.BR7 UH1.BP7 UH1.BN7 ; UH1.BD11 UH1.BD10 ; UH1.BD11 145.43,66.75 v2(145.71,66.47) 145.62,66.47 UH1.BD10 ; UH1.BD10 UH1.BD9 ; UH1.BD10 145.51,65.84 v2(145.7,65.84) 145.31,65.45 UH1.BD9 ; UH1.AC4 UH1.AC3 UH1.AC2 UH1.AC1 v2(162.44,59.69) ; UH1.AC4 162.32,62.19 v2(161.99,61.86) ; UH1.BT24 UH1.BR24 138.13,76.95 138.73,76.95 UH1.BP24 138.81,76.98 139.35,76.98 UH1.BN24 139.4,76.85 v2(139.73,76.53) 140.05,76.2 UH1.BM23 ; v2(139.08,83.62) 138.75,83.94 UH1.BP34 UH1.BR34 138.1,83.81 UH1.BT32 136.97,83.16 v2(136.87,83.26) ; v2(139.08,83.62) 139.08,83.68 UH1.BN34 ; v2(139.08,83.62) 138.75,83.29 UH1.BP33 138.75,83.09 UH1.BN31 139.72,82.12 v2(139.72,82.07) 139.72,81.96 UH1.BN30 ; UH1.E38 175.08,86.76 v2(175.08,85.89) 174.76,85.56 UH1.F36 ; UH1.BH10 UH1.BH11 ; UH1.BH10 142.88,66.47 v2(142.96,66.47) 142.69,66.75 UH1.BH11 ; UH2.AT45 77.19,10.11 UH2.AP46 ; UH1.J33 173.18,83.61 v2(173.51,83.28) ; v2(172.05,63.19) 172.14,63.19 UH1.K5 UH1.K4 ; UH2.A4 UH2.A3 98.21,27.63 v2(98.07,27.77) ; UV18.AH5 199.14,62.25 199.14,63.1 UV18.AH7 ; UH1.T14 167.09,68.7 v2(166.75,68.35) 167.05,68.05 UH1.T13 ; UH1.D9 176.18,65.39 ; 176.18,65.39 176.25,65.46 176.25,66.01 UH1.D10 ; UH1.BK25 UH1.BJ25 v2(142.58,77.71) ; UH1.BN21 139.34,74.5 138.82,74.5 UH1.BP21 138.72,74.53 138.14,74.53 UH1.BR21 UH1.BT21 v2(136.59,74.56) ; v2(153.93,65.84) 153.73,65.84 UH1.AP10 ; v2(174.51,72.82) 174.83,73.14 UH1.F19 174.83,73.29 v2(174.51,73.61) 174.51,73.68 UH1.G20 ; v2(218.41,65.65) 218.41,65.65 218.41,64.93 218.55,64.8 219.76,64.8 219.76,64.8 219.8,64.8 220.04,65.04 220.04,65.75 220.33,66.05 UV18.C10 UV18.B10 ; UH1.F13 174.29,67.95 174.29,67.95 174.18,67.84 UH1.G12 174.18,67.64 v2(173.86,67.31) ; UH1.AH33 158.28,83.61 v2(158.57,83.91) 158.22,84.26 UH1.AH34 UH1.AH35 UH1.AH36 ; v2(136.72,78.36) 136.86,78.5 UH1.BT26 UH1.BR26 UH1.BP26 ; UH1.AU34 151.14,84.26 v2(151.46,84.58) ; UH2.C5 97.37,26.11 UH2.C4 v2(97.29,26.74) 97.21,26.82 UH2.A5 ; UH1.N6 UH1.P6 ; UH1.N6 UH1.N5 ; UH1.N6 UH1.M6 ; UH1.AL9 156.28,65.45 v2(156.68,65.84) ; UH1.BJ32 141.55,82.96 v2(141.23,83.28) 141.55,83.61 UH1.BJ33 ; UH1.K3 UH1.K4 ; UH1.K3 172.44,61.54 v2(172.05,61.15) ; UH1.BC33 146.41,83.61 v2(146.74,83.28) ; UH1.BM38 140.19,86.87 v2(140.56,87.24) 140.91,86.9 UH1.BL38 ; UH1.G23 174.51,76.69 v2(174.51,76.76) ; UH1.AP12 153.65,67.4 153.93,67.11 ; v2(152.39,58.77) 152.38,58.79 UH1.AR1 UH1.AR2 UH1.AR3 UH1.AR4 UH1.AR5 ; UH2.AT1 99.44,9.8 v2(99.55,9.7) ; UH1.Y38 v2(164.45,87.39) ; UH1.F11 174.83,66.85 v2(175.16,66.52) ; v2(175.16,80.7) 175.16,80.79 174.86,81.09 UH1.F29 ; v2(178.77,74.11) 178.66,74 UH1.A20 ; UH1.BD9 UH1.BD8 ; UH1.BD9 145.49,65.2 145.65,65.2 ; 9.4,70.09 9.4,69.75 v2(9.58,69.57) ; 9.4,70.09 DT21.2 9.88,70.11 v2(10.19,69.8) ; 9.4,70.09 v2(8.96,69.65) ; UH1.D30 176.44,82.19 v2(176.44,82.27) 176.44,82.33 UH1.C31 176.78,82.8 UH1.D33 ; UH1.T33 167.48,83.61 v2(167.16,83.93) 167.5,84.26 UH1.T34 ; v2(94.92,25.34) 94.54,25.34 UH2.E10 94.04,25.08 v2(93.71,25.08) ; v2(142.28,59.47) 142.07,59.68 UH1.BH1 142.07,60.63 UH1.BH2 UH1.BH3 UH1.BH4 UH1.BH5 142.18,62.84 v2(141.9,63.11) ; v2(173.86,67.31) 173.86,67.24 UH1.H11 ; UH1.BD8 145.65,65.2 ; UH1.C29 177.1,80.77 v2(177.1,80.72) ; UH1.D3 176.36,61.57 v2(176.82,61.57) ; v2(162.07,63.81) 161.74,63.49 UH1.AD6 161.26,63.15 v2(161.18,63.15) 161.09,63.15 UH1.AE6 ; UH1.BG37 143.26,86.21 v2(143.59,85.89) ; PU600.1 287.47,31.79 287.34,31.92 286.5,31.92 286.26,32.16 286.26,32.97 v2(286.36,33.07) ; v2(156.68,65.84) v2(156.68,65.2) 156.27,64.8 UH1.AL8 UH1.AL7 ; v2(156.68,65.84) 156.68,65.84 v2(156.68,66.47) 156.31,66.1 UH1.AL10 ; v2(136.86,85.55) UH1.BT36 137.99,85.55 UH1.BR36 ; UH1.BR38 137.9,87.01 v2(137.9,87.52) ; UH1.F5 174.67,62.84 UH1.G5 ; UH1.BN7 139.4,63.86 v2(139.47,63.79) ; UH1.AH12 158.19,67.4 v2(158.5,67.71) ; UH1.BM26 140.38,78.17 v2(140.38,78.1) 140.38,78.04 UH1.BM25 ; v2(77.64,7.23) 77.62,7.21 UH2.BC45 ; UH1.H25 UH1.J25 172.71,77.94 172.49,78.16 v2(172.33,78.16) ; v2(211.98,86.47) 211.98,86.45 212.09,86.34 UV18.N33 ; UH1.BM35 140.05,84.81 v2(140.4,85.15) 140.59,85.15 UH1.BL35 ; UH1.AJ3 UH1.AJ2 UH1.AJ1 v2(157.41,59.69) ; v2(171.88,87.29) 172.3,86.86 UH1.K38 ; UH1.BT3 137.35,61.43 136.94,61.43 v2(136.85,61.34) ; UH1.J32 173.2,82.96 v2(173.51,83.28) ; UH1.BK13 141.35,67.84 v2(141.18,67.67) ; v2(164.83,83.91) 165.13,83.61 UH1.W33 ; UH2.A33 83.38,28.26 v2(83.18,28.46) ; UH1.K11 172.88,66.47 v2(173.03,66.47) ; UH1.C2 176.82,61.04 v2(176.82,61.57) ; UH1.J10 173.37,66.13 v2(173.03,66.47) ; v2(174.51,71.21) 174.83,71.53 UH1.F17 ; UV18.B4 221.24,60.78 221.44,60.58 222.97,60.58 223.2,60.81 v2(223.2,62.1) ; UH1.K4 UH1.J4 173.66,62.51 173.74,62.51 ; v2(174.51,76.76) 174.83,76.44 UH1.F23 ; 173.74,62.51 174.07,62.84 UH1.G5 ; UH1.AU9 UH1.AU8 UH1.AU7 ; D18.2 342.89,60.02 v2(342.89,60.57) ; UH1.F25 175.16,77.61 v2(175.16,77.55) ; UH1.G5 174.18,62.88 174.18,63.44 UH1.G6 ; UH1.AL14 155.9,69.01 v2(155.77,69.01) ; v2(177.15,74.42) 177.11,74.46 177.11,74.59 176.91,74.79 UH1.C21 176.78,74.93 UH1.D22 ; UH1.BK22 UH1.BJ22 142.51,75.35 v2(142.56,75.4) ; v2(93.69,6.82) 93.65,6.82 92.99,7.48 ; UH1.Y13 164.55,68.05 v2(164.88,68.37) 164.55,68.7 UH1.Y14 ; UH1.A28 v2(178.59,80.3) ; UH1.AU7 151.39,63.49 UH1.AT6 ; v2(80.84,6.89) 80.81,6.86 80.68,6.73 80.47,6.73 UH2.BC40 ; UH1.D12 176.24,67.7 176.78,67.16 UH1.C11 177.16,66.53 v2(177.16,66.53) ; UH1.AB33 v2(163.27,83.93) ; v2(199.2,83.21) 199.16,83.25 199.16,83.97 UV18.AH32 ; UH1.C37 176.74,86.21 177.31,86.21 UH1.B37 177.52,86.29 UH1.A37 178.81,87.02 v2(178.81,87.25) ; DT20.2 9.4,72.16 v2(9.39,72.17) ; DT20.2 9.22,71.57 v2(8.79,72) ; UH1.A30 178.41,82.08 178.63,82.3 v2(178.94,82.3) ; UH1.AV38 150.35,86.86 v2(150.67,86.54) 150.35,86.21 UH1.AV37 ; UH1.A18 178.1,72.44 v2(178.75,72.44) ; v2(177.17,71.25) UH1.C17 176.78,71.78 UH1.D18 ; UH2.E13 93.04,25.46 UH2.E15 92.19,25.5 UH2.D16 ; v2(145.7,65.2) 145.65,65.2 ; UH1.BD38 145.62,86.86 v2(145.95,86.54) 145.63,86.21 UH1.BD37 ; v2(157.37,87.56) UH1.AJ38 UH1.AJ37 ; 92.58,12.15 92.58,11.4 92.78,11.2 93.08,11.2 93.43,11.55 UH2.AN12 93.78,11.63 94.58,11.63 94.79,11.42 94.79,10.91 94.35,10.47 93.7,10.47 UH2.AR12 ; UH2.J46 77.47,23.07 v2(78,23.6) ; v2(171.19,82) 171.54,81.64 UH1.L30 UH1.L29 ; UH1.D14 176.78,68.63 UH1.C13 177.13,68.14 177.13,68.13 v2(177.14,68.13) ; UH1.BN14 UH1.BP14 138.75,69.12 v2(138.43,69.44) 138.1,69.12 UH1.BR14 UH1.BT14 ; UV18.AE2 202.48,59.79 v2(204.2,59.79) ; DI13.2 318.18,32.64 v2(318.26,32.64) ; UH1.G14 174.83,69.93 UH1.F15 174.83,70.14 v2(174.51,70.46) 174.51,70.53 UH1.G16 ; UH1.AY34 148.77,84.26 v2(149.1,83.93) 148.78,83.61 UH1.AY33 ; UH1.A6 177.93,63.78 177.49,63.34 177.14,63.34 UH1.C5 176.29,62.49 v2(175.95,62.49) ; UH1.BR29 UH1.BP29 ; UH1.D28 176.78,79.65 UH1.C27 176.77,79.51 176.47,79.22 v2(176.47,79.1) 176.13,78.76 UH1.D26 ; UV18.AL5 196.67,61.53 v2(196.67,61.51)
  BOTTOM w0.229: v2(203.33,63.85) 203.28,63.9 202.54,63.9 202.13,63.5 UV18.AE7 ; UT4.A1 20.61,55.25 20.36,55 v2(20.31,55)
  BOTTOM w0.254: v2(59.83,35.3) 59.83,35.41 59.73,35.51 59.73,36.52 JEDP1.17 ; v2(139.71,83.58) 139.67,83.62 v2(139.08,83.62) ; v2(139.71,83.58) 139.75,83.61 140.44,83.61 ; v2(139.71,83.58) 139.71,83.57 140.05,83.23 UH1.BM33 ; UH1.AG13 158.84,68.05 v2(158.5,67.71) ; v2(247.79,55.62) 247.72,55.69 UV25.R14 ; 14.69,77.21 14.81,77.33 CV182.1 ; 14.69,77.21 CV181.1 ; 14.69,77.21 v2(14.64,77.16) ; UV24.N1 v2(214.75,101.68) ; UV23.T10 v2(234.41,109.68) ; UV23.A3 229.21,97.7 229.09,97.57 v2(229.09,97.49) ; UV18.AG11 v2(200.71,66.53) ; UV18.U21 208.83,75.8 v2(208.34,75.31) 207.86,75.8 UV18.V21 ; UV24.C1 v2(215.56,108.88) ; UV25.L10 v2(244.12,59.8) ; D324.2 312.59,34.29 C1080.2 v2(313.27,35.14) ; UV23.R14 238.33,108.96 v2(238.33,108.87) ; UH1.BT35 136.86,84.73 v2(136.84,84.75) ; UH1.BT24 137.42,76.89 135.35,76.89 134.77,76.32 v2(134.77,76.14) ; 240.93,83.94 UV26.M5 ; 240.93,83.94 v2(240.93,83.95) ; 240.93,83.94 241.32,83.55 UV26.L5 ; v2(196.67,61.51) 196.63,61.47 195.86,61.47 UV18.AN4 ; UV25.R1 v2(247.32,67.01) ; UV23.E14 v2(237.61,101.68) ; RT41.1 34.01,45.11 34.24,45.34 34.24,45.44 v2(34.56,45.76) ; UV26.K13 v2(241.72,90.34) UV26.K14 ; UH1.BT29 UH1.BR29 ; UI2.14 332.04,64.51 v2(332.36,64.83) ; UH1.BJ15 UH1.BK15 140.98,69.46 140.98,69.46 ; UH1.BJ15 142.01,69.92 v2(142.46,70.37) ; UH1.BJ15 142.42,69.42 v2(142.52,69.42) 142.52,68.72 UH1.BH14 ; UV23.L5 231.17,105.72 v2(231.17,105.67) ; UV18.N30 212.15,82.73 212.15,82.04 v2(212.06,81.95) ; PQ220.1 60.05,17.25 60.58,17.78 v2(61.04,17.78) ; UH2.BC31 84.47,6.56 84.2,6.83 84.2,6.92 v2(84.19,6.94) ; 238.51,58.21 UV25.C11 ; 238.51,58.21 238.51,58.2 UV25.C12 ; 238.51,58.21 v2(238.51,58.24) ; UV18.V14 207.84,68.96 v2(208.32,69.45) 208.84,68.94 UV18.U14 ; UV24.H1 214.83,105.6 v2(214.76,105.6) 214.68,105.6 UV24.H2 ; v2(28.64,99.89) 28.32,99.57 UI1.14 ; v2(63.42,5.65) 63.62,5.65 63.76,5.51 RH529.2 ; UH1.BK13 UH1.BK14 ; UH1.BK14 141.97,69.05 UH1.BJ14 142.39,68.7 UH1.BH14 ; UH1.BK14 141.35,69.05 140.98,69.43 140.98,69.46 ; UH2.P46 77.19,21.33 v2(77.14,21.38) ; v2(228.64,111.33) 228.76,111.33 UV23.U3 ; v2(148.45,69.02) 148.77,68.7 UH1.AY14 ; UV26.C12 v2(248.12,88.74) UV26.C11 ; v2(20.45,61.02) 20.45,60.96 20.61,60.79 UT4.L1 ; UH2.AH38 80.85,13.34 v2(80.71,13.2) 80.83,13.07 UH2.AL38 ; UV23.U1 v2(227.07,110.88) ; UV18.V16 207.84,70.8 v2(208.34,71.31) 208.84,70.82 UV18.U16 ; v2(206.75,98.48) UV24.U12 ; UV24.A3 v2(213.15,110.48) ; UH1.BJ33 141.62,83.7 141.57,83.75 141.57,84.12 141.62,84.17 UH1.BJ34 141.69,84.26 v2(142.01,84.58) 141.95,84.58 UH1.BJ35 141.93,85.22 141.98,85.22 ; RH5892.2 68.92,12.28 68.52,11.88 67.31,11.88 66.9,12.28 RH528.2 ; UH1.T9 167.15,65.45 166.83,65.77 v2(166.7,65.77) 167.02,66.1 UH1.T10 ; D125.2 19.85,96.49 v2(20.09,96.25) ; D123.2 326.68,70.29 v2(326.37,69.98) ; UH1.AB34 163.15,84.53 v2(163.28,84.53) ; v2(248.88,83.9) UV26.B5 ; UV26.U1 v2(236.92,80.73) ; UH1.BH14 142.86,68.38 142.96,68.38 ; UV26.P10 v2(239.32,87.94) ; RH5841.1 70.74,6.58 70.36,6.19 70.04,6.19 v2(69.75,5.9) ; v2(248.94,56.6) 249.32,56.21 UV25.U14 ; UV23.F10 v2(235.21,102.48) UV23.G10 ; UV24.A12 v2(205.95,110.48) ; v2(244.12,91.07) 244.04,91.07 243.72,90.75 UV26.H14 UV26.H13 ; UH1.BL22 140.7,75.26 v2(140.37,74.93) 140.7,74.6 UH1.BL21 141.01,74.26 v2(141.01,74.17) 141.01,74.08 UH1.BL20 140.88,73.59 140.88,73.2 140.7,73.02 UH1.BL19 UH1.BL18 UH1.BK18 ; UH1.BL22 UH1.BK22 ; UH1.BL22 140.65,75.4 140.11,75.4 UH1.BM22 ; UV24.J10 v2(207.55,104.08) ; UV26.A14 248.62,91.43 v2(248.62,91.43) ; JEDP1.11 62.73,35.31 v2(62.79,35.26) ; UV23.B5 v2(230.43,98.49) ; UV26.M10 v2(240.92,87.13) UV26.L10 ; UV23.C11 v2(236.01,100.08) UV23.C12 ; UV25.K14 243.67,56.2 v2(243.25,56.62) 243.64,57 UV25.K13 ; UV23.D10 v2(235.21,100.08) ; v2(16.75,69.82) 16.5,69.56 CM37.2 CM8.2 ; v2(10.77,61.75) 10.48,62.04 DT26.2 ; UV26.U14 v2(236.92,90.34) ; UV24.C3 v2(213.15,108.88) UV24.C4 ; UV26.R1 v2(238.52,80.73) ; UV23.A12 236.41,98.08 236.09,97.75 v2(236.03,97.75) ; v2(246.13,67.18) 246.13,67.06 246.12,67.05 UV25.N1 ; UV26.E12 245.71,89.54 v2(245.71,89.56) ; UV24.H13 v2(205.17,105.66) 204.78,105.28 UV24.H14 ; UH1.U37 166.86,86.26 166.86,86.33 166.87,86.33 166.87,86.7 166.86,86.71 166.86,86.82 UH1.U38 v2(166.82,87.38) ; v2(65.75,35.32) 65.75,35.47 65.73,35.49 JEDP1.5 ; v2(243.3,67.02) UV25.K1 UV25.K2 ; UV23.M5 v2(231.4,106.88) ; 140.05,78.86 140.05,78.87 v2(139.07,78.87) 139.07,78.81 UH1.BP26 ; 140.05,78.86 UH1.BM27 ; 140.05,78.86 UH1.BM26 ; UV23.N12 236.71,107.97 236.71,108.02 v2(236.76,108.07) ; UV23.L10 234.47,105.73 v2(234.47,105.67) ; UV23.N14 238.31,107.98 238.31,107.98 238.33,108 238.33,108.04 v2(238.36,108.07) ; CZ100.2 15.48,62.55 UZ25.5 15.48,63.86 16.02,64.4 v2(16.08,64.4) ; UV25.R4 v2(248.12,64.61) UV25.R3 ; UV18.AA18 204.84,72.76 204.41,72.33 ; DT26.2 11.04,62.36 v2(11.12,62.28) ; DT26.2 10.48,62.89 v2(10.43,62.93) ; v2(215.02,59.03) 214.99,59.03 214.62,59.4 UV18.K2 ; UV23.C1 v2(228.02,99.27) ; UV18.AA13 204.43,67.4 v2(204.43,67.27) 204.31,67.27 UV18.AB12 ; v2(248.13,87.96) 248.52,87.57 UV26.B10 ; UV18.M18 213.53,72.5 213.53,72.34 v2(213.56,72.32) ; v2(222.42,83.08) 222.38,83.08 222.36,83.1 222.32,83.1 221.85,83.57 221.26,83.57 UV18.B31 ; UV18.AE28 202.29,81.31 202.57,81.31 202.77,81.51 203.91,81.51 204.16,81.25 v2(204.16,80.7) ; UV24.E14 204.47,107.68 v2(204.27,107.47) ; UV26.N3 v2(239.32,81.53) ; UV24.U1 v2(214.75,98.48) ; UV26.A3 v2(248.92,82.33) ; UV25.N14 245.95,56.04 v2(245.95,55.68) ; 138.08,78.09 138.08,78.48 UH1.BR26 ; 138.08,78.09 138.37,78.09 UH1.BP25 ; 138.08,78.09 138.1,78.07 UH1.BR25 UH1.BR24 ; 138.08,78.09 137.31,78.09 137.13,77.91 135.65,77.91 135.41,78.15 ; v2(234.36,11.99) JHDD.7 234.36,10.08 234.19,9.91 233.05,9.91 232.86,10.09 JHDD.4 ; RH59.2 133.08,77.91 135.17,77.91 135.41,78.15 ; v2(78,23.6) 78.12,23.72 UH2.G44 ; UV24.F5 211.54,106.88 v2(211.4,106.74) ; UV18.T7 209.42,63.5 209.18,63.25 v2(209.18,63.08) ; v2(141.23,83.28) 140.9,83.61 UH1.BL33 140.44,83.61 ; v2(18.42,30.84) 18.42,32.2 18.25,32.37 PU201.3 ; UV24.K2 UV24.K1 215.82,103.68 215.98,103.84 215.99,103.84 216.17,104.01 v2(216.35,104.01) ; UV26.K1 v2(242.52,80.73) UV26.K2 ; UV18.AC18 202.92,72.8 v2(203.36,72.36) ; UV25.B5 237.01,63.1 v2(237.01,62.96) ; JDIMM1.238 168.63,18.83 169.04,18.42 v2(169.29,18.42) 169.29,18.32 169.7,17.91 170.74,17.91 171.12,18.3 JDIMM1.248 ; v2(236.88,88.75) 236.88,88.77 UV26.U12 ; UV23.R1 227.6,109.26 v2(227.01,109.26) ; v2(157.54,67.15) 157.54,67.64 UH1.AJ13 ; 140.98,69.46 v2(140.98,69.46) ; UV26.R12 v2(238.52,88.74) UV26.R11 ; UV23.G5 v2(230.41,102.48) UV23.F5 ; v2(247.27,79.95) 247.66,80.33 UV26.C1 ; UV23.T5 v2(231.21,109.68) ; UV18.U19 208.8,73.8 208.41,73.41 v2(208.34,73.41) 208.28,73.41 207.89,73.8 UV18.V19 ; UV23.H14 v2(237.61,103.28) UV23.H13 ; UV26.T5 237.71,83.14 v2(237.77,83.14) ; v2(22.13,30.55) 22.1,30.57 CT44.2 ; v2(240.86,62.99) 240.9,62.99 UV25.G5 ; CE3321.2 148.35,10.72 148.19,10.55 147.61,10.55 147.34,10.28 v2(147.29,10.28) ; UV25.T10 v2(248.12,59.8) ; v2(196.64,79.78) 197.02,79.4 UV18.AL26 ; UV24.L5 v2(212.35,102.48) UV24.M5 ; UV25.F5 v2(240.92,63.81) ; UH1.D38 175.99,86.87 178.75,89.64 v2(178.75,89.78) ; 259.74,9.04 259.25,8.56 v2(259.25,7.24) ; v2(88.38,7.06) 88.38,6.94 87.83,6.39 UH2.BC24 ; CT151.2 18.28,61.02 18.9,60.4 v2(18.9,60.37) ; v2(227.09,107.69) 227.1,107.68 UV23.N1 ; UV23.A14 238.01,97.53 v2(238.13,97.42) ; UV18.AB32 v2(205,84.81) ; UV24.P10 v2(207.55,100.88) ; UV25.B10 v2(236.92,59) ; UH1.BL14 UH1.BL13 ; UV24.B5 v2(212.35,109.68) ; UH2.AC4 97.31,16.14 v2(96.98,15.81) 97.31,15.49 UH2.AE4 ; UH1.BM35 140.44,84.41 140.44,83.61 ; UV24.C14 204.04,109.28 v2(203.78,109.02) ; v2(8.8,61.82) 9.02,62.04 DT27.2 ; UV23.U12 v2(236.01,110.48) ; DT27.2 9.02,62.66 v2(8.73,62.95) ; DT27.2 v2(8.29,62.36) ; UV25.C3 v2(237.72,64.61) UV25.C4 ; UH1.BP18 138.75,72.14 v2(139.1,71.79) ; 78.08,6.5 78.08,6.25 78.3,6.03 UH2.BD43 78.34,5.77 78.16,5.59 UH2.BE44 ; 78.08,6.5 77.94,6.65 UH2.BC45 ; 78.08,6.5 78.08,6.61 78.34,6.87 78.63,6.87 UH2.BB43 78.66,7.24 v2(78.93,7.5) 79.23,7.21 UH2.BB41 ; UH1.A34 178.47,84.31 v2(178.81,84.31) ; UV18.T17 209.87,71.8 v2(210.29,72.22) 210.28,72.23 210.28,72.28 209.84,72.72 UV18.T18 ; v2(236.12,57.4) 236.12,57.41 UV25.A12 ; UV18.W28 207.08,81.1 207.08,81.1 206.73,80.74 v2(206.67,80.74) ; v2(53.13,35.31) 53.23,35.41 JEDP1.30 ; v2(77.64,7.23) 78.11,7.7 UH2.BA44 ; UV26.C3 247.76,81.93 248.12,82.29 v2(248.12,82.34) 248.12,82.4 247.79,82.73 UV26.C4 ; UV23.H2 v2(228.01,103.28) UV23.H1 ; UV26.F10 v2(245.32,87.01) ; UV18.R16 211.33,70.31 211.33,70.3 v2(211.39,70.23) 211.83,69.8 UV18.P15 ; UH2.BC35 82.3,6.36 82.3,6.88 v2(82.31,6.9) ; UV24.E3 v2(213.15,107.28) ; UV24.R11 v2(206.75,100.08) UV24.R12 ; UV25.A1 v2(236.92,67.01) ; v2(220.85,68.14) 220.44,68.55 UV18.C13 220.44,68.57 v2(220.04,68.97) ; RH200.2 133.72,83.96 134.09,83.59 134.92,83.59 135.21,83.3 136.83,83.3 v2(136.87,83.26) ; UV24.L10 v2(208.35,102.48) UV24.M10 ; UV24.K14 v2(205.15,103.28) UV24.K13 ; UV25.E14 v2(240.12,56.6) ; UV25.R12 v2(248.12,58.2) UV25.R11 ; 135.41,78.15 v2(135.41,78.5) ; UV23.N3 v2(229.61,107.28) ; v2(199.06,75.67) 199.14,75.67 199.51,76.05 UV18.AH22 ; UV25.H1 v2(241.72,66.21) UV25.H2 ; UV26.E3 v2(245.72,82.33) ; UV24.U14 v2(205.15,98.48) ; UH1.BP29 UH1.BN29 ; UV25.T5 v2(248.12,63) ; UH2.AT45 77.39,9.5 77.6,9.29 v2(77.6,9.22) 77.6,9.14 UH2.AW46 ; UV23.E12 v2(236.81,100.88) ; D126.2 v2(19.85,99.99) ; UV25.E12 239.35,57.44 v2(239.35,57.4) ; UV18.U23 UV18.V23 207.84,77.81 207.57,78.08 v2(207.57,78.3) ; UV25.P10 v2(247.32,59) ; JDIMM2.61 198.67,28.65 197.64,29.69 v2(197.47,29.69) ; v2(175.1,8.77) 175.12,8.75 JAPS.8 ; UV25.L5 v2(244.92,63) UV25.M5 ; UV24.E12 206.35,107.69 v2(205.94,108.1) ; v2(234.29,106.88) 234.36,106.88 234.36,106.88 UV23.M10 ; UV26.E14 246.12,91.26 v2(246.08,91.3) ; UV26.N12 v2(240.12,88.74) ; UV23.U14 v2(237.77,111.33) ; v2(210,84.84) 209.59,84.43 UV18.T32 209.58,84.4 v2(209.19,84.01) ; UV25.C14 v2(237.72,56.6) ; 204.41,72.33 204.84,71.9 UV18.AA17 ; 204.41,72.33 v2(204.37,72.33) ; v2(211.03,106.09) 211.04,106.08 UV24.G5 ; v2(235.24,98.41) 235.24,98.45 UV23.B10 ; UV24.N3 v2(213.95,100.88) ; UV18.AN10 195.46,66.05 v2(195.84,66.42) ; v2(64.23,35.26) 64.23,35.26 JEDP1.8 ; UH1.R12 168.26,67.56 168.86,67.56 UH1.P12 169.19,67.57 169.76,67.57 UH1.N12 ; UV24.C11 v2(206.75,108.88) UV24.C12 ; v2(155.41,85.9) 155.22,86.09 155.21,86.09 155.09,86.21 UH1.AM37 ; v2(80.72,12.09) 80.72,11.64 UH2.AN38 ; UV26.U3 v2(236.12,82.33) ; v2(245.32,59.93) 245.32,59.86 UV25.M10 ; UV25.U12 249.28,57.8 v2(248.93,57.45) ; UV26.G10 v2(244.12,87.13) ; UV26.E1 246.12,80.18 246.09,80.16 246.09,79.78 246.49,79.38 v2(246.57,79.38) ; UV23.R12 v2(236.01,108.88) UV23.R11 ; UV25.G10 240.97,59.06 v2(240.97,59) 240.94,59.03 240.89,59.03 UV25.F10 ; UV24.A14 204.22,110.35 v2(204.22,110.13) ; UV18.AL32 UV18.AL33 197.06,85.2 v2(196.66,85.6) ; UV25.D10 v2(238.52,59) ; 141.98,85.22 141.64,85.56 UH1.BJ36 ; 141.98,85.22 v2(141.99,85.22) ; UV23.A1 227.59,98.05 v2(227.59,97.11) ; UH1.AG11 158.96,66.81 159.11,66.97 v2(159.41,66.97) ; UV26.R3 v2(238.52,82.33) UV26.R4 ; UV26.C14 v2(248.12,90.34) ; UV18.B22 221.24,76.1 v2(220.85,76.49) ; UV26.A1 249.68,79.97 v2(249.68,79.88) ; UH1.BM25 UH1.BM24 140.42,76.56 v2(140.42,76.51) ; v2(95.23,18.68) 95.23,18.82 95.68,19.27 96.17,19.27 v2(96.32,19.42) 96,19.74 UH2.T7 ; UV24.R1 v2(214.75,100.08) ; v2(149.18,4.76) 149.18,6.15 149.58,6.55 149.58,7.47 DE9.1 ; UH1.BM13 140.34,68.54 140.34,68.77 UH1.BM14 139.89,69.22 139.57,69.22 UH1.BN14 ; UH1.M13 170.94,68.05 v2(171.29,68.39) ; v2(221.68,59) 221.67,58.99 221.67,58.92 221.35,58.6 UV18.B1 ; D124.2 328.57,70.11 328.69,69.99 v2(328.69,69.98) ; v2(246.57,87.89) 246.57,87.89 UV26.D10 ; UV24.R14 v2(205.15,100.08) ; UV25.H14 v2(241.72,56.6) UV25.H13 ; UV24.N12 v2(206.75,101.68) ; v2(199.13,70.64) UV18.AH16 ; UZ5.5 343.49,62.92 343.67,63.1 343.67,63.35 343.54,63.48 v2(341.86,63.48) ; UH2.N35 UH2.N37 81.57,21.19 v2(81.15,20.77) 80.81,21.12 UH2.N38 80.8,21.35 v2(80.8,22.87) UH2.K39 80.17,23.23 UH2.J40 ; UH1.AL33 155.44,83.26 v2(155.38,83.26) ; v2(220.04,73.98) 220.04,73.95 UV18.C19 220.85,73.97 v2(220.85,73.98) ; 166.78,67.64 166.95,67.64 UH1.T12 UH1.T13 166.78,67.64 ; 166.78,67.64 166.78,67.6 166.48,67.6 166.28,67.4 UH1.V12 166.1,67.4 v2(165.85,67.15) 165.61,67.15 UH1.W12 165.28,67.4 164.86,67.82 164.68,67.82 UH1.Y13 163.96,67.56 163.83,67.56 163.66,67.4 UH1.AA12 163.38,67.55 162.77,67.55 UH1.AC12 ; v2(121.46,29.89) 122.37,28.97 JDIMM1.61 ; UV24.F10 v2(208.56,106.88) ; UV24.A1 215.55,110.48 v2(216.08,110.48) ; v2(206.54,67.24) 206.57,67.27 206.57,67.38 206.84,67.65 UV18.W13 ; UV25.J10 v2(243.32,59) ; UH2.AW40 79.99,8.74 UH2.AV39 80.17,9.32 v2(79.95,9.54) ; UV25.N12 v2(245.72,57.4) ; UV18.AJ7 UV18.AK7 197.84,63.58 v2(197.45,63.96) ; RH5849.2 RH5848.2 RH5846.2 71.72,12.78 RH5845.2 71.48,12.73 71.1,13.11 v2(71.1,13.23) ; UA3.5 4.34,14.99 4.16,15.17 v2(3.31,15.17) ; UH1.BM22 UH1.BM23 ; UH1.BM22 140.05,75.28 v2(139.73,74.95) ; UV23.K1 v2(228.01,104.88) UV23.K2 ; UH1.A36 UH1.A37 ; v2(161.23,66.41) 161.54,66.1 UH1.AD10 ; UV25.U1 249.32,66.92 v2(249.12,67.12) ; D74.2 343.35,44.34 v2(343.38,44.3) ; UV24.D10 v2(207.55,108.08) ; v2(202.52,67.32) 202.52,67.48 UV18.AC13 ; v2(215,62.21) 214.97,62.24 214.97,63.11 UV18.K7 ; UH2.AE38 v2(80.92,14.57) ; v2(320.42,38.36) 320.68,38.1 D323.2 ; UV26.A12 249.41,89.14 v2(249.78,88.76) ; v2(205.07,63.88) 204.96,63.88 UV18.AB7 UV18.AB5 v2(205.01,61.37) ; UV25.E1 v2(239.32,66.21) ; UV23.R3 229.52,109.59 v2(229.62,109.59) 229.7,109.59 UV23.R4 ; CT43.2 22.1,33.82 ; UV18.W18 206.84,72.79 206.5,72.45 v2(206.5,72.33) 206.5,72.13 UV18.W17 ; UV25.U3 249.75,65.43 v2(249.75,65.47) ; UV23.C3 v2(229.61,99.28) UV23.C4 ; v2(168.75,86.52) 168.88,86.52 UH1.P37 ; v2(77.67,13.94) 77.53,13.81 77.53,13.52 77.19,13.18 UH2.AK46 ; UV23.P10 v2(235.21,108.88) ; UV26.F5 245.32,84 245.25,84.06 v2(245.25,84.18) ; JEDP1.14 v2(61.23,35.26) ; v2(212.35,99.32) 212.35,99.27 UV24.T5 ; UV26.H2 244.09,80.76 v2(244.09,80.71) UV26.H1 ; JEDP1.28 54.23,35.81 54.03,35.62 v2(54.03,35.31) ; UV23.C14 v2(237.61,100.08) ; UV26.T10 v2(237.72,87.13) ; UV23.K13 237.54,105.6 v2(237.62,105.6) 237.69,105.6 UV23.K14 ; UV25.A3 v2(236.92,65.41) ; UV23.E3 v2(229.61,101.68) ; UV18.P18 211.84,72.68 v2(212.17,72.35) 211.84,72.01 UV18.P17 ; v2(244.12,83.93) UV26.G5 ; UH1.W34 165.11,84.26 v2(164.82,84.56) ; UV24.G10 v2(208.35,105.68) ; v2(208.33,99.27) 208.33,99.26 UV24.T10 ; UV26.N14 v2(240.12,90.34) ; UV24.R4 v2(213.15,100.08) UV24.R3 ; UV26.R14 v2(238.52,90.34) ; UV24.U3 v2(213.12,97.64) ; JHDD.10 v2(235.86,12) ; RH1958.1 129.39,84.71 RH475.2 ; UH1.BJ29 141.68,80.73 UH1.BK29 ; v2(199.95,63.09) UV18.AH7 ; PC1520.2 192.55,116.51 192.79,116.27 v2(192.79,111.38) ; v2(14.21,35.38) 13.79,34.96 13.44,34.96 CA36.2 ; v2(205.15,101.68) UV24.N14 ; v2(235.36,56.64) 236.09,56.64 UV25.A14 ; UV25.C1 v2(238.52,67.01) ; UV24.B10 v2(207.55,109.68) ; UV26.N1 v2(240.12,80.73) ; UH2.E13 93.42,25.08 v2(93.71,25.08) ; UV23.E1 v2(228.02,101.68) ; UV25.E3 v2(240.12,64.61) ; UV24.E1 v2(214.75,108.08)
  BOTTOM w0.279: UV18.AL23 UV18.AL24 197.04,77.79 196.72,78.11 v2(196.67,78.11) 196.67,78.16 196.28,78.55 UV18.AM25 UV18.AN25 ; v2(199.11,78.12) UV18.AH24
  BOTTOM w0.3: UV18.K30 214.59,82.72 214.89,82.42 214.98,82.42 v2(214.98,82.43) ; 217.14,68.55 217.14,68.52
  BOTTOM w0.305: v2(216.74,66.47) 217.14,66.07 UV18.G10 ; UV18.AL15 UV18.AL14 197.04,69.35 UV18.AM13 ; JDIMM1.252 172.12,20.61 173.17,21.65 173.17,22.26 172.86,22.56 v2(172.64,22.56) ; UV18.AB23 v2(204.41,77.22) UV18.AA22 ; UV18.AH33 199.74,85.35 199.74,86.59 v2(199.84,86.68) ; JDIMM2.248 247.42,18.54 v2(247.51,18.45) ; JDIMM1.94 130.62,20.61 130.84,20.83 131.46,20.83 131.62,20.66 JDIMM1.98 131.62,18.65 131.67,18.6 v2(131.67,18.4) ; JDIMM1.227 165.87,28.89 165.54,29.26 v2(165.39,29.26) 165.17,29.26 164.89,28.98 164.89,28.8 JDIMM1.223 ; JDIMM2.193 233.67,29.08 v2(233.56,29.19) ; JDIMM2.2 183.92,18.82 184.25,18.49 184.72,18.49 184.92,18.7 JDIMM2.6 184.92,21.38 184.42,21.89 v2(184.16,21.89) ; JDIMM2.15 187.18,28.93 187.3,29.06 v2(187.98,29.06) 188.18,28.87 JDIMM2.19 ; v2(119.33,23.46) 119.33,23.35 119.38,23.3 119.38,21.58 119.73,21.23 120.49,21.23 121.12,20.59 JDIMM1.56 ; JDIMM2.23 189.18,29.07 189.19,29.09 189.19,29.14 v2(189.27,29.21) 189.86,29.21 190.18,28.9 JDIMM2.27 ; v2(202.06,86.55) 202.01,86.5 202.01,85.28 UV18.AE33 ; 166.63,19.65 166.63,20.52 167.63,21.52 167.63,22.17 167.24,22.56 v2(167.06,22.56) ; v2(174.2,8.76) 174.12,8.69 JAPS.10 ; JDIMM1.26 113.62,18.82 114.15,18.29 v2(114.68,18.29) 114.68,19.59 JDIMM1.30 ; JDIMM1.48 119.12,18.61 119.4,18.33 v2(119.52,18.33) 119.71,18.33 120.12,18.75 JDIMM1.52 ; JDIMM2.1 183.68,30.1 v2(184.33,30.76) 184.68,30.41 JDIMM2.5 ; v2(309.06,30.54) 308.52,31.08 JDEG1.10 ; v2(152.18,29.11) 152.61,29.11 152.87,28.85 JDIMM1.175 ; v2(226.72,29.82) 226.82,29.82 227.3,29.33 227.3,28.94 227.18,28.81 JDIMM2.167 ; v2(199.16,68.1) 199.16,68.12 199.54,68.49 UV18.AH13 ; JDIMM1.23 112.88,29.07 v2(112.89,29.08) ; JDIMM2.52 196.43,18.65 196.13,18.36 195.92,18.36 v2(195.92,18.36) 195.92,18.36 195.65,18.36 195.43,18.59 JDIMM2.48 ; JDIMM2.57 197.67,28.9 197.46,29.12 197.46,29.67 v2(197.47,29.69) ; v2(198.95,73.2) 199.19,73.2 UV18.AH19 ; UV18.G28 217.14,81.1 v2(217.56,81.52) 217.99,81.1 UV18.F28 ; v2(196.64,83.15) 197.04,82.75 UV18.AL30 ; UV18.B7 221.45,63.33 222.9,63.33 223.2,63.64 v2(223.2,63.78) ; UV18.AB2 v2(204.2,59.79) ; JDIMM1.176 153.12,20.89 153.81,21.57 ; JDIMM2.9 185.68,28.74 v2(186.07,29.14) ; 160.2,18.38 160.34,18.38 160.63,18.67 JDIMM1.206 ; 160.2,18.38 v2(160.2,18.39) ; 160.2,18.38 160.01,18.38 159.63,18.77 JDIMM1.202 ; v2(195.48,29.93) 195.18,29.62 JDIMM2.47 ; v2(204.17,82.38) 204.58,82.8 UV18.AB30 ; v2(223.16,79.7) 223.17,79.7 223.17,79.06 222.85,78.74 221.43,78.74 UV18.B25 ; v2(262.23,20.41) 262.23,19.98 261.8,19.54 JNGFF2.15 ; JDIMM2.98 207.92,18.56 v2(208.13,18.36) ; JDIMM1.77 126.37,29.28 v2(125.71,29.94) 125.19,29.41 125.19,28.96 125.37,28.77 JDIMM1.73 ; 153.81,21.57 154.12,21.26 JDIMM1.180 ; 153.81,21.57 153.81,22.13 153.38,22.56 v2(153.29,22.56) 153.11,22.56 152.12,21.57 JDIMM1.172 ; JDIMM2.64 199.43,18.66 199.13,18.36 v2(198.93,18.36) 198.77,18.36 198.43,18.7 JDIMM2.60 ; UV18.E10 218.81,66.05 v2(218.41,65.65) ; UV18.AN19 UV18.AM19 196.24,73.5 UV18.AL18 UV18.AL17 197.02,71.9 v2(196.62,71.51) 196.24,71.12 UV18.AM16 UV18.AN16 ; UV18.AH29 199.59,81.93 v2(199.13,81.47) 199.49,81.1 UV18.AH28 ; UV18.AB28 204.56,81.1 v2(204.16,80.7) ; JDIMM1.196 158.12,18.67 v2(157.84,18.39) 157.37,18.39 157.12,18.64 JDIMM1.192 ; JDIMM1.244 170.12,20.6 170.71,21.19 170.71,22.14 v2(170.84,22.28) ; v2(216.7,63.07) 216.75,63.07 217.14,63.46 UV18.G7 ; v2(153.43,29.23) 154.06,29.23 154.37,28.91 JDIMM1.181 ; v2(248.1,29.97) 247.9,29.97 247.18,29.25 JDIMM2.247 ; v2(131.73,29.38) 131.88,29.24 JDIMM1.99 ; v2(116.9,29.69) 117.23,29.69 117.88,29.05 JDIMM1.43 ; JDIMM2.189 232.67,29.01 232.49,29.19 v2(232.24,29.19) 231.99,29.19 231.67,28.87 JDIMM2.185 ; v2(167.06,25.1) 167.17,25.1 167.57,25.5 167.57,26.32 166.87,27.01 JDIMM1.231 ; v2(228.16,29.73) 228.7,29.73 229.18,29.26 JDIMM2.175 ; JNGFF1.21 335.55,85.21 336,85.65 v2(336.55,85.65) JNGFF1.25 ; UV18.AH30 199.59,82.82 v2(199.2,83.21) ; UV18.R19 v2(211.33,74.29) UV18.P20 ; v2(119.47,29.72) 119.34,29.72 118.88,29.26 JDIMM1.47 ; JDIMM1.189 156.39,27.85 156.39,28.93 156.19,29.12 v2(155.98,29.12) 155.63,29.12 155.37,28.87 JDIMM1.185 ; JDIMM2.69 200.67,28.81 200.4,29.08 v2(199.67,29.08) JDIMM2.65 ; JDIMM1.235 167.87,29.08 v2(168.05,29.26) 168.06,29.24 168.63,29.24 168.87,29 JDIMM1.239 ; JDIMM1.93 130.37,29.45 129.69,30.14 v2(129.64,30.14) ; v2(191.19,29.12) 191.18,29.11 JDIMM2.31 ; v2(219.97,81.47) 220.03,81.47 220.44,81.07 UV18.C28 UV18.B28 ; RA68.2 14.63,36.49 14.63,36.04 v2(14.56,35.97) ; JDIMM1.243 169.87,26.77 170.35,26.3 170.35,25.77 169.68,25.1 v2(169.47,25.1) ; v2(216.74,73.97) 217.14,73.57 UV18.G19 ; v2(211.66,80.7) 212.06,81.1 UV18.N28 ; UV18.AH10 199.55,66.05 v2(199.95,66.45) 199.54,66.87 UV18.AH11 ; JKB.17 164.18,7.41 163.87,7.09 162.64,7.09 v2(162.46,6.9) ; JDIMM2.218 239.93,18.7 239.66,18.43 v2(239.66,18.36) ; UV18.AB19 203.83,73.8 v2(203.42,74.22) 202.84,74.8 UV18.AC20 ; JDIMM2.184 231.42,18.65 231.62,18.45 232.21,18.45 232.3,18.35 ; JDIMM1.171 151.87,28.7 151.63,28.94 151.63,29.47 151.86,29.7 v2(152.17,29.7) ; UV18.T15 v2(210.43,69.21) UV18.R14 ; JDIMM2.197 234.67,29.21 234.11,29.78 v2(233.51,29.78) ; UV18.Y23 v2(206.37,77.27) UV18.W22 ; v2(334.3,93.35) JNGFF1.16 ; UV18.AE30 201.99,82.8 v2(201.58,83.21) ; JDIMM2.94 206.92,18.7 v2(206.58,18.36) ; v2(194.94,87.39) 194.89,87.39 194.41,86.9 194.41,85.43 UV18.AP33 ; v2(201.68,83.94) 201.68,83.95 202.09,84.35 UV18.AE32 ; UV18.G16 217.14,71.07 v2(216.74,71.47) ; v2(195.01,86.81) 195.44,86.38 UV18.AN34 ; 232.3,18.35 232.42,18.47 JDIMM2.188 ; 232.3,18.35 v2(232.3,18.35) ; v2(123.36,29.98) 124.37,28.97 JDIMM1.69 ; UV18.T5 209.59,62.67 v2(209.18,63.08) ; JDIMM1.218 163.63,20.49 164.63,21.5 164.63,22.05 164.13,22.56 v2(164.01,22.56) ; JDIMM1.90 129.62,20.62 129.41,20.84 128.83,20.84 128.62,20.63 JDIMM1.86 128.62,18.78 128.14,18.29 v2(127.91,18.29) 127.62,18.58 JDIMM1.82 ; v2(204.22,18.35) 203.92,18.65 JDIMM2.82 ; JDIMM1.167 150.87,28.73 151.1,28.96 151.1,29.3 150.62,29.78 v2(150.53,29.78) ; v2(203.36,72.36) 202.84,71.84 UV18.AC17 ; v2(129.64,29.4) 129.39,29.13 129.37,29.11 JDIMM1.89 ; UV18.T20 210.24,75.21 v2(210.37,75.21) 210.37,75.24 210.84,75.71 UV18.R21 ; JNGFF1.37 339.55,85.53 v2(339.6,85.57) ; JDIMM2.77 202.67,29.22 202.13,29.77 201.67,29.77 v2(201.54,29.63) 201.39,29.48 201.39,29.05 201.67,28.77 JDIMM2.73 ; UV18.Y19 v2(205.35,74.29) UV18.AA20 ; JDIMM2.102 208.92,18.66 209.24,18.35 v2(209.4,18.35) 209.53,18.35 209.94,18.76 JDIMM2.106 ; v2(246.08,18.36) 246.42,18.7 JDIMM2.244 ; JDIMM2.93 206.67,29.04 206.56,29.15 v2(206.56,29.44) 206.03,29.44 205.67,29.08 JDIMM2.89 ; JDIMM1.51 119.88,28.83 119.61,29.1 v2(119.47,29.1) ; JDIMM2.43 194.18,28.98 v2(193.18,29.97) ; JDIMM2.81 203.67,28.98 204.02,29.33 v2(204.17,29.33) 204.3,29.33 204.67,28.96 JDIMM2.85 ; JDIMM1.188 156.12,18.64 v2(155.87,18.39) 155.34,18.39 155.12,18.6 JDIMM1.184 ; v2(243.48,22.54) 243.22,22.54 241.93,21.24 JDIMM2.226 ; v2(131.73,30.11) 132.81,29.02 132.88,29.02 JDIMM1.103 ; JDIMM2.44 194.43,18.72 194.07,18.36 193.94,18.36 v2(193.94,18.36) 193.94,18.36 193.76,18.36 193.43,18.7 JDIMM2.40 ; JDIMM2.192 233.42,18.71 233.78,18.36 v2(234.05,18.36) 234.42,18.73 JDIMM2.196 ; UV18.T13 210.33,67.31 v2(210.33,67.27) 210.8,66.8 UV18.R12 ; v2(116.89,29.08) 116.89,29.08 116.88,29.06 JDIMM1.39 ; JDIMM1.72 125.12,18.71 125.5,18.33 v2(126.19,18.33) 126.62,18.77 JDIMM1.78 ; v2(150.74,22.81) 150.98,22.81 151.3,22.49 151.3,21.64 151.12,21.47 JDIMM1.168 ; v2(208.03,29.09) 208.18,28.94 JDIMM2.99 ; UV18.N23 212.84,77.77 v2(212.35,77.28) 212.28,77.28 211.84,76.84 UV18.P22 ; v2(222.47,84.85) 222.39,84.85 UV18.A33 UV18.B34 ; JDIMM1.102 132.62,18.6 132.83,18.39 v2(133.16,18.39) 133.41,18.39 133.62,18.61 JDIMM1.106 ; JDIMM2.231 243.18,28.89 v2(243.53,29.25) 243.8,29.25 244.18,28.88 JDIMM2.235 ; 191.66,18.35 191.96,18.35 192.43,18.81 JDIMM2.36 ; 191.66,18.35 191.39,18.35 190.92,18.82 JDIMM2.30 ; 191.66,18.35 v2(191.66,18.36) ; UV18.AK10 198.2,65.69 v2(198.28,65.69) ; JNGFF2.9 261.34,21.04 261.64,20.75 v2(261.64,20.41) ; v2(212.46,58.97) 212.09,59.34 UV18.N2 ; JDIMM2.180 230.43,19.65 v2(230.43,18.35) ; v2(219.12,58.2) 219.23,58.31 219.23,59.04 UV18.D2 ; UV18.AH2 199.23,59.76 199.23,59.81 199.2,59.84 v2(199.18,59.84) ; UV18.A2 222.44,58.99 222.44,58.95 v2(222.46,58.93) ; v2(123.36,18.32) 123.65,18.32 124.12,18.8 JDIMM1.68 ; v2(167.41,18.37) 167.41,18.57 167.63,18.78 JDIMM1.234 ; v2(111.68,29.7) 111.6,29.7 111.47,29.57 111.47,29.57 111.17,29.27 111.17,29.27 110.88,28.97 JDIMM1.15 ; JDIMM2.78 202.94,19.65 202.94,18.66 v2(202.63,18.35) ; UV18.K5 v2(215,62.21) ; v2(220.81,70.61) 220.81,70.63 220.44,71 UV18.C16 ; v2(218.4,78.89) 218.5,78.89 UV18.E25 ; JDIMM2.214 238.93,18.55 238.73,18.35 v2(238.29,18.35) 238.17,18.35 237.93,18.6 JDIMM2.210 ; v2(214.74,81.63) 214.74,81.25 UV18.K28 ; JDIMM2.222 240.93,19.65 240.93,18.59 v2(241.15,18.36) ; v2(114.92,29.1) 114.88,29.05 JDIMM1.31 ; JDIMM1.222 164.63,18.63 v2(164.86,18.39) 165.2,18.39 165.63,18.81 JDIMM1.226 ; v2(217.5,62.22) 217.5,62.21 UV18.G5 ; JDIMM1.81 127.37,28.78 127.65,29.05 v2(127.76,29.16) ; v2(228.83,23.8) 228.69,23.8 227.42,22.54 JDIMM2.168 ; JDIMM2.51 196.18,28.93 v2(195.73,29.37) ; UV18.V12 207.86,66.8 v2(208.34,67.27) 208.81,66.8 UV18.U12 ; v2(123.39,29.23) 123.37,29.21 JDIMM1.65 ; UV18.AN22 UV18.AM22 196.29,76.05 v2(196.66,75.68) 197.04,75.3 UV18.AL21 UV18.AL20 ; JDIMM2.234 243.93,18.63 243.65,18.35 v2(243.56,18.35) 243.38,18.35 242.93,18.81 JDIMM2.230 ; UV18.T22 v2(210.32,77.28) UV18.R23 ; v2(220.06,83.91) 220.05,83.91 219.74,83.6 UV18.D31 ; UV18.T2 209.29,59.1 209.29,58.16 v2(209.33,58.11) ; UV18.P13 212.24,67.4 212.24,67.27 212.3,67.22 v2(212.3,67.26) 212.76,66.8 UV18.N12 ; UV18.E7 218.84,63.5 v2(218.44,63.1) UV18.F7 ; JDIMM2.217 239.67,28.93 v2(239.29,29.32) ; DV12.2 58.53,29.07 v2(57.94,29.67) ; JNGFF2.39 261.37,13.54 261.84,13.08 v2(261.84,12.83) 261.84,12.61 261.27,12.04 JNGFF2.45 ; JNGFF1.61 345.55,85.17 345.18,85.54 344.12,85.54 v2(344.05,85.6) JNGFF1.55 ; v2(341,85.78) 341,85.45 341.05,85.4 JNGFF1.43 ; UV18.E5 v2(219.24,61.4) ; UV18.W20 v2(206.38,75.25) UV18.Y21 ; JDIMM2.90 205.92,22.94 205.11,23.75 v2(204.68,23.75) ; 187.81,18.34 187.32,18.34 186.92,18.73 JDIMM2.14 ; 187.81,18.34 v2(187.81,18.36) ; 187.81,18.34 187.92,18.46 JDIMM2.18 ; UV18.C7 220.44,63.51 v2(220.04,63.11) ; JDIMM2.205 236.67,28.78 236.25,29.2 v2(236.14,29.2) 235.67,28.74 JDIMM2.201 ; v2(200.26,18.36) 200.43,18.52 JDIMM2.68 ; v2(261.78,15.35) 261.7,15.27 261.7,15.23 261.51,15.04 JNGFF2.33 ; JDIMM2.172 228.42,18.66 228.73,18.36 v2(229.04,18.36) 229.2,18.36 229.44,18.61 JDIMM2.176 ; UV18.E22 219.22,75.66 v2(219.22,75.62) ; JDIMM2.202 235.93,18.62 236.19,18.36 236.49,18.36 v2(236.5,18.36) 236.5,18.36 236.79,18.36 236.94,18.51 JDIMM2.206 ; JDIMM1.27 113.88,29.28 113.48,29.67 v2(112.89,29.67) ; v2(245.23,18.36) 244.93,18.67 JDIMM2.238 ; v2(213.56,72.32) 213.56,72.28 213.84,72.01 UV18.M17 ; JDIMM1.201 159.37,28.8 159.71,29.13 v2(159.77,29.13) 159.83,29.2 160.14,29.2 160.37,28.97 JDIMM1.205 ; UV18.T28 209.61,81.1 v2(210.01,80.7) ; JDIMM2.209 237.67,29 v2(237.97,29.3) 238.29,29.3 238.67,28.91 JDIMM2.213 ; CZ82.2 186.17,85.02 UZ9.5 ; JNGFF1.28 337.3,90.99 337.15,90.83 337.15,89.94 v2(337.29,89.8) ; UV18.G32 217.27,84.58 217.27,85.01 UV18.G33 216.97,85.2 216.66,84.89 v2(216.66,84.88) ; JDIMM1.209 161.37,28.74 v2(161.02,29.09) 161.25,29.32 162.01,29.32 162.37,28.96 JDIMM1.213 ; v2(220.04,76.49) 220.44,76.09 UV18.C22 ; JNGFF1.49 342.55,85.44 v2(342.71,85.6) ; JDIMM2.56 197.43,18.61 v2(197.67,18.36) ; v2(296.5,32.7) 296.01,32.7 295.56,32.24 JLPDE1.9 ; JDIMM2.251 248.18,29.32 v2(248.1,29.4) ; v2(197.44,81.47) 197.04,81.07 UV18.AL28 ; JDIMM1.44 118.12,18.6 v2(117.83,18.31) 117.59,18.31 117.12,18.77 JDIMM1.40 ; v2(214.38,70.11) 214.07,69.8 UV18.M15 213.84,69.82 213.43,70.23 v2(213.43,70.21) UV18.N16 ; v2(195.04,83.12) 195.44,82.72 UV18.AN30 ; JDIMM1.60 122.12,18.75 122.56,18.31 v2(122.64,18.31) 122.64,18.33 123.12,18.81 JDIMM1.64 ; v2(230.43,29.1) 230.67,28.86 JDIMM2.181 ; JDIMM2.252 248.42,20.92 v2(248.81,21.31) ; v2(154.18,7.75) 155.23,7.75 JKB.16 ; UV18.AB21 203.77,75.8 203.41,76.16 v2(203.39,76.16) 203.39,76.19 202.84,76.73 UV18.AC22 ; v2(115.87,18.31) 115.87,18.32 116.12,18.58 JDIMM1.36 ; v2(171.83,8.87) 171.83,8.75 172.12,8.46 JAPS.14 ; UV18.AN7 194.52,63.55 v2(194.5,63.56) ; JDIMM2.107 210.18,29.01 v2(210.65,29.49) ; JDIMM2.35 192.18,29.08 192.34,29.25 v2(193.18,29.25) 193.19,29.25 193.17,29.23 193.17,27.86 JDIMM2.39 ; JDIMM1.107 133.88,29.17 v2(134.28,29.58) ; JDIMM1.247 170.89,29.17 170.62,29.17 v2(170.56,29.24) 171.83,29.24 171.89,29.18 171.89,27.85 JDIMM1.251 ; UV18.G3 217.09,60.17 v2(217.45,59.81) 217.44,59.81 217.09,59.46 UV18.G2 ; v2(214.18,76.34) 214.22,76.34 213.84,76.72 UV18.M22 UV18.N21 ; UV18.Y14 v2(206.33,69.3) UV18.W15 ; v2(204.68,22.48) 204.89,22.48 205.27,22.1 205.27,20.88 204.92,20.54 JDIMM2.86 ; UV18.AM13 UV18.AN13 ; UV18.AM13 196.24,68.45 v2(196.57,68.11) 196.99,67.7 UV18.AL12 ; JDIMM1.193 157.39,28.83 157.09,29.13 v2(157.04,29.13) ; JDIMM1.214 162.63,18.8 162.21,18.39 v2(161.97,18.39) 161.63,18.74 JDIMM1.210 ; JDIMM2.72 201.43,20.94 v2(202.65,22.17) ; UV18.Y12 205.96,66.8 206.35,67.18 206.48,67.18 v2(206.54,67.24) ; UV18.G22 216.82,76.36 216.82,76.43 v2(216.8,76.46) ; UV18.AC15 202.84,69.86 v2(203.39,70.41) 203.77,70.8 UV18.AB16 ; v2(332.8,93.34) JNGFF1.10 ; JDIMM2.227 242.18,28.83 v2(241.78,29.27) 241.67,29.27 241.18,28.78 JDIMM2.223 ; UV18.G30 217.11,82.8 v2(217.51,83.2) ; JNGFF2.57 259.68,9.04 259.29,9.43 259.29,10.33 259.5,10.54 JNGFF2.51 ; JNGFF1.1 v2(328.55,85.65) ; UV18.AA15 v2(205.35,70.31) UV18.Y16 ; v2(217.56,78.12) 217.14,78.54 217.14,78.55 UV18.G25 ; v2(20.07,52.57) 20.82,52.57 CT152.2 ; UV25.N3 245.76,64.64 245.68,64.64 v2(245.68,64.64) ; UV18.K32 214.63,84.44 214.63,85.15 UV18.K33 214.65,85.26 214.65,86.51 214.69,86.55 214.69,86.61 v2(214.71,86.62) ; JDIMM2.243 246.18,26.73 v2(245.77,26.32) 245.18,26.91 JDIMM2.239 ; JDIMM1.19 111.88,28.87 v2(111.68,29.06) ; v2(330.05,85.65) JNGFF1.7 ; JDIMM2.171 228.18,29.13 v2(228.16,29.15) ; JDIMM1.5 108.37,26.85 107.55,26.03 v2(107.41,26.03) 107.25,26.03 106.81,26.48 106.81,26.8 107.37,27.36 JDIMM1.1 ; v2(219.97,78.12) 220.01,78.12 UV18.C25 ; UV18.G13 217.14,68.55 ; JDIMM2.22 188.92,18.73 189.3,18.36 189.5,18.36 v2(189.5,18.36) 189.5,18.36 189.52,18.36 189.92,18.76 JDIMM2.26 ; JDIMM1.85 128.37,29.39 v2(127.81,29.95) ; v2(163.74,29.26) 163.37,28.9 JDIMM1.217 ; UV18.N19 213.34,74.3 v2(213.57,74.3) 213.57,74.53 213.83,74.8 UV18.M20 ; UV18.N7 212.39,63.19 212.39,62.45 v2(212.51,62.33) ; UV18.D33 220.01,85.62 220.01,86.18 220.31,86.48 220.31,87.13 v2(220.23,87.2) ; v2(334.56,85.83) 334.05,85.32 JNGFF1.15 ; v2(121.46,29.19) 121.37,29.1 JDIMM1.57 ; UV18.N33 UV18.N32 ; v2(156.97,29.87) 157.21,29.87 158.39,28.69 158.39,27.85 JDIMM1.197 ; JDIMM1.35 115.88,29.72 115.31,30.28 v2(114.89,30.28) ; UV18.W32 207.11,84.4 207.52,84.81 v2(207.52,84.83) ; JAPS.12 173.12,8.48 173.03,8.57 v2(173.03,8.76) ; v2(338.7,86.36) 338.67,86.39 338.15,86.39 337.9,86.13 337.9,85.4 338.05,85.24 JNGFF1.31 ; v2(335.67,93.33) 335.8,93.2 JNGFF1.22 ; v2(194.9,58.12) 194.96,58.12 UV18.AN1 UV18.AP2 ; JDIMM2.103 209.18,29.02 210.24,30.09 v2(210.59,30.09) ; JDIMM2.10 v2(185.92,21.77) ; UV18.AE5 v2(202.51,62.22) ; UV18.AB14 UV18.AC13 ; 217.14,68.52 v2(216.74,68.12) ; UV18.M13 v2(213.38,68.25) UV18.N14
  BOTTOM w0.356: CA23.2 4.69,29.07 CA37.2 ; CA9.2 15.72,37.89 CA8.2 ; v2(28.45,71.5) 28.2,71.76 CM32.2 ; RT37.1 29.47,47.68 29.34,47.8 v2(29.34,47.8) ; JDIMM1.18 111.62,20.8 110.76,21.67 110.76,22.02 110.32,22.46 v2(110.18,22.46) ; RT187.1 20.87,63.11 20.59,63.38 v2(20.59,63.5) 20.23,63.14 RT188.1 ; CM31.2 CM29.1 ; 109.62,21 JDIMM1.10 ; 109.62,21 109.64,20.99 110.31,20.99 110.62,20.68 JDIMM1.14 ; 109.62,21 109.62,21.92 108.66,22.88 108.66,23.44 v2(108.68,23.46) ; JDIMM1.6 108.62,21.59 108.05,22.17 v2(107.77,22.17) 107.51,22.17 107.19,21.85 107.19,21.27 107.62,20.83 JDIMM1.2 ; JDIMM1.22 112.62,20.79 111.81,21.6 111.81,22.21 112.19,22.58 v2(112.42,22.58) ; v2(212.51,62.33) 212.51,62.22 UV18.N5 ; CA11.2 14.16,38.95 CA10.2 13.2,38.95 v2(12.97,39.18) ; v2(21.34,95.12) 21.21,95.25 CM40.1 ; C3003.2 v2(351.19,60.64) ; v2(35.58,43.95) 35.32,43.69 RT4.1 ; JDIMM1.9 109.37,26.67 108.66,25.96 108.66,25.28 v2(108.64,25.26) ; C3004.2 v2(347.12,46.7)
  BOTTOM w0.381: v2(28.45,73.03) 28.2,72.77 CM30.1 ; CT186.2 CT187.2 23.96,47.18 v2(24.49,47.71) ; v2(54.45,27.25) 54.61,27.41 CZ44.2 53.71,28.25 CV184.2 ; RH95.1 103.27,12.37 104.1,12.37 v2(105.28,13.54) ; CV182.1 15.69,76.99 17.17,76.99 ; v2(8.47,34.29) CA32.2 8.43,33.71 CA78.2 ; CV933.2 203.86,101.42 204.01,101.28 UV24.N14 ; v2(22.45,78.07) 22.38,78 21.82,78 21.51,78.31 21.51,78.49 21.06,78.94 20.02,78.94 19.43,78.36 ; v2(22.45,78.07) 22.45,77.73 23.12,77.06 CM5.1 ; v2(22.45,78.07) 22.49,78.03 24.77,78.03 25.22,77.57 CM2.2 24.93,77 CM3.1 ; v2(335.38,33.5) 335.47,33.4 CR5.2 336.31,33.07 RR6.1 ; UV24.U12 205.06,96.78 CV934.2 ; RH5833.2 RH5832.2 ; CM29.1 27.79,69.11 27.89,69.01 CM27.2 ; v2(8.74,13.03) 8.74,12.63 8.42,12.32 CA122.2 ; CM38.1 CM50.2 18.76,73.04 v2(19.1,73.38) 18.89,73.6 CM35.1 18.72,74.08 CM34.2 ; v2(68.35,4.96) 68.62,4.7 CH45.2 ; PQ221.4 60.21,14.49 v2(60.39,14.67) 60.45,14.73 PC219.2 ; v2(209.82,56.64) 210.08,56.37 RV1840.2 ; v2(52.47,26.25) 52.47,26.31 51.81,26.97 51.81,27.92 RV114.2 ; v2(69.75,5.9) 69.72,5.92 69.72,6.12 69.36,6.49 68.89,6.49 UH8.4 ; UH1.Y37 164.45,86.27 164.29,86.43 164.28,86.43 164.19,86.52 v2(164.04,86.52) ; CM25.2 21.25,77.38 CM23.2 19.89,77.55 19.43,78 19.43,78.36 ; JTS.6 350,53.94 v2(349.62,54.33) ; RH148.1 RH149.1 173.8,58.13 v2(173.72,58.22) ; CR2.2 335.5,37.9 v2(335.23,37.9) 335.12,38.01 CR1.2 ; CH51.1 CD3325.2 106.03,2.71 v2(105.86,2.53) 105.8,2.53 CH50.1 ; YT1.2 v2(21.21,30.57) ; v2(28.44,70.63) 28.12,70.63 CM31.2 CM32.2 ; PQ223.1 58.78,20.99 v2(59.46,20.99) ; v2(334.51,41.33) 334.84,41.66 335.15,41.66 ; 51.33,16.42 51.89,15.86 PQ227.4 52.82,15.86 54.12,17.16 PQ227.1 ; v2(16.94,35.18) 16.94,35.3 16.81,35.43 15.66,35.43 15.34,35.1 PC204.2 14.95,34.41 PQ205.3 ; CH46.2 72.69,4.7 v2(73.69,3.71) ; CA34.2 4.53,33.86 4.46,33.78 CA33.2 CA120.1 4.46,32.45 v2(4.62,32.28) ; v2(10.63,74.61) 11.2,74.61 RM21.1 ; v2(5.67,28.6) 5.25,29.01 CA23.2 ; v2(100.93,17.49) 100.79,17.64 100.74,17.64 100.33,18.05 100.33,18.16 100.31,18.18 v2(100.31,18.2) 99.87,18.65 99.87,18.9 v2(99.77,19) ; CZ43.2 v2(50.71,24.08) ; RA94.1 2.67,31.67 2.96,31.96 2.96,33.67 3.34,34.05 3.34,35.14 v2(3.75,35.54) ; v2(52.96,1.7) 52.46,1.7 PC1908.2 ; 17.17,76.99 17.17,76.65 CM22.2 ; 17.17,76.99 18.54,78.36 19.43,78.36 ; UH14.3 60.36,4.74 v2(60.54,4.92) ; v2(171.11,55.28) 171.58,55.75 RH150.1 ; v2(28.45,73.66) 28.32,73.66 28.2,73.53 CM28.1 CM33.2 ; RV109.2 RV107.2 46.79,29.41 47.64,30.26 v2(47.64,30.79) ; v2(68.33,2.52) 67.81,2 UH7.3 ; CA121.2 v2(6.57,10.26) ; CT123.2 12.32,62.98 12,62.66 v2(11.56,62.66) ; v2(10.64,33.08) 10.61,33.11 RA16.1 ; v2(10.64,63.49) 9.92,63.49 9.13,64.27 8.23,64.27 CT122.2
  BOTTOM w0.406: JLPDE1.11 300.56,29.68 300.63,29.75 v2(300.63,30.18) ; v2(293.42,30.04) 293.42,30.01 JLPDE1.12
  BOTTOM w0.457: UM2.4 28.17,91.95 v2(28.73,92.51) ; PC1005.2 PC1017.2 167.9,120.09 v2(167.88,120.11) ; 308.52,31.08 308.2,31.08 307.52,30.39 JDEG1.12 ; YT1.4 20.11,33.42 v2(20.27,33.58) ; v2(202.5,12.45) 201.46,11.41 DE4.1 ; v2(121.03,95.25) 121.1,95.17 CH3.2 122.63,95.17 CH175.2 ; v2(16.51,52.58) 16.46,52.53 CT189.2 ; v2(64.58,14.06) 64.62,14.1 PQ224.3 ; v2(314.02,26.93) JDEG1.11
  BOTTOM w0.508: v2(45.44,22.1) 45.44,22.63 v5(45.23,22.84) 44.78,23.29 PC1923.2 ; v2(3.22,15.88) 3.79,15.88 CZ104.2 ; PC1119.2 112.5,102.01 v2(112.5,101.87) ; v2(250.06,103.11) 250.05,103.13 PR1608.2 249.45,103.85 PR1607.2 ; PC512.2 132.41,2.8 v2(132.41,2.34) ; CM1.2 27.69,79.21 v2(28.59,80.11) 28.36,80.34 PC114.2 PC115.2 ; v2(243.49,110.36) 243.59,110.47 PR906.2 PC911.2 ; 183,9.08 JTP.9 183.85,9.1 ; v2(314.02,26.93) 314.27,26.67 C1079.2 ; RV1837.2 v2(215.65,54.16) ; v2(239.91,110.41) 240.41,110.9 PC912.2 ; v2(154.18,7.75) 154.43,8 CE74.2 ; JNGFF2.68 262.05,24.94 v2(262.05,26.54) 262.05,26.54 PC611.2 ; PC1288.2 146.75,120.61 v2(146.41,120.27) ; v2(244.2,118.77) PC901.2 v2(243.21,119.51) ; PC1200.2 134.62,111.2 v2(134.62,110.8) ; v2(28.87,61.18) 28.72,61.02 CT157.2 ; v2(223.65,59.18) 224.64,60.17 CV871.2 CV862.2 ; v2(247.3,100.38) 247.91,100.99 PC1612.2 ; v2(182.5,86.81) 181.23,85.54 CZ86.2 ; v2(66.06,12.65) 66.06,12.56 66.18,12.45 RH528.2 ; v2(16.47,36.03) 16.47,37.08 16.02,37.53 CA9.2 ; CR17.2 351.17,48.55 v2(351.23,48.61) ; PC1105.1 108.52,106.74 v2(108.01,107.25) 108.14,107.25 108.59,107.7 PR1106.1 ; v2(156.01,119.3) 156.01,119.74 156.54,120.27 PC1290.2 ; v2(32.26,15.88) 31.95,16.18 PC1932.2 ; CZ88.2 CZ47.2 180.32,82.59 v2(179.66,81.93) ; PC610.2 289.36,25.01 v2(287.13,25.01) 287.35,25.23 287.35,25.89 PC607.1 ; v2(340.73,49.04) 340.35,48.65 JTS1.8 ; JFAN1.5 97.97,39.6 97.69,39.32 v2(97.69,38.17) 97.89,37.97 97.89,37.14 97.6,36.84 JFAN1.4 ; DA2.2 14.52,53.24 15.23,52.53 CT189.2 ; v2(132.26,106.1) 132.25,106.08 132.25,105 132.61,104.64 RH469.2 ; v2(14.63,59.48) 14.72,59.56 CZ101.1 16.28,59.56 CT144.2 16.79,59.06 RT191.2 17.76,58.8 RV1845.2 ; v2(183.37,113.98) PC1517.2 184.3,113.93 RV1835.2 ; v2(166.4,29.26) 166.4,31.09 171.06,35.75 JDIMM1.262 ; JTP.5 v2(189,12.42) 189,13.57 188.25,14.32 CE79.2 CE80.2 ; JFAN2.5 333.32,59.52 v2(333.75,59.95) ; JFAN2.5 334.09,58.23 334.09,54.17 JFAN2.6 ; JFAN2.5 330.74,59 330.46,59.28 CI2.2 ; CZ29.2 v2(345.57,61.66) ; CR18.2 351.11,42.58 v2(351.03,42.5) ; DI3.1 347.73,41.78 v2(347.98,41.53) ; v2(286.36,33.07) 286.44,33.15 PC609.2 ; v2(197.91,12.4) 197.91,10.75 196,8.84 JTP.10 196,6.69 v2(195.92,6.6) ; JTS.3 349.71,56.34 v2(349.51,56.14) ; JFP.9 313.6,38.01 312.45,36.86 310.87,36.86 v2(310.01,37.72) ; v2(152.66,7.75) 152.05,7.14 CE83.2 ; PQ223.4 56.87,19.46 57.13,19.2 v2(57.13,18.94) ; JTS.7 348.4,51.86 348.87,51.4 v2(348.87,51) ; PR607.2 293.25,32.54 v2(293.28,32.51) ; v2(344.8,40.97) 344.68,41.1 CR16.2 ; PR1604.2 PC1611.2 249.76,105.72 v2(250.06,105.41) ; v2(230.51,6.61) 230.99,7.09 JHDD.23 ; PC614.2 293.16,30.74 293.42,30.47 v2(293.42,30.04) ; PC1117.2 v2(124.27,104.84) ; v2(318.19,30.15) 318.39,30.35 RE255.1 ; JFP.10 318.71,38.24 v2(318.5,38.44) ; v2(127.73,84.42) 127.86,84.42 128.39,83.9 RH475.2 128.58,83.58 129.19,82.96 129.22,82.96 129.76,82.42 RH497.1 ; v2(20.31,102.43) 20.3,102.43 20.28,102.41 RI26.2 ; RH472.2 135.68,95.14 136.7,95.14 137.9,96.34 RH466.2 138.14,96.87 v2(138.42,97.16) ; v2(23.8,67.29) 24.66,66.42 CT153.2 ; CE78.2 191.36,12.83 v2(191.8,12.39) ; v2(104.04,79.66) 104.04,78.77 PC1302.1 ; v2(29.55,57.56) 29.55,57.71 29.04,58.22 CT149.2 27.78,58.22 CT150.2 ; v2(330.86,38.67) CR6.2 ; v2(164.06,120.07) 163.77,119.78 PC1018.2 ; JAPS.20 167.14,4.01 v2(167.12,4.01) ; PC812.2 PC805.2 109.86,65.83 110.22,66.19 v2(110.29,66.19) ; v2(302.83,27.63) 303.03,27.43 303.03,26.85 303.51,26.37 JTAG1.2 ; v2(336.86,42.13) 336.95,42.22 CR3.2 ; CLRP1.2 v2(65.66,4.57) ; v2(189.1,120.78) 189.1,120.05 189.08,120.03 PR1519.2 PC1532.2 ; RV593.2 190.03,63.98 v2(190.4,63.62) ; JDIMM2.262 249.61,36.99 v2(248.5,36.99) ; PR1104.1 110.68,109.54 v2(110.36,109.22) ; PR1104.1 PC1139.1 ; PR1104.1 PR1100.1 ; JFAN2.4 v2(338.71,57.7) ; v2(108.72,55.01) 108.76,55.05 H25.1 ; v2(3.11,60.45) 2.92,60.26 RA95.1 3.59,59.79 3.75,59.95 DA5.2 ; v2(213.95,54.14) 213.74,54.35 RV567.2 ; JEDP1.44 63.68,33.66 62.79,34.55 v2(62.79,35.26) ; RI11.2 RI12.2 338.21,61.76 v2(338.62,61.35) 338.71,61.44 RZ39.2 ; v2(24.26,102.92) RI8.1 23.32,102.92 23.13,103.11 UI4.3 ; PR804.2 PC811.2 104.06,64.19 104.19,64.31 v2(104.24,64.31) 104.06,64.49 PR808.2 ; v2(219.05,105.92) 218.42,105.3 RV613.2 ; v2(224.04,104.97) 224.3,105.22 RV617.2 RV614.2 ; RH77.2 63.03,2.38 62.54,1.88 v2(62.54,1.59) ; v2(107.47,15.61) 107.14,15.61 106.71,15.18 105.47,15.18 104.77,14.48 RH5836.2 ; JFAN1.6 94.46,39.6 95.54,40.68 95.54,42.65 v2(95.43,42.76) ; PC1604.2 240.83,96.2 v2(240.36,96.67) ; v2(330.86,37.47) CR4.2 ; v2(145.97,103.36) 145.62,103.36 PH1104.1 ; v2(348.22,50.98) 347.45,50.21 JTS1.9 ; v2(237.87,6.61) 238.36,7.09 JHDD.24 ; PC1518.2 184.12,115.83 184.07,115.88 v2(183.69,115.88) 183.69,116.26 184.16,116.72 PC1501.2 ; v2(102.64,25.78) 102.36,26.06 CH202.2 ; CZ31.2 v2(346.33,62.93) ; v2(166.68,10.16) 166.55,10.03 CE82.2 CE81.2 ; v2(194.76,12.36) 194.76,12.39 194.78,12.4 194.78,12.77 CE77.2 ; CH3329.2 74.04,1.47 73.04,2.48 v2(72.9,2.48) ; v2(183.78,119.71) PC1522.2 183.95,118.91 184.17,119.13 PR1516.1 ; PQ1501.3 188.82,110.52 PR1502.2 ; JTS1.10 339.51,49.75 v2(340.04,49.75) ; v2(3.07,44.54) 2.67,44.93 DA3.2 ; PC1041.2 171.31,118.04 v2(171.46,117.89) ; v2(134.79,2.31) 134.79,3.03 PC511.2 ; PC1055.2 PR1022.2 173.24,114.77 v2(173.53,114.48) ; v2(183.26,30.77) 183.25,30.78 JDIMM2.261 ; v2(330.33,31.37) 330.33,29.38 SW_BOT.4 ; PC615.2 276.38,33.76 v2(277.1,33.76) ; v2(187.52,62.17) 187.9,62.55 RV589.2 189.05,62.52 RV592.2 ; v2(191.9,88.37) 191.2,87.67 RV578.1 ; v2(165.9,109.73) 165.74,109.9 PC1030.2 ; v2(116.1,97.61) 115.63,98.08 PC1134.1 ; v2(151.54,10) 151.38,9.84 CE3322.2 ; v2(328.55,85.65) 327.91,85.65 JNGFF1.68 ; v2(20.75,105.29) 20.69,105.23 CI21.2 ; PU1302.9 v2(114.63,95.61) ; PC900.2 v2(242.32,119.51) ; v2(104.84,34.01) 106.57,35.75 JDIMM1.261 ; CZ82.2 186.84,85.04 186.91,84.98 v2(187.92,84.98) ; PC1336.1 104.06,71.54 v2(103.85,71.76) ; C3005.2 v2(346.46,61.66) ; PH1100.1 v2(104.52,85.66) ; v2(242.06,110.26) PR910.2 ; CV868.1 v2(222.35,119.32) ; PC1293.2 145.8,119.7 145.54,119.95 v2(145.54,120.27) ; v2(44.55,22.3) 44.43,22.43 PC1924.2 ; v2(70.93,24.04) 70.93,25.23 CH180.2 ; CE67.2 v2(335.84,47.32) ; PR908.2 240.45,111.05 ; JTS.8 v2(349.71,59.24)
  vias: v2(0.43,20.68) v2(0.43,19.41) v2(0.43,18.14) v2(0.43,16.87) v2(0.43,15.6) v2(0.43,14.33) v2(0.43,13.06) v2(0.43,11.79) v2(1.02,21.8) v2(1.1,10.71) v2(1.33,94.99) v2(1.33,93.72) v2(1.33,74.53) v2(1.33,73.26) v2(1.33,71.99) v2(1.33,70.72) v2(1.33,69.45) v2(1.33,68.18) v2(1.33,66.91) v2(1.33,65.64) v2(1.33,64.37) v2(1.33,63.1) v2(1.33,61.83) v2(1.33,60.56) v2(1.33,47.16) v2(1.33,45.89) v2(1.33,44.62) v2(1.33,43.35) v2(1.33,42.08) v2(1.33,40.81) v2(1.33,39.54) v2(1.33,38.27) v2(1.33,37) v2(1.33,35.73) v2(1.33,34.46) v2(1.33,33.19) v2(1.33,31.92) v2(1.33,30.65) v2(1.33,29.38) v2(1.33,28.11) v2(1.33,26.84) v2(1.33,25.57) v2(1.33,24.3) v2(1.33,23.03) v2(1.33,9.46) v2(1.33,6.92) v2(1.33,2.86) v2(1.33,1.84) v2(1.36,112.66) v2(1.38,75.8) v2(1.46,111.39) v2(1.52,0.58) v2(1.75,96.19) v2(1.99,4.07) v2(2.11,92.71) v2(2.08,5.31) v2(2.56,113.07) v2(2.6,76.15) v2(2.64,6.11) v2(2.64,2.95) v2(2.78,0.43) v2(3.83,113.07) v2(3.93,6.62) v2(3.89,2.52) v2(4.05,0.43) v2(5.1,113.07) v2(5.09,13.34) v2(5.16,2.87) v2(5.27,67.54) v2(5.26,65.06) v2(5.32,0.43) v2(5.38,111.18) v2(5.56,96.22) v2(5.56,5.99) v2(5.92,92.71) v2(6.12,4.54) v2(6.37,113.07) v2(6.41,76.15) v2(6.53,111.18) v2(6.57,36.75) v2(6.59,0.43) v2(6.83,96.22) v2(7.19,92.71) v2(7.19,10.54) v2(7.64,113.07) v2(7.68,76.15) v2(7.8,111.18) v2(7.82,10.54) v2(7.86,0.43) v2(8.1,96.22) v2(8.46,92.71) v2(8.46,10.54) v2(8.64,38.82) v2(8.93,75.89) v2(8.85,69.06) v2(8.95,61.27) v2(9.07,111.18) v2(9.15,60.58) v2(9.09,10.54) v2(9.13,0.43) v2(9.37,96.22) v2(9.49,7.05) v2(9.63,93.21) v2(9.73,10.54) v2(9.98,91.11) v2(9.98,89.84) v2(9.98,79.42) v2(9.98,78.41) v2(10.2,75.9) v2(10.34,111.18) v2(10.4,0.43) v2(10.48,61.27) v2(10.64,96.22) v2(10.71,71.43) v2(10.71,40.9) v2(10.71,36.75) v2(10.74,15.07) v2(11.49,16.3) v2(11.56,61.75) v2(11.67,0.43) v2(11.98,6.09) v2(12.07,16.3) v2(12.58,27.47) v2(12.68,16.27) v2(12.85,111.42) v2(12.94,0.43) v2(13.03,96.22) v2(13.13,108.91) v2(13.13,107.64) v2(13.13,106.37) v2(13.13,105.1) v2(13.13,103.83) v2(13.13,102.56) v2(13.13,101.29) v2(13.13,100.02) v2(13.13,98.75) v2(13.07,70.36) v2(13.16,27.48) v2(13.31,6.17) v2(13.9,6.17) v2(14.49,6.17) v2(14.73,64.72) v2(15.08,6.17) v2(15.52,8.31) v2(15.55,7.72) v2(16.45,7.62) v2(16.53,113.07) v2(16.81,8.21) v2(16.75,0.43) v2(16.9,39.55) v2(16.99,40.18) v2(17.05,7.62) v2(17.11,37.89) v2(17.41,8.19) v2(17.65,7.64) v2(17.8,113.07) v2(17.86,37.33) v2(18,99.49) v2(18.02,0.43) v2(18.49,35.64) v2(19.07,113.07) v2(19.15,32.18) v2(19.18,99.66) v2(19.18,97.83) v2(19.29,0.43) v2(19.55,111.11) v2(19.72,107.27) v2(19.7,30.46) v2(20,47.51) v2(20,46.93) v2(20.14,111.11) v2(20.34,113.07) v2(20.33,107.27) v2(20.63,30.49) v2(20.56,0.43) v2(20.73,111.13) v2(20.85,97.79) v2(20.88,96.24) v2(21.01,41.63) v2(21.11,45.35) v2(21.09,40.87) v2(21.27,45.97) v2(21.53,44.94) v2(21.61,113.07) v2(21.68,45.55) v2(21.83,0.43) v2(21.91,99.79) v2(22.36,70.16) v2(22.82,38.27) v2(22.88,113.07) v2(23.1,0.43) v2(23.17,106.83) v2(23.22,105.59) v2(23.46,40.87) v2(23.46,39.57) v2(23.46,38.92) v2(23.46,38.27) v2(23.98,31.28) v2(24.15,113.07) v2(24.11,40.87) v2(24.11,36.97) v2(24.37,0.43) v2(24.55,56.4) v2(24.59,58.22) v2(24.61,56.99) v2(24.94,64.26) v2(25.17,91.87) v2(25.27,92.51) v2(25.42,113.07) v2(25.41,39.57) v2(25.39,31.43) v2(25.64,0.43) v2(25.68,96.9) v2(25.73,92.13) v2(25.68,91.54) v2(25.66,90.96) v2(25.86,92.74) v2(26.11,85.15) v2(26.12,84.58) v2(26.06,42.84) v2(26.22,47.66) v2(26.32,92.1) v2(26.37,91.52) v2(26.37,21.62) v2(26.63,85.4) v2(26.63,84.24) v2(26.62,31.42) v2(26.69,113.07) v2(26.66,84.82) v2(26.91,0.43) v2(27.24,106.29) v2(27.17,85.13) v2(27.17,84.54) v2(27.17,83.96) v2(27.36,40.22) v2(27.61,104.9) v2(27.76,31.42) v2(27.96,113.07) v2(27.99,107.48) v2(28,41.53) v2(28.18,0.43) v2(28.73,91.44) v2(28.73,90.76) v2(28.73,90.16) v2(28.73,89.54) v2(28.73,88.95) v2(28.73,88.38) v2(28.73,87.69) v2(28.72,87.1) v2(28.72,84.98) v2(28.82,104.22) v2(29.13,112.58) v2(29.45,107.72) v2(29.45,0.43) v2(29.57,111.39) v2(29.57,110.12) v2(29.57,103.42) v2(29.57,102.15) v2(29.57,100.88) v2(29.57,99.61) v2(29.57,98.34) v2(29.57,97.07) v2(29.57,95.8) v2(29.57,94.53) v2(29.57,93.26) v2(29.57,91.99) v2(29.57,90.72) v2(29.57,89.45) v2(29.57,88.18) v2(29.57,86.91) v2(29.57,85.64) v2(29.57,84.37) v2(29.57,83.1) v2(29.57,81.83) v2(29.57,80.56) v2(29.57,79.29) v2(29.57,78.02) v2(29.57,76.75) v2(29.57,75.48) v2(29.57,74.21) v2(29.57,72.94) v2(29.57,71.67) v2(29.57,70.4) v2(29.57,69.13) v2(29.57,67.86) v2(29.57,66.59) v2(29.57,65.32) v2(29.57,64.05) v2(29.57,62.78) v2(29.62,26.74) v2(29.71,61.52) v2(29.93,60.27) v2(29.94,39.57) v2(30.19,59.02) v2(30.2,26.74) v2(30.5,57.79) v2(30.47,54.88) v2(30.54,54.31) v2(30.48,31.89) v2(30.63,5.74) v2(30.72,0.43) v2(30.86,56.57) v2(30.92,53.87) v2(31.27,55.37) v2(31.36,5.71) v2(31.73,54.19) v2(31.97,34.41) v2(31.99,0.43) v2(32.24,53.02) v2(32.42,28.52) v2(32.79,51.88) v2(33,28.53) v2(33.04,20.22) v2(33.26,0.43) v2(33.39,50.76) v2(33.58,28.52) v2(33.68,20.22) v2(34.03,49.66) v2(34.3,20.22) v2(34.43,28.53) v2(34.53,0.43) v2(34.72,48.59) v2(34.94,20.22) v2(35.04,28.53) v2(35.44,47.55) v2(35.54,20.22) v2(35.8,0.43) v2(35.88,28.51) v2(36.21,46.54) v2(36.49,28.51) v2(37.01,45.57) v2(37.07,0.43) v2(37.51,41.02) v2(37.54,39.42) v2(37.87,44.62) v2(38.34,0.43) v2(38.75,43.7) v2(38.75,40.91) v2(39.13,38.75) v2(39.61,0.43) v2(39.66,42.82) v2(40.61,41.98) v2(40.78,38.94) v2(40.88,0.43) v2(41.38,38.81) v2(41.59,41.17) v2(42.15,0.43) v2(42.61,40.41) v2(43.16,38.05) v2(43.42,0.43) v2(43.56,31.27) v2(43.65,39.69) v2(43.79,37.85) v2(44.73,39.01) v2(44.69,0.43) v2(45.85,38.41) v2(45.96,0.43) v2(46.33,36.6) v2(47.03,37.95) v2(47.23,0.43) v2(47.8,13.99) v2(48.26,37.64) v2(48.5,0.43) v2(48.91,16.23) v2(48.91,15.11) v2(48.91,13.99) v2(49.26,11.25) v2(49.26,10.67) v2(49.52,37.49) v2(49.77,0.43) v2(49.91,11.91) v2(49.89,11.3) v2(49.87,10.72) v2(50.03,13.99) v2(50.79,37.47) v2(50.93,18.75) v2(50.93,18.16) v2(50.93,17.58) v2(50.93,16.99) v2(50.93,13.08) v2(50.93,12.5) v2(50.93,11.91) v2(50.93,11.33) v2(50.92,10.72) v2(51.04,0.43) v2(51.06,31.24) v2(51.24,35.31) v2(51.51,18.75) v2(51.51,18.16) v2(51.51,17.58) v2(51.51,13.08) v2(51.51,12.5) v2(51.51,11.91) v2(51.51,11.33) v2(51.51,10.75) v2(51.69,31.24) v2(52.06,37.47) v2(52.1,11.33) v2(52.1,10.75) v2(52.31,0.43) v2(52.52,5.82) v2(52.64,7.21) v2(52.68,11.33) v2(52.68,10.75) v2(53.1,6.35) v2(53.11,5.78) v2(53.12,5.19) v2(53.1,4.6) v2(53.24,7.19) v2(53.33,37.47) v2(53.25,11.91) v2(53.25,11.33) v2(53.25,10.75) v2(53.58,0.43) v2(53.75,6.36) v2(53.75,5.79) v2(53.75,5.22) v2(53.74,4.62) v2(53.85,7.18) v2(54.35,1.45) v2(54.42,7.18) v2(54.6,37.47) v2(55.27,11.91) v2(55.27,11.33) v2(55.27,10.75) v2(55.35,2.23) v2(55.87,37.47) v2(56.62,2.23) v2(57.14,37.47) v2(57.89,2.23) v2(58.41,37.47) v2(59.16,2.23) v2(59.68,37.47) v2(60.43,2.12) v2(60.95,37.47) v2(61.13,1.06) v2(61.55,26.34) v2(62.22,37.47) v2(62.24,0.43) v2(62.33,26.35) v2(63.12,26.31) v2(63.49,37.47) v2(63.51,0.43) v2(64.48,26.48) v2(64.76,37.47) v2(64.78,0.43) v2(65.79,26.32) v2(66.03,37.47) v2(66.05,0.43) v2(66.99,26.32) v2(67.3,37.47) v2(67.32,0.43) v2(67.39,10.32) v2(68.24,35.51) v2(68.57,37.47) v2(68.59,0.43) v2(68.95,35.51) v2(69.84,37.47) v2(69.86,0.43) v2(71.11,37.47) v2(71.13,0.43) v2(71.77,31.67) v2(72.38,37.47) v2(72.41,31.67) v2(72.4,0.43) v2(73.04,31.67) v2(73.65,37.47) v2(73.67,0.43) v2(74.92,37.47) v2(74.94,0.43) v2(75.57,28.27) v2(75.72,23.39) v2(76.02,28.74) v2(76.05,25.66) v2(76.19,37.47) v2(76.15,28.17) v2(76.21,0.43) v2(76.58,28.56) v2(77.06,27.69) v2(77.08,19.24) v2(77.46,37.47) v2(77.48,0.43) v2(78.73,37.47) v2(78.75,0.43) v2(80,37.47) v2(80.02,0.43) v2(81.27,37.47) v2(81.29,0.43) v2(82.4,19.68) v2(82.45,18.52) v2(82.54,37.49) v2(82.5,25.06) v2(82.56,0.43) v2(83.4,18.52) v2(83.46,10.91) v2(83.8,37.66) v2(83.83,0.43) v2(84,25.07) v2(85.03,37.97) v2(85.1,0.43) v2(85.22,25.12) v2(85.43,23.01) v2(86.22,38.44) v2(86.37,0.43) v2(87.05,22.89) v2(87.33,39.04) v2(87.3,24.01) v2(87.29,23.42) v2(87.64,0.43) v2(88.4,39.72) v2(88.91,0.43) v2(89.45,40.45) v2(89.56,26.65) v2(89.89,21.87) v2(90.18,0.43) v2(90.35,25.07) v2(90.46,41.21) v2(90.74,17.06) v2(90.86,13.56) v2(91.05,21.87) v2(91.09,20.82) v2(91.44,42.02) v2(91.38,17.09) v2(91.45,0.43) v2(92.39,42.87) v2(92.72,0.43) v2(93.3,43.75) v2(93.65,21.9) v2(93.58,15.82) v2(93.79,14.39) v2(93.87,9.48) v2(93.99,0.43) v2(94.18,44.67) v2(95.02,45.62) v2(95.26,0.43) v2(95.82,46.61) v2(96.53,0.43) v2(96.58,47.63) v2(96.94,8.29) v2(97.05,21.29) v2(96.96,12.64) v2(97.29,48.67) v2(97.8,0.43) v2(97.95,4.03) v2(98.12,3.43) v2(98.26,49.5) v2(98.55,3.93) v2(98.99,3.38) v2(99.07,0.43) v2(99.52,49.59) v2(99.58,32.83) v2(100.34,0.43) v2(100.46,54.94) v2(100.61,50.25) v2(100.88,56.14) v2(100.94,53.77) v2(101.25,57.36) v2(101.29,51.32) v2(101.41,52.59) v2(101.52,35.82) v2(101.57,58.59) v2(101.61,0.43) v2(101.84,59.83) v2(102.17,33.36) v2(102.43,96.62) v2(102.43,95.35) v2(102.43,94.08) v2(102.43,92.81) v2(102.43,91.54) v2(102.43,90.27) v2(102.64,81.37) v2(102.64,80.1) v2(102.64,78.83) v2(102.64,77.56) v2(102.64,76.29) v2(102.64,75.02) v2(102.64,73.75) v2(102.64,72.48) v2(102.64,71.21) v2(102.64,69.94) v2(102.64,68.67) v2(102.64,67.4) v2(102.64,66.13) v2(102.87,56.69) v2(102.88,0.43) v2(103.23,97.6) v2(103.18,35.38) v2(103.61,33.86) v2(103.62,24.07) v2(103.62,23.36) v2(103.93,120.26) v2(103.93,118.99) v2(103.93,117.72) v2(103.93,116.45) v2(103.93,115.18) v2(103.93,113.91) v2(103.93,112.64) v2(103.93,111.37) v2(103.93,110.1) v2(103.93,108.83) v2(103.93,107.56) v2(103.93,106.29) v2(103.93,105.02) v2(103.93,103.75) v2(103.93,102.48) v2(103.93,101.21) v2(103.93,99.94) v2(103.92,98.67) v2(104.01,121.53) v2(104.04,59.54) v2(104.04,58.93) v2(104.04,58.29) v2(104.04,57.68) v2(104.15,0.43) v2(104.27,60.12) v2(104.46,93.51) v2(104.57,59.18) v2(104.6,57.96) v2(104.75,58.55) v2(105.25,121.82) v2(105.42,0.43) v2(105.6,61.44) v2(106.52,121.82) v2(106.69,0.43) v2(106.76,71.62) v2(107.06,75.78) v2(107.06,74.82) v2(107.06,73.86) v2(107.07,73.22) v2(107.61,77.15) v2(107.61,76.46) v2(107.68,73.22) v2(107.79,121.82) v2(107.83,83.66) v2(107.83,81.73) v2(107.79,81.1) v2(107.77,75.78) v2(107.77,74.82) v2(107.77,73.86) v2(107.82,71.51) v2(107.82,70.93) v2(107.94,61.69) v2(107.96,0.43) v2(108.42,81.08) v2(108.53,83.66) v2(108.53,82.7) v2(108.53,81.73) v2(108.48,75.78) v2(108.48,74.82) v2(108.48,73.86) v2(108.46,71.51) v2(108.46,70.93) v2(108.58,79.23) v2(109.06,121.82) v2(109.14,78.58) v2(109.07,71.51) v2(109.07,70.93) v2(109.25,86.36) v2(109.24,83.66) v2(109.24,82.7) v2(109.24,81.73) v2(109.19,79.17) v2(109.17,77.98) v2(109.17,77.37) v2(109.17,76.73) v2(109.17,76.1) v2(109.23,0.43) v2(109.34,85.76) v2(109.32,84.6) v2(109.61,85.22) v2(109.67,71.51) v2(109.67,70.93) v2(109.82,96.88) v2(109.82,96.27) v2(109.84,84.11) v2(109.83,83.52) v2(109.83,79.17) v2(109.78,78.58) v2(109.81,77.98) v2(109.81,77.37) v2(109.81,76.73) v2(109.81,76.1) v2(109.86,86.3) v2(109.9,84.71) v2(109.87,53.6) v2(109.97,85.71) v2(110.22,97.36) v2(110.21,57.94) v2(110.21,57.3) v2(110.21,56.67) v2(110.18,25) v2(110.18,23.73) v2(110.32,121.72) v2(110.28,85.19) v2(110.5,96.81) v2(110.5,96.22) v2(110.49,86.3) v2(110.48,84.11) v2(110.46,83.52) v2(110.5,0.43) v2(110.61,120.48) v2(110.59,85.7) v2(110.62,84.7) v2(110.91,97.38) v2(110.95,95.44) v2(110.91,94.77) v2(110.93,94.11) v2(110.9,93.47) v2(111.1,119.31) v2(111.1,96.64) v2(111.1,96.03) v2(111.13,86.3) v2(111.13,85.08) v2(111.18,85.71) v2(111.55,95.35) v2(111.51,94.77) v2(111.51,94.13) v2(111.57,93.53) v2(111.73,96.64) v2(111.73,96.03) v2(111.76,86.3) v2(111.81,85.71) v2(111.76,85.08) v2(111.77,0.43) v2(112.04,118.45) v2(112.1,94.78) v2(112.1,94.17) v2(112.17,95.63) v2(112.42,25.12) v2(112.42,23.85) v2(113.04,0.43) v2(113.25,118.08) v2(113.35,79.57) v2(113.35,78.93) v2(113.35,78.3) v2(113.35,77.66) v2(113.35,77.03) v2(113.35,76.39) v2(113.35,75.76) v2(113.95,79.57) v2(113.95,78.93) v2(113.95,78.3) v2(113.95,77.66) v2(113.95,77.03) v2(113.95,76.39) v2(113.95,75.76) v2(114.31,0.43) v2(114.4,24.12) v2(114.37,22.32) v2(114.52,118.07) v2(114.56,79.57) v2(114.56,78.93) v2(114.56,78.3) v2(114.56,77.66) v2(114.56,77.03) v2(114.56,76.39) v2(114.56,75.76) v2(114.58,59.01) v2(114.61,58.32) v2(114.61,57.71) v2(114.62,56.96) v2(114.94,86.11) v2(114.94,85.35) v2(115.1,108.35) v2(115.1,106.39) v2(115.1,104.42) v2(115.06,57.34) v2(115.19,59.7) v2(115.19,59.12) v2(115.19,58.52) v2(115.19,57.91) v2(115.64,25.12) v2(115.64,23.85) v2(115.64,22.58) v2(115.58,0.43) v2(115.7,86.11) v2(115.7,85.35) v2(115.79,118.17) v2(115.83,57.99) v2(116.47,94.15) v2(116.46,86.11) v2(116.46,85.35) v2(116.85,0.43) v2(116.91,118.77) v2(117.15,117.08) v2(117.07,108.35) v2(117.07,106.39) v2(117.07,104.42) v2(117.15,94.12) v2(117.22,86.11) v2(117.22,85.35) v2(117.48,1.78) v2(117.67,119.79) v2(117.98,86.11) v2(117.98,85.35) v2(118,25) v2(118,23.73) v2(118,22.46) v2(118.15,120.97) v2(118.08,1.78) v2(118.12,0.43) v2(118.67,1.78) v2(119.04,108.35) v2(119.04,106.39) v2(119.04,104.42) v2(119.08,119.2) v2(119.26,25.26) v2(119.25,1.78) v2(119.42,120.97) v2(119.39,0.43) v2(119.51,68.2) v2(119.89,120.52) v2(119.89,117.48) v2(119.86,1.78) v2(120.02,67.69) v2(120.14,69.09) v2(120.14,68.45) v2(120.08,21.97) v2(120.44,1.78) v2(120.69,120.97) v2(120.75,25) v2(120.75,22.46) v2(120.66,0.43) v2(120.78,69.09) v2(120.78,68.45) v2(120.94,117.1) v2(121.03,1.78) v2(121.93,0.43) v2(121.98,1.78) v2(122.12,117.48) v2(122.4,120.37) v2(122.56,1.78) v2(123.02,121.66) v2(123.13,1.78) v2(123.16,25) v2(123.16,23.73) v2(123.16,22.46) v2(123.2,0.43) v2(123.7,1.78) v2(124.07,51.69) v2(124.28,121.82) v2(124.27,1.78) v2(124.41,23.99) v2(124.44,22.19) v2(124.47,0.43) v2(124.75,118.63) v2(124.74,117.98) v2(124.73,117.37) v2(124.77,120.43) v2(124.76,119.85) v2(124.75,119.23) v2(125.27,111.1) v2(125.45,120.41) v2(125.44,119.81) v2(125.43,119.21) v2(125.42,118.63) v2(125.38,117.98) v2(125.42,117.34) v2(125.55,121.82) v2(125.6,14.58) v2(125.74,0.43) v2(125.76,110.57) v2(126.21,110.08) v2(126.41,25) v2(126.41,23.73) v2(126.41,22.46) v2(126.67,62.8) v2(126.82,121.82) v2(126.8,58.19) v2(127.01,0.43) v2(127.73,63.04) v2(127.8,58) v2(128.09,121.82) v2(128.28,0.43) v2(128.82,58.24) v2(128.91,62.76) v2(129.05,118.78) v2(129.06,118.18) v2(129.36,121.82) v2(129.55,0.43) v2(129.64,118.78) v2(129.65,118.17) v2(130.27,118.78) v2(130.27,118.16) v2(130.63,121.82) v2(130.82,0.43) v2(131.11,6.73) v2(131.9,121.82) v2(132.09,0.43) v2(133.1,109.35) v2(133.17,121.82) v2(133.36,0.43) v2(133.54,6.9) v2(133.73,109.73) v2(133.93,25.25) v2(133.93,23.92) v2(133.93,21.39) v2(134.11,109.22) v2(134.44,121.82) v2(134.63,0.43) v2(134.75,72.16) v2(135.28,66.09) v2(135.38,74.54) v2(135.37,60.96) v2(135.44,2.34) v2(135.63,59.95) v2(135.71,121.82) v2(135.78,24.9) v2(135.78,23.6) v2(135.91,7.11) v2(135.9,0.43) v2(136.02,64.81) v2(136.54,107.99) v2(136.53,6.94) v2(136.53,6.3) v2(136.68,79.88) v2(136.68,76.14) v2(136.87,56.88) v2(136.98,121.82) v2(137.15,107.96) v2(137.16,6.94) v2(137.16,6.3) v2(137.17,0.43) v2(137.61,105.81) v2(137.67,101.35) v2(137.85,107.96) v2(137.84,25.04) v2(137.82,23.66) v2(137.76,6.94) v2(137.76,6.3) v2(138.09,58.15) v2(138.25,121.82) v2(138.35,6.94) v2(138.35,6.3) v2(138.44,0.43) v2(138.66,55.53) v2(138.96,106.16) v2(138.95,6.94) v2(138.95,6.3) v2(139.05,109.7) v2(139.06,109.02) v2(139.07,101.03) v2(139.52,121.82) v2(139.48,59.27) v2(139.54,6.94) v2(139.54,6.3) v2(139.6,110.06) v2(139.65,109.4) v2(139.65,108.76) v2(139.71,0.43) v2(139.82,56.81) v2(140.08,25.08) v2(140.08,23.81) v2(140.29,110.03) v2(140.29,109.4) v2(140.29,108.76) v2(140.26,105.78) v2(140.34,101.43) v2(140.4,119.74) v2(140.39,119.15) v2(140.4,118.54) v2(140.4,117.79) v2(140.36,117.04) v2(140.79,121.82) v2(140.98,0.43) v2(141.17,58.16) v2(141.26,119.76) v2(141.33,119.18) v2(141.26,118.57) v2(141.33,117.78) v2(141.35,117.04) v2(141.64,4.91) v2(141.9,5.97) v2(141.85,3.93) v2(142.06,121.82) v2(142.24,117.04) v2(142.19,56.46) v2(142.25,0.43) v2(142.3,119.79) v2(142.3,119.19) v2(142.27,118.6) v2(142.29,117.78) v2(142.25,25.6) v2(142.3,23.8) v2(142.63,74.74) v2(143.33,121.82) v2(143.34,117.67) v2(143.35,119.77) v2(143.35,119.15) v2(143.35,118.52) v2(143.49,57.74) v2(143.52,0.43) v2(143.61,73.65) v2(143.61,72.13) v2(143.74,79.08) v2(143.66,78.23) v2(143.7,77.47) v2(143.74,56.29) v2(143.75,70.28) v2(143.94,74.48) v2(144.1,71.43) v2(144.45,117.61) v2(144.4,81.98) v2(144.45,79.03) v2(144.39,77.42) v2(144.46,119.7) v2(144.46,119.08) v2(144.46,118.46) v2(144.6,121.82) v2(144.63,74.47) v2(144.7,71.43) v2(144.8,24.11) v2(144.8,22.84) v2(144.79,0.43) v2(145.16,81.99) v2(145.55,5.96) v2(145.49,3.89) v2(145.81,4.87) v2(145.87,121.82) v2(146.06,0.43) v2(146.54,54.17) v2(146.47,24.11) v2(146.74,81.99) v2(147.14,121.82) v2(147.33,0.43) v2(147.36,54.99) v2(147.5,82) v2(147.88,108.26) v2(148.05,74.4) v2(148.16,79.03) v2(148.15,77.37) v2(148.15,71.45) v2(148.15,69.8) v2(148.41,121.82) v2(148.45,65.84) v2(148.45,65.2) v2(148.59,108.28) v2(148.59,98.68) v2(148.65,74.38) v2(148.6,0.43) v2(148.75,77.35) v2(148.75,71.44) v2(148.75,69.78) v2(148.76,79.01) v2(149.07,81.99) v2(149.23,98.68) v2(149.18,24.11) v2(149.28,108.31) v2(149.28,74.41) v2(149.39,79.04) v2(149.38,77.38) v2(149.38,71.47) v2(149.38,69.81) v2(149.53,56.01) v2(149.68,121.82) v2(149.86,98.68) v2(149.89,81.99) v2(149.87,0.43) v2(150.09,59.06) v2(150.5,98.68) v2(150.56,107.86) v2(150.74,25.35) v2(150.74,24.08) v2(150.95,121.82) v2(151.14,0.43) v2(151.26,54.14) v2(151.29,52.21) v2(151.5,81.99) v2(151.75,107.88) v2(152.09,1.27) v2(152.22,121.82) v2(152.25,86.54) v2(152.25,85.23) v2(152.25,83.93) v2(152.25,82.63) v2(152.23,82) v2(152.39,56.87) v2(152.39,54.9) v2(152.67,115.66) v2(152.67,115.04) v2(152.66,9.27) v2(152.66,6.22) v2(152.8,77.4) v2(153.04,81.99) v2(153.14,1.98) v2(153.28,115.66) v2(153.28,115.08) v2(153.28,114.49) v2(153.29,25.1) v2(153.29,23.83) v2(153.49,121.82) v2(153.82,83.93) v2(153.82,81.99) v2(153.86,115.66) v2(153.86,115.08) v2(153.86,114.49) v2(153.86,113.91) v2(154.03,79.63) v2(154,78.11) v2(153.98,76.76) v2(153.99,76.18) v2(154.02,74.17) v2(154.02,71.16) v2(154.06,70.5) v2(154.16,72.5) v2(154.45,115.66) v2(154.45,115.08) v2(154.45,114.49) v2(154.45,113.91) v2(154.41,113.29) v2(154.41,1.98) v2(154.76,121.82) v2(155.03,115.66) v2(155.03,115.08) v2(155.03,114.49) v2(155.03,113.91) v2(155.07,25.37) v2(155.09,23.56) v2(155.17,113.27) v2(155.23,112.59) v2(155.45,80.39) v2(155.58,114.88) v2(155.59,114.26) v2(155.7,9.27) v2(155.7,6.22) v2(155.68,1.98) v2(156.03,121.82) v2(156.14,57.18) v2(156.16,59.07) v2(156.3,54.37) v2(156.31,52.57) v2(156.46,25.1) v2(156.46,23.83) v2(156.46,22.56) v2(156.47,10.09) v2(156.95,81.99) v2(156.95,1.98) v2(157.1,10.1) v2(157.3,121.82) v2(157.34,73.15) v2(157.37,72.44) v2(157.38,71.31) v2(157.41,70.7) v2(157.43,69.41) v2(157.39,58.34) v2(157.39,56.51) v2(157.5,54.62) v2(158.21,79.75) v2(158.22,1.98) v2(158.57,121.82) v2(158.57,81.98) v2(158.84,79.73) v2(158.88,25.1) v2(158.88,23.83) v2(158.88,22.56) v2(159.34,85.88) v2(159.34,84.59) v2(159.34,81.99) v2(159.41,74.36) v2(159.39,73.73) v2(159.51,75.56) v2(159.5,74.96) v2(159.49,1.98) v2(159.84,121.82) v2(159.92,56.51) v2(159.94,54.3) v2(160.08,87.3) v2(160.27,24.09) v2(160.32,22.29) v2(160.36,73.25) v2(160.76,1.98) v2(161.01,53.9) v2(161.11,121.82) v2(161.27,113.96) v2(161.27,113.37) v2(161.27,112.79) v2(161.68,82) v2(161.67,25.1) v2(161.67,23.83) v2(161.67,22.56) v2(161.81,115.24) v2(161.81,114.66) v2(161.85,113.44) v2(161.85,114.08) v2(161.86,112.84) v2(162.03,1.98) v2(162.38,121.82) v2(162.4,115.24) v2(162.4,114.66) v2(162.43,114.08) v2(162.45,113.46) v2(162.45,112.87) v2(162.43,57.99) v2(162.46,112.27) v2(162.47,111.65) v2(162.94,102.45) v2(162.98,115.24) v2(163.03,112.83) v2(163.01,105.42) v2(163.01,104.79) v2(162.96,104.2) v2(162.96,103.62) v2(162.96,103.03) v2(163.05,112.25) v2(163.08,111.65) v2(163.31,82) v2(163.3,56.19) v2(163.3,1.98) v2(163.5,102.21) v2(163.58,105.63) v2(163.56,104.99) v2(163.59,104.39) v2(163.65,121.82) v2(164.04,85.23) v2(164.03,82) v2(164.01,25.1) v2(164.01,23.83) v2(164.19,105.61) v2(164.17,105.03) v2(164.17,104.43) v2(164.24,79.74) v2(164.18,73.34) v2(164.21,70.23) v2(164.31,75) v2(164.52,102.36) v2(164.58,103.54) v2(164.59,102.96) v2(164.61,98.25) v2(164.57,97.64) v2(164.57,1.98) v2(164.68,98.83) v2(164.8,70.26) v2(164.92,121.82) v2(164.93,75) v2(164.98,73.33) v2(164.96,57.59) v2(165.14,97.64) v2(165.2,98.22) v2(165.26,98.84) v2(165.53,25.43) v2(165.52,23.56) v2(165.73,97.66) v2(165.67,82) v2(165.84,98.86) v2(165.79,98.26) v2(165.8,93.09) v2(165.84,1.98) v2(165.91,121.01) v2(166.11,78.07) v2(166.11,77.44) v2(166.11,76.8) v2(166.11,76.17) v2(166.19,97.14) v2(166.19,96.55) v2(166.19,95.97) v2(166.19,95.39) v2(166.31,56.24) v2(166.37,93.14) v2(166.41,82.01) v2(166.6,99.42) v2(166.65,100) v2(166.77,97.14) v2(166.77,96.55) v2(166.77,95.97) v2(166.77,95.39) v2(167.06,23.83) v2(167.11,1.98) v2(167.18,120.97) v2(167.3,94.95) v2(167.5,115.66) v2(167.6,54.94) v2(167.9,94.92) v2(168.02,82.02) v2(168.12,116.28) v2(168.12,115.03) v2(168.45,120.97) v2(168.37,57.93) v2(168.38,1.98) v2(168.55,69.04) v2(168.75,115.66) v2(168.8,85.25) v2(168.81,84.59) v2(168.8,83.9) v2(168.8,82.03) v2(169.11,73.24) v2(169.18,70.23) v2(169.3,74.85) v2(169.44,78.43) v2(169.44,77.72) v2(169.44,77.09) v2(169.44,76.45) v2(169.44,75.82) v2(169.47,23.83) v2(169.47,22.56) v2(169.56,74.06) v2(169.65,56.68) v2(169.72,120.97) v2(169.65,1.98) v2(170.54,24.13) v2(170.92,1.98) v2(170.99,120.97) v2(170.97,8.87) v2(171.33,58.11) v2(171.78,10.89) v2(172.19,1.98) v2(172.25,121.09) v2(172.61,89.12) v2(172.64,25.1) v2(172.64,23.83) v2(172.68,56.76) v2(173.29,121.82) v2(173.46,1.98) v2(174.47,93.07) v2(174.56,121.82) v2(174.73,1.98) v2(175.29,21.54) v2(175.41,95.01) v2(175.83,121.82) v2(175.95,95.34) v2(175.95,94.73) v2(175.89,21.55) v2(176.05,93.07) v2(176,1.98) v2(176.56,95.95) v2(176.56,95.34) v2(176.56,94.73) v2(177.1,121.82) v2(177.27,1.98) v2(177.62,120.96) v2(177.62,120.38) v2(177.62,119.79) v2(178.02,102.85) v2(178.02,102.22) v2(178.02,101.62) v2(178.02,101.02) v2(178.02,100.43) v2(178.11,97.64) v2(178.2,120.96) v2(178.2,120.38) v2(178.2,119.79) v2(178.37,121.82) v2(178.54,1.98) v2(178.69,109.7) v2(178.69,109.07) v2(178.69,108.43) v2(178.69,107.8) v2(178.69,107.16) v2(178.69,106.53) v2(178.69,105.89) v2(178.69,105.26) v2(178.69,104.62) v2(178.69,103.99) v2(178.69,103.35) v2(178.69,102.72) v2(178.69,102.08) v2(178.69,101.45) v2(178.69,100.81) v2(178.69,100.18) v2(178.69,99.54) v2(178.69,98.91) v2(178.69,98.27) v2(178.69,97.64) v2(178.69,97.05) v2(178.84,120.96) v2(178.84,120.38) v2(178.84,119.79) v2(178.94,3.24) v2(179.27,109.7) v2(179.27,109.07) v2(179.27,108.43) v2(179.27,107.8) v2(179.27,107.16) v2(179.27,106.53) v2(179.27,105.89) v2(179.27,105.26) v2(179.27,104.62) v2(179.27,103.99) v2(179.27,103.35) v2(179.27,102.72) v2(179.27,102.08) v2(179.27,101.45) v2(179.27,100.81) v2(179.27,100.18) v2(179.27,99.54) v2(179.27,98.91) v2(179.27,98.27) v2(179.27,97.64) v2(179.27,97.05) v2(179.47,120.96) v2(179.47,120.38) v2(179.47,119.79) v2(179.64,121.82) v2(179.56,3.24) v2(179.81,1.98) v2(180.11,120.96) v2(180.11,120.38) v2(180.11,119.79) v2(180.19,12.86) v2(180.19,3.23) v2(180.49,56.21) v2(180.74,120.96) v2(180.74,120.38) v2(180.74,119.79) v2(180.91,121.82) v2(180.93,55.6) v2(181.03,53.44) v2(181,12.86) v2(181.08,1.98) v2(181.33,120.96) v2(181.33,120.38) v2(181.33,119.79) v2(181.84,12.86) v2(182.18,121.82) v2(182.35,1.98) v2(182.61,12.86) v2(182.97,52.18) v2(183.21,12.86) v2(183.28,25.66) v2(183.45,121.82) v2(183.62,1.98) v2(184.37,58.9) v2(184.53,54.65) v2(184.62,92.51) v2(184.63,88.03) v2(184.72,121.82) v2(184.89,1.98) v2(185.04,110.62) v2(185.23,25.34) v2(185.23,23.44) v2(185.52,101.59) v2(185.5,100.99) v2(185.65,110.67) v2(185.65,110.08) v2(185.65,109.5) v2(185.84,92.79) v2(185.78,87.75) v2(185.78,54.31) v2(185.9,59.35) v2(185.99,121.82) v2(186.23,109.5) v2(186.16,1.98) v2(186.54,100.97) v2(186.82,109.5) v2(186.98,88.05) v2(187.01,25.02) v2(187.01,23.75) v2(187.01,22.48) v2(187.15,101.56) v2(187.14,100.97) v2(187.12,92.41) v2(187.12,54.69) v2(187.26,121.82) v2(187.31,58.84) v2(187.4,109.5) v2(187.43,1.98) v2(187.58,100.52) v2(187.58,99.94) v2(187.61,98.5) v2(187.68,101.86) v2(187.68,101.22) v2(187.99,109.5) v2(188.27,116.29) v2(188.53,121.82) v2(188.57,109.5) v2(188.7,1.98) v2(188.9,116.91) v2(189.15,109.5) v2(189.23,43.63) v2(189.42,25.02) v2(189.42,23.75) v2(189.42,22.48) v2(189.52,116.29) v2(189.8,121.82) v2(189.97,1.98) v2(190.37,53.98) v2(190.89,24.07) v2(191.07,121.82) v2(191.24,1.98) v2(191.88,110.87) v2(191.88,110.27) v2(192.34,121.82) v2(192.45,110.86) v2(192.45,110.29) v2(192.51,1.98) v2(192.57,25.02) v2(192.57,23.75) v2(192.57,22.48) v2(193.31,116.97) v2(193.36,109.82) v2(193.61,121.82) v2(193.78,1.98) v2(193.93,117.59) v2(193.93,116.35) v2(193.99,109.86) v2(194.37,120.4) v2(194.55,116.97) v2(194.88,121.82) v2(194.95,120.97) v2(194.95,120.4) v2(194.93,25.02) v2(194.93,23.75) v2(195.05,1.98) v2(195.52,120.97) v2(195.52,120.4) v2(196.09,120.97) v2(196.09,120.4) v2(196.15,121.82) v2(196.32,1.98) v2(196.66,120.97) v2(196.66,120.4) v2(197.23,120.97) v2(197.23,120.4) v2(197.42,121.82) v2(197.59,1.98) v2(197.8,120.97) v2(197.8,120.4) v2(198.38,120.97) v2(198.38,120.4) v2(198.48,90.77) v2(198.61,25.02) v2(198.61,23.75) v2(198.61,22.48) v2(198.69,121.82) v2(198.95,120.97) v2(198.86,1.98) v2(199.42,95.58) v2(199.84,96.03) v2(199.96,121.82) v2(200.13,1.98) v2(201,25.02) v2(201,23.75) v2(201,22.48) v2(201.23,121.82) v2(201.4,104.93) v2(201.4,104.34) v2(201.4,103.76) v2(201.4,103.18) v2(201.4,1.98) v2(201.87,89.22) v2(202.5,121.82) v2(202.65,24.71) v2(202.65,24.07) v2(202.67,1.98) v2(202.88,55.69) v2(203.71,106.83) v2(203.71,106.25) v2(203.77,121.82) v2(203.84,87.63) v2(203.92,1.75) v2(204.49,0.61) v2(204.68,25.02) v2(205.04,121.82) v2(205.74,0.43) v2(206.24,5.04) v2(206.31,121.82) v2(206.44,4.06) v2(206.49,6.09) v2(206.95,88.93) v2(207.01,0.43) v2(207.58,121.82) v2(208.03,29.69) v2(208.28,0.43) v2(208.54,87.3) v2(208.85,121.82) v2(208.92,120.91) v2(209.11,65.52) v2(209.49,50.1) v2(209.55,120.91) v2(209.55,0.43) v2(210.12,121.82) v2(210.14,6.08) v2(210.09,4.01) v2(210.23,24.97) v2(210.23,23.69) v2(210.23,22.31) v2(210.41,4.99) v2(210.82,0.43) v2(211.39,121.82) v2(212.08,24.9) v2(212.08,22.23) v2(212.09,0.43) v2(212.29,112.82) v2(212.47,114.45) v2(212.66,121.82) v2(212.89,112.81) v2(212.86,112.23) v2(213.06,114.45) v2(213.11,29.29) v2(213.36,0.43) v2(213.47,112.81) v2(213.45,112.22) v2(213.64,114.45) v2(213.74,120.91) v2(213.93,121.82) v2(213.99,29.25) v2(214.06,112.81) v2(214.05,112.22) v2(214.14,25.04) v2(214.23,114.45) v2(214.16,22.39) v2(214.3,93.56) v2(214.38,120.91) v2(214.64,112.81) v2(214.64,112.21) v2(214.63,0.43) v2(215.01,120.91) v2(215.2,121.82) v2(215.29,112.82) v2(215.52,12.19) v2(215.9,112.81) v2(215.9,0.43) v2(216.38,25.08) v2(216.38,23.81) v2(216.38,22.57) v2(216.47,121.82) v2(217.17,0.43) v2(217.74,121.82) v2(217.68,12.19) v2(218.15,25.65) v2(218.15,23.75) v2(218.44,0.43) v2(218.63,101.41) v2(219.01,121.82) v2(219.71,0.43) v2(220.28,121.82) v2(220.32,108.07) v2(220.75,24.87) v2(220.72,23.33) v2(220.98,0.43) v2(221.55,121.82) v2(222.12,108.14) v2(222.25,0.43) v2(222.65,22.25) v2(222.65,25.08) v2(222.65,23.71) v2(222.82,121.82) v2(223.33,76.96) v2(223.52,0.43) v2(224.09,121.82) v2(224.41,70.61) v2(224.79,0.43) v2(225.36,121.82) v2(225.55,66.41) v2(225.87,118.56) v2(225.95,90.08) v2(226.06,0.43) v2(226.26,25.57) v2(226.26,24.05) v2(226.26,22.53) v2(226.45,118.56) v2(226.63,121.82) v2(227.33,0.43) v2(227.9,121.82) v2(228.1,119.86) v2(228.6,6.61) v2(228.6,0.43) v2(228.73,119.86) v2(228.83,25.07) v2(229.13,121.5) v2(229.49,6.61) v2(229.87,0.43) v2(230.28,120.97) v2(230.57,119.6) v2(230.58,119.01) v2(230.6,25.38) v2(230.6,23.48) v2(231.14,0.43) v2(231.55,120.97) v2(232.37,25.08) v2(232.37,23.81) v2(232.37,22.54) v2(232.41,0.43) v2(232.69,14.02) v2(232.82,120.97) v2(233.43,8.51) v2(233.68,0.43) v2(234.08,120.76) v2(234.45,119.55) v2(234.51,14.03) v2(234.66,25.08) v2(234.66,23.81) v2(234.66,22.54) v2(234.95,0.43) v2(235.31,118.6) v2(236.22,0.43) v2(236.44,24.13) v2(236.44,22.23) v2(236.48,118.11) v2(236.48,14.03) v2(237.49,0.43) v2(237.75,118.07) v2(237.89,25.08) v2(237.89,23.81) v2(237.89,22.54) v2(238.76,0.43) v2(239.01,118.11) v2(239.49,11.98) v2(240.03,0.43) v2(240.19,118.6) v2(240.18,25.08) v2(240.18,23.81) v2(240.18,22.54) v2(240.76,11.98) v2(241.04,119.54) v2(241.17,29.69) v2(241.3,0.43) v2(241.42,120.75) v2(241.38,11.98) v2(241.56,114.94) v2(241.7,25.4) v2(241.7,23.5) v2(242.01,11.98) v2(242.11,121.82) v2(242.57,0.43) v2(243.38,121.82) v2(243.52,55.12) v2(243.48,25.08) v2(243.48,23.81) v2(243.56,113.03) v2(243.71,45.85) v2(243.84,0.43) v2(243.92,115.49) v2(243.92,114.89) v2(244.1,112.73) v2(244.44,107.28) v2(244.41,55.12) v2(244.58,114.12) v2(244.65,121.82) v2(244.7,112.75) v2(245.07,107.09) v2(245.11,0.43) v2(245.17,55.09) v2(245.54,114.91) v2(245.54,114.3) v2(245.66,107.09) v2(245.78,104.75) v2(245.77,25.08) v2(245.77,23.81) v2(245.77,22.54) v2(246.09,75.55) v2(246.11,72.4) v2(246.3,121.82) v2(246.41,114.25) v2(246.7,1.63) v2(246.84,119.8) v2(246.91,84.58) v2(246.86,2.99) v2(247.02,121.17) v2(247.32,62.42) v2(247.29,24.13) v2(247.29,22.23) v2(247.65,118.35) v2(248.07,76.51) v2(248.11,71.5) v2(248.81,25.08) v2(248.81,22.54) v2(249.15,118.1) v2(249.53,3.48) v2(249.91,99.27) v2(249.93,98.05) v2(249.9,96.48) v2(249.93,95.61) v2(250.03,72.45) v2(249.98,1.05) v2(250.06,75.49) v2(250.17,2.27) v2(250.25,118.85) v2(250.38,121.45) v2(250.53,120.3) v2(250.86,1.68) v2(251.07,120.97) v2(251.07,119.7) v2(251.07,117.16) v2(251.07,115.89) v2(251.07,114.62) v2(251.07,113.35) v2(251.07,112.08) v2(251.07,110.81) v2(251.07,109.54) v2(251.07,108.27) v2(251.07,107) v2(251.07,105.73) v2(251.07,104.46) v2(251.07,103.19) v2(251.07,101.92) v2(251.07,100.65) v2(251.07,99.38) v2(251.53,98.19) v2(252.23,2.23) v2(252.57,97.46) v2(252.57,96.19) v2(252.57,94.92) v2(252.57,93.65) v2(252.57,92.38) v2(252.57,91.11) v2(252.57,89.84) v2(252.57,88.57) v2(252.57,87.3) v2(252.57,86.03) v2(252.57,84.76) v2(252.57,83.49) v2(252.57,82.22) v2(252.57,80.95) v2(252.57,79.68) v2(252.57,78.41) v2(252.57,77.14) v2(252.57,75.87) v2(252.57,74.6) v2(252.57,73.33) v2(252.57,72.06) v2(252.57,70.79) v2(252.57,69.52) v2(252.57,68.25) v2(252.57,66.98) v2(252.57,65.71) v2(252.6,64.44) v2(252.68,63.17) v2(252.82,61.91) v2(253.01,60.65) v2(253.24,59.41) v2(253.32,16.55) v2(253.53,58.17) v2(253.5,2.23) v2(253.87,56.95) v2(254.1,15.37) v2(254.25,55.74) v2(254.69,54.54) v2(254.77,2.23) v2(255.17,53.37) v2(255.7,52.21) v2(255.87,20.44) v2(256.04,2.23) v2(256.28,51.08) v2(256.46,39.64) v2(256.48,39.06) v2(256.9,49.97) v2(256.88,44.74) v2(257.31,2.23) v2(257.56,48.89) v2(258.23,22.14) v2(258.27,47.84) v2(258.57,19.18) v2(258.58,2.23) v2(258.68,3.3) v2(259.02,46.81) v2(259.28,3.32) v2(259.81,45.82) v2(259.85,2.23) v2(260.15,34.19) v2(260.17,35.38) v2(260.17,34.77) v2(260.65,44.86) v2(260.81,35.38) v2(260.81,34.8) v2(261.12,2.23) v2(261.51,43.93) v2(262.11,17.19) v2(262.42,43.04) v2(262.39,2.23) v2(262.76,17.18) v2(262.99,3.26) v2(263.36,42.19) v2(263.66,2.23) v2(264.34,41.38) v2(264.68,16.03) v2(264.93,2.23) v2(265.34,40.6) v2(265.81,20.51) v2(265.81,15.67) v2(266.2,2.23) v2(266.38,39.87) v2(266.38,20.41) v2(266.83,16.79) v2(267.44,39.18) v2(267.47,2.23) v2(268.54,38.53) v2(268.74,2.23) v2(269.66,37.93) v2(270.01,2.23) v2(270.8,37.37) v2(271.28,2.23) v2(271.96,36.86) v2(272.55,2.23) v2(273.14,36.4) v2(273.66,29.92) v2(273.66,29.34) v2(273.82,2.23) v2(274.18,28.69) v2(274.18,28.06) v2(274.34,35.99) v2(274.26,29.92) v2(274.26,29.34) v2(274.74,28.52) v2(274.74,27.93) v2(275.09,2.23) v2(275.34,27.95) v2(275.36,28.54) v2(275.56,35.62) v2(275.71,5.56) v2(276.04,28.54) v2(275.97,27.95) v2(276.36,2.23) v2(276.61,28.56) v2(276.79,35.3) v2(276.84,29.16) v2(277.63,2.23) v2(278.03,35.04) v2(278.26,5.84) v2(278.9,2.23) v2(279.28,34.82) v2(280.17,2.23) v2(280.54,34.66) v2(281.44,2.23) v2(281.81,34.54) v2(282.71,2.23) v2(283.08,34.48) v2(283.98,2.23) v2(284.35,34.47) v2(285.17,32.72) v2(285.25,2.23) v2(285.62,34.47) v2(286.52,2.23) v2(286.89,34.47) v2(287.21,27.24) v2(287.66,27.62) v2(287.82,30.58) v2(287.82,29.69) v2(287.79,2.23) v2(288.16,34.47) v2(288.29,30.1) v2(288.71,30.58) v2(288.71,29.69) v2(289.06,2.23) v2(289.43,34.47) v2(290.33,2.23) v2(290.7,34.47) v2(291.6,2.23) v2(291.97,34.47) v2(292.87,2.23) v2(293.24,34.47) v2(293.75,25.78) v2(294.14,2.23) v2(294.51,34.47) v2(295.41,2.23) v2(295.78,34.52) v2(296.68,2.23) v2(297.04,34.61) v2(297.95,2.23) v2(298.3,34.76) v2(299.22,2.23) v2(299.56,34.96) v2(300.49,2.23) v2(300.8,35.21) v2(301.76,2.23) v2(302.04,35.51) v2(303.03,2.23) v2(303.26,35.86) v2(304.3,2.23) v2(304.46,36.26) v2(305.57,2.23) v2(305.65,36.71) v2(306.82,37.2) v2(306.84,2.23) v2(307.97,37.74) v2(308.11,2.23) v2(309.21,38.39) v2(309.38,2.23) v2(310.31,39.03) v2(310.65,2.23) v2(311.38,39.71) v2(311.92,2.23) v2(312.42,40.43) v2(313.19,2.23) v2(313.53,41.06) v2(314.46,2.23) v2(314.8,41.06) v2(315.73,2.23) v2(316.07,41.06) v2(316.12,29.08) v2(317,2.23) v2(317.34,41.06) v2(317.64,29.08) v2(318.27,2.23) v2(318.39,8.48) v2(318.39,7.9) v2(318.61,41.06) v2(318.97,8.48) v2(318.97,7.9) v2(318.97,7.32) v2(319.54,2.23) v2(319.56,8.48) v2(319.83,41.4) v2(320.04,47.73) v2(320.04,46.46) v2(320.04,45.19) v2(320.04,43.92) v2(320.04,42.65) v2(320.14,8.48) v2(320.42,32.64) v2(320.46,48.93) v2(320.73,8.48) v2(320.81,2.23) v2(321.12,50.01) v2(321.31,8.48) v2(321.61,36.66) v2(321.61,35.54) v2(321.61,34.43) v2(321.74,51.12) v2(321.69,41.72) v2(321.9,8.48) v2(322.11,51.84) v2(322.08,2.23) v2(322.38,22.18) v2(322.48,8.48) v2(322.66,52.99) v2(322.73,36.66) v2(322.73,35.54) v2(322.73,34.43) v2(323.04,30.35) v2(322.96,22.18) v2(323.06,8.48) v2(323.16,54.15) v2(323.35,2.23) v2(323.55,22.18) v2(323.61,55.34) v2(323.65,8.48) v2(323.85,36.66) v2(323.85,35.54) v2(323.85,34.43) v2(323.91,41.72) v2(324.13,22.18) v2(324.23,22.91) v2(324.23,8.48) v2(324.29,56.41) v2(324.37,27.91) v2(324.62,2.23) v2(324.71,22.18) v2(324.82,22.91) v2(324.82,8.48) v2(325.31,63.28) v2(325.26,62.01) v2(325.3,22.18) v2(325.39,118.76) v2(325.39,117.49) v2(325.39,116.22) v2(325.39,114.95) v2(325.39,113.68) v2(325.39,112.41) v2(325.39,111.14) v2(325.39,109.87) v2(325.39,108.6) v2(325.39,107.33) v2(325.39,106.06) v2(325.39,104.79) v2(325.39,103.52) v2(325.39,102.25) v2(325.39,100.98) v2(325.39,99.71) v2(325.39,98.44) v2(325.39,97.17) v2(325.39,95.9) v2(325.39,94.63) v2(325.39,93.36) v2(325.39,92.09) v2(325.39,90.82) v2(325.39,89.55) v2(325.39,88.28) v2(325.39,87.01) v2(325.39,85.74) v2(325.39,84.47) v2(325.39,83.2) v2(325.39,81.93) v2(325.39,80.66) v2(325.39,72.17) v2(325.41,70.9) v2(325.41,69.63) v2(325.4,68.36) v2(325.42,67.09) v2(325.4,65.82) v2(325.36,64.55) v2(325.4,22.91) v2(325.4,11.41) v2(325.4,10.82) v2(325.4,10.24) v2(325.4,9.65) v2(325.4,9.07) v2(325.4,8.48) v2(325.5,120.02) v2(325.52,56.72) v2(325.63,78.14) v2(325.56,74.7) v2(325.73,50.24) v2(325.88,22.18) v2(325.89,2.23) v2(326.04,23.5) v2(326.04,22.91) v2(325.98,11.41) v2(325.98,10.82) v2(325.98,10.24) v2(325.98,9.65) v2(325.98,9.07) v2(325.98,8.48) v2(325.98,7.9) v2(325.98,7.32) v2(325.98,6.73) v2(326.11,61.07) v2(326.48,57.56) v2(326.57,22.7) v2(326.74,120.27) v2(326.82,74.74) v2(326.81,60.01) v2(326.91,78.13) v2(326.94,58.74) v2(327.15,22.7) v2(327.16,2.23) v2(327.74,22.7) v2(327.86,120.87) v2(327.94,77.19) v2(327.93,75.65) v2(328.32,22.7) v2(328.43,2.23) v2(328.55,81.28) v2(328.93,79.48) v2(328.85,72.84) v2(328.85,71.09) v2(328.87,68.54) v2(328.87,67.96) v2(328.87,67.37) v2(328.91,22.7) v2(329.09,121.17) v2(329.7,2.23) v2(329.82,64.26) v2(329.79,61.29) v2(330.36,121.17) v2(330.68,81.69) v2(330.81,79.76) v2(330.97,2.23) v2(331.37,74.48) v2(331.36,72.7) v2(331.52,41.05) v2(331.63,121.17) v2(331.9,71.1) v2(332.11,42.67) v2(332.24,2.23) v2(332.83,34.5) v2(332.9,121.17) v2(333.24,19.78) v2(333.51,2.23) v2(333.65,20.27) v2(333.93,19.75) v2(333.99,20.9) v2(334.17,121.17) v2(334.25,64.64) v2(334.26,20.27) v2(334.37,118.06) v2(334.54,19.76) v2(334.72,116.46) v2(334.68,34.55) v2(334.78,2.23) v2(334.93,20.25) v2(335.16,19.7) v2(335.34,115.32) v2(335.44,121.17) v2(335.43,18.32) v2(335.54,20.25) v2(335.77,19.7) v2(335.84,19.11) v2(336.01,1.91) v2(336.05,18.33) v2(336.2,20.15) v2(336.71,121.17) v2(336.81,20.15) v2(336.83,18.33) v2(336.83,0.93) v2(337.05,19.62) v2(337.15,18.81) v2(337.44,20.06) v2(337.43,18.31) v2(337.92,114.56) v2(337.88,20.46) v2(338.03,18.32) v2(338.1,19.89) v2(338.1,0.93) v2(338.49,20.46) v2(338.63,18.34) v2(338.71,19.9) v2(338.72,19.31) v2(338.84,82.11) v2(338.82,21.04) v2(338.87,78.08) v2(338.87,76.81) v2(338.87,75.54) v2(338.87,74.27) v2(338.87,73) v2(338.87,71.73) v2(338.87,70.46) v2(338.87,69.19) v2(338.86,38.71) v2(338.86,36.48) v2(339.13,121.17) v2(339.24,87.48) v2(339.33,19.53) v2(339.36,33.82) v2(339.37,0.93) v2(339.47,99.32) v2(339.65,98.6) v2(339.92,115.15) v2(339.98,37.59) v2(340.25,87.36) v2(340.51,98.12) v2(340.51,97.49) v2(340.64,0.93) v2(340.66,65.97) v2(341.01,80.93) v2(341.1,116.6) v2(341.1,38.71) v2(341.1,36.48) v2(341.35,120.47) v2(341.94,119.2) v2(341.93,65.97) v2(341.89,60.83) v2(341.91,0.93) v2(342.28,80.93) v2(343.2,65.97) v2(343.18,0.93) v2(343.35,118.71) v2(343.55,80.93) v2(343.78,20.8) v2(344.4,21.43) v2(344.4,20.8) v2(344.4,20.18) v2(344.45,0.93) v2(344.47,65.97) v2(344.55,119.36) v2(344.78,121.99) v2(344.82,80.93) v2(344.93,82.11) v2(344.94,64.69) v2(344.96,120.71) v2(345.02,20.8) v2(345.38,122.86) v2(345.74,65.97) v2(345.72,0.93) v2(345.97,39.34) v2(346.09,80.93) v2(346.6,39.37) v2(346.58,38.04) v2(346.79,5.11) v2(346.84,1.91) v2(346.98,122.87) v2(347.22,38.04) v2(348.03,82.75) v2(348.03,5.54) v2(348.11,1.65) v2(348.25,122.87) v2(349.21,82.86) v2(349.28,5.11) v2(349.43,1.93) v2(349.52,122.87) v2(349.9,80.93) v2(349.96,108.73) v2(350.12,106.48) v2(350.11,105.21) v2(350.1,102.86) v2(350.13,101.59) v2(350.08,99.24) v2(350.07,95.62) v2(350.06,92.01) v2(350.14,42.29) v2(350.15,97.97) v2(350.17,94.35) v2(350.18,90.74) v2(350.67,122.32) v2(350.67,121.05) v2(350.67,119.78) v2(350.67,118.51) v2(350.67,113.41) v2(350.67,112.14) v2(350.67,89.57) v2(350.67,88.3) v2(350.67,87.03) v2(350.67,85.76) v2(350.67,84.49) v2(350.67,83.22) v2(350.67,81.95) v2(350.67,65.36) v2(350.67,64.09) v2(350.75,33.54) v2(350.67,32.27) v2(350.67,31) v2(350.67,29.73) v2(350.67,28.46) v2(350.67,27.19) v2(350.67,25.92) v2(350.67,24.65) v2(350.67,23.38) v2(350.67,22.11) v2(350.67,20.84) v2(350.67,19.57) v2(350.67,18.3) v2(350.67,17.03) v2(350.67,15.76) v2(350.67,14.49) v2(350.67,13.22) v2(350.67,11.95) v2(350.67,10.68) v2(350.67,9.41) v2(350.67,8.14) v2(350.67,6.87) v2(350.67,5.6) v2(351.12,108.21) v2(351.18,117.35) v2(351.22,116.08) v2(351.35,104.91) v2(351.33,103.17) v2(351.3,99.57) v2(351.29,95.97) v2(351.27,92.37) v2(351.33,63.01) v2(351.35,106.77) v2(351.37,101.31) v2(351.39,97.71) v2(351.41,94.11) v2(351.75,34.32) v2(352.27,107.65) v2(352.27,104.03) v2(352.27,100.4) v2(352.27,96.78) v2(352.27,93.17) v2(352.27,62.15) v2(352.27,60.88) v2(352.27,59.61) v2(352.27,58.34) v2(352.27,57.07) v2(352.27,55.93) v2(352.27,41.83) v2(352.27,40.56) v2(352.27,39.29) v2(352.27,38.02) v2(352.27,36.75) v2(352.27,35.48) v4(22.84,40.22) v4(25.4,35.69) v4(26.7,35.71) v4(27.35,35.71) v4(28.01,44.08) v4(28.64,35.67) v4(29.31,40.91) v4(31.24,42.83) v4(31.24,38.28) v5(15.27,72.96) v5(20.68,45.87) v5(109.67,94.37) v5(117.29,57.41) v5(118.26,57.74) v5(138.18,110.69) v5(143.71,116.5) v5(149.42,117.32) v5(163.68,99.54) v5(165.27,100.22) v5(200.1,93.98) v5(200.53,103.18) v5(215.41,113.95) v5(231.14,118.89) v5(261.33,35.05) v5(266.1,19.67)
