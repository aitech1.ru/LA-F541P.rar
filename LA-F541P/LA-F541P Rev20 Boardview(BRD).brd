# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_RTCRST#_R: length 3.2
  TOP w0.14: v1(174.79,11.18) 174.79,10.4 RT1133.2 175.49,10.16 175.87,9.78 QR104.1
PCH_RTCX1: length 9.1
  BOTTOM w0.089: UH2.BA49 75.34,7.67 73.33,7.67
  BOTTOM w0.14: 73.33,7.67 72.57,6.91 72.02,6.91 71.23,6.12 70.97,6.12 70.44,5.59 RH70.1 70.36,4.88 CH45.1 70.18,3.74 YH1.1
PCH_RTCX2: length 8.6
  BOTTOM w0.089: 73.56,7.44 73.6,7.48 75.12,7.48 75.31,7.29 75.85,7.29 UH2.BA48
  BOTTOM w0.14: YH1.2 71.17,3.61 CH46.1 71.27,4.8 RH70.2 71.27,5.68 72.16,6.56 72.68,6.56 73.56,7.44
PCH_RTD3_USB_PWR_EN: length 124.5
  TOP w0.089: v2(90.35,7.76) 90.35,7.66 v1(89.84,7.15)
  TOP w0.14: RT5841.1 25.22,51.17 25.12,51.07 v2(25.12,50.28)
  IN1 w0.076: 73.28,12.1 74.31,11.08 75.42,11.08 76.47,10.02 78.83,10.02 79.07,9.79 79.07,9.34 78.87,9.14 78.87,8.15 78.43,7.71 78.43,7.31 78.58,7.16 78.77,7.16 79.25,6.69 79.25,6.56 79.42,6.38 79.42,6.38 79.49,6.31 84.37,6.31 84.5,6.44 87.23,6.44 87.7,6.91 87.7,8.36 88.03,8.68 89.15,8.68 90.07,7.76 v2(90.35,7.76)
  IN1 w0.089: 27.33,46.36 27.33,45.96 27.82,45.47 28.45,45.47 29.18,44.73 29.18,43.85 28.97,43.64 28.97,43.02 29.87,42.12 30.12,42.12 31.47,40.77 31.47,38.69 32.51,37.65 32.51,35.85 33.37,35 33.37,34.8 v2(33.31,34.74)
  IN1 w0.099: v6(58.29,18.8) 58.29,18.63 57.72,18.06 57.72,16.84 58.2,16.37 58.2,15.1 58.45,14.85 59.23,14.85 61.35,12.73 61.35,12.61 62.19,11.77 62.19,10.6 61.68,10.1 61.68,8.84 61.88,8.65 61.88,7.82 62.12,7.58 64.79,7.58 66.46,9.25 67.01,9.25 67.19,9.07 67.51,9.07 68.63,7.94 68.63,5.83 68.87,5.59 68.87,5.36 69.33,4.9 70.54,4.9 71.61,5.97 71.61,11.33 72.39,12.11 73.27,12.11 73.28,12.1 ; v2(25.12,50.28) 25.62,49.79 25.62,49.32 26.93,48.01 26.93,47.59 27.33,47.19 27.33,46.36
  IN4 w0.089: 33.66,34.35 33.53,34.35 33.31,34.58 v2(33.31,34.74)
  IN4 w0.091: v6(58.29,18.8) 58.29,19.34 57.25,20.38 57.25,24.77 59.35,26.87 59.35,31.42 57.79,32.98 45.15,32.98 43.78,34.35 33.66,34.35
  BOTTOM w0.089: v2(90.35,7.76) 90.32,7.74 90.32,7.55 90.38,7.49 90.38,6.91 90.75,6.54 UH2.BC17
PCH_SLP_LAN#: length 2.8
  BOTTOM w0.089: T20.1 80.03,2.71 80.03,3.68 79.91,3.8 79.91,4.78 80.13,5 UH2.BF40
PCH_SMB_ALERT#: length 2.8
  TOP w0.089: RH505.2 87.27,4.88 86.65,4.26 v2(86.6,4.26)
  BOTTOM w0.089: v2(86.6,4.26) 86.65,4.32 86.65,4.87 86.95,5.16 86.95,5.23 87.25,5.54 UH2.BE25
PCH_SMBCLK: length 341.3
  TOP w0.14: v2(238.89,47.63) 239.11,47.4 239.11,47.08 239,46.97 237.48,46.97 237.36,47.08 UF1.1 ; RH463.2 110.36,9.49 110.17,9.3 110.17,8.88 v2(110.18,8.88) ; v2(172.38,10.9) 172.48,11 172.48,11.4 172.82,11.74 172.82,20.93 173.43,21.54 173.43,22.13 173.93,22.62 174.02,22.62 v2(174.25,22.85) ; JXDP.53 129.28,99.01 129.82,99.55 130.31,99.55 130.73,99.98 133.39,99.98 137.38,95.99 137.38,91.57 137.82,91.13 137.82,88.84 v2(137.93,88.73)
  IN1 w0.089: 134.87,84.35 134.88,84.36 134.88,84.37 134.97,84.45 134.97,84.46 137.22,86.71 137.23,86.71 137.43,86.92 137.43,87.22 137.44,87.23
  IN1 w0.099: v2(174.25,22.85) 174.03,22.63 173.89,22.63 173.41,22.15 173.41,21.95 172.97,21.51 161.49,21.51 161.14,21.86 161.14,25.75 159.82,27.07 158.98,27.07 157.53,28.52 155.94,28.52 155.41,29.05 155.41,30.09 154.33,31.16 146.64,31.16 132.28,45.52 132.28,64.35 131.12,65.52 131.12,66 129.9,67.22 129.9,74.85 132.69,77.64 132.69,78.97 134.4,80.68 134.4,83.88 134.87,84.35 ; v2(137.93,88.73) 137.74,88.53 137.74,88.14 137.44,87.84 137.44,87.23
  IN3 w0.091: v2(248.71,29.47) 248.71,27.18 248.6,27.08 248.35,27.08 247.87,26.59 247.87,21.38 247.57,21.08 231.01,21.08 230.7,20.77 227.14,20.77 226.38,20 203.9,20 202.67,21.24 185.6,21.24 184.9,21.93 184.9,22.93 184.51,23.32 183.8,23.32 183.02,22.54 175.18,22.54 175.07,22.66 174.44,22.66 v2(174.25,22.85)
  IN6 w0.099: v2(110.18,8.88) 110.06,8.75 110.06,8.28 111.38,6.96 114.28,6.96 114.57,7.25 114.57,8.84 115.4,9.68 118.31,9.68 119.38,10.74 122,10.74 122.76,11.5 124.12,11.5 125.1,12.49 131.21,12.49 131.97,11.72 134.67,11.72 135.46,12.52 137.7,12.52 138.78,11.44 141.75,11.44 142.8,10.39 146.61,10.39 147.27,9.73 147.6,9.73 149.12,8.21 151.54,8.21 152.19,8.85 163.36,8.85 164.08,9.58 169.26,9.58 170,10.32 172.21,10.32 172.5,10.6 172.5,10.78 v2(172.38,10.9)
  BOTTOM w0.127: JDIMM1.253 172.38,26.93
  BOTTOM w0.14: v2(110.18,8.88) 110.18,9.02 109.65,9.54 109.65,10.34 110.13,10.81 QH4.1 ; JDIMM2.253 248.68,29.44 v2(248.71,29.47) 248.71,29.97 242.57,36.1 242.57,40.34 241.91,41 239.21,41 235.55,44.65 235.55,47.39 236.3,48.14 236.93,48.14 237.57,48.78 239.16,48.78 239.32,48.62 239.32,47 239.05,46.73 236.52,46.73 236.4,46.85 236.4,47.03 236.54,47.17 238.79,47.17 238.89,47.28 v2(238.89,47.63) ; 172.38,26.93 174.25,25.05 v2(174.25,22.85)
PCH_SMBDATA: length 341.3
  TOP w0.14: v2(137.34,88.73) 137.42,88.81 137.42,90.97 136.98,91.41 136.98,95.82 133.22,99.58 130.89,99.58 130.47,99.16 129.98,99.16 129.44,98.62 129.35,98.62 129.24,98.51 JXDP.51 ; v2(109.59,8.88) 109.78,9.06 109.78,9.59 RH462.2 ; v2(238.25,47.63) 238.51,47.88 238.51,48.64 238.15,49 UF1.4 ; v2(172.96,10.9) 172.88,10.98 172.88,11.24 173.22,11.58 173.22,20.77 173.82,21.37 173.82,21.96 174.09,22.23 v2(174.29,22.23)
  IN1 w0.089: 137.08,87.06 134.62,84.6
  IN1 w0.099: v2(137.34,88.73) 137.39,88.68 137.38,88.68 137.38,88.29 137.08,87.99 137.08,87.06 ; 134.62,84.6 134.26,84.23 134.05,84.02 134.05,80.83 132.34,79.11 132.34,77.79 129.54,75 129.54,67.07 130.76,65.86 130.76,65.37 131.93,64.21 131.93,45.37 146.49,30.81 154.19,30.81 155.06,29.94 155.06,28.9 155.79,28.17 157.39,28.17 158.84,26.72 159.67,26.72 160.79,25.61 160.79,21.71 161.34,21.16 173.11,21.16 173.76,21.81 173.76,22.01 174.04,22.28 174.24,22.28 v2(174.29,22.23)
  IN3 w0.091: v2(249.66,21.93) 249.86,21.93 249.96,22.03 249.96,25.57 248.79,26.73 248.49,26.73 248.21,26.45 248.21,21.74 248.21,21.31 248.08,21.17 247.69,20.79 231.14,20.79 230.82,20.47 227.26,20.47 226.5,19.71 203.78,19.71 202.55,20.94 185.48,20.94 184.61,21.81 184.61,22.73 184.36,22.98 183.95,22.98 183.19,22.23 175.01,22.23 174.92,22.31 174.37,22.31 v2(174.29,22.23)
  IN6 w0.099: v2(109.59,8.88) 109.6,8.88 109.7,8.77 109.7,8.21 111.25,6.66 114.4,6.66 114.87,7.13 114.87,8.72 115.53,9.38 118.44,9.38 119.45,10.39 122.08,10.39 122.85,11.15 124.27,11.15 125.18,12.07 131.13,12.07 131.83,11.37 134.74,11.37 135.59,12.22 137.58,12.22 138.65,11.14 141.62,11.14 142.67,10.09 146.48,10.09 147.14,9.43 147.48,9.43 149,7.9 151.74,7.9 152.34,8.5 163.51,8.5 164.23,9.22 169.4,9.22 170.15,9.97 172.36,9.97 172.85,10.45 172.85,10.78 v2(172.96,10.9)
  BOTTOM w0.14: v2(174.29,22.23) 173.85,22.23 173.55,21.93 173.55,21.43 172.63,20.51 JDIMM1.254 ; QH4.4 109.13,9.51 109.59,9.05 v2(109.59,8.88) ; JDIMM2.254 248.93,20.53 249.46,21.07 249.46,21.47 249.66,21.67 v2(249.66,21.93) 249.69,21.95 249.69,25 250.73,26.04 250.73,30.16 250.4,30.49 248.74,30.49 242.96,36.26 242.96,40.5 242.08,41.39 239.37,41.39 235.95,44.81 235.95,47.23 236.47,47.74 238.14,47.74 v2(238.25,47.63)
PCH_SPI_CLK: length 60.9
  TOP w0.14: v2(72.68,11.7) 72.49,11.89 v1(72.14,11.89) 71.83,11.58 RH577.2
  IN1 w0.076: 101.98,8.18 101.65,8.51 99.13,8.51 98.52,7.91 96.68,7.91 96.04,8.54 93.75,8.54 92.65,7.45 91.81,7.45 91.14,6.78 89.78,6.78 88.63,5.63 88.09,5.63 87.94,5.78 84.56,5.78 84.48,5.7 78.7,5.7 77.6,6.81 75.49,6.81 73.28,9.02 73.28,9.96
  IN1 w0.099: 101.98,8.18 102.4,7.76 110.08,7.76 111.39,6.45 113.26,6.45 114.15,5.57 v2(114.17,5.57) ; 73.28,9.96 72.69,10.56 72.33,10.56 72.2,10.69 72.2,11.22 v2(72.68,11.7)
  BOTTOM w0.089: UH2.AW47 76.3,9.02 75.68,9.02 75.6,9.09 75.32,9.09
  BOTTOM w0.14: RH5892.1 69.64,12.57 70.61,12.57 71.51,11.67 RP4.1 72.65,11.67 v2(72.68,11.7) 72.76,11.7 73.72,10.74 73.72,10.03 74.31,9.44 74.79,9.44 75.14,9.09 75.32,9.09 ; JSPI1.4 114.07,5.66 v2(114.17,5.57)
PCH_SPI_CLK_R: length 16
  TOP w0.14: v2(62.29,8.04) 62.1,7.85 61.77,7.85 v5(61.76,7.84)
  IN1 w0.099: v2(62.29,8.04) 62.22,8.12 62.22,8.71 63.11,9.61 65.32,9.61 65.55,9.84 68.52,9.84 69.41,10.73 70.16,10.73 70.4,10.49 v2(70.4,9.64)
  BOTTOM w0.089: 71.14,9.84 70.98,9.68 70.44,9.68 70.41,9.64 v2(70.4,9.64)
  BOTTOM w0.14: RP4.8 71.01,11.67 71.41,11.27 71.41,10.11 71.14,9.84 ; v2(62.29,8.04) 61.93,8.04 61.76,7.88 UH8.6
PCH_SPI_CLK_TPM: length 92.4
  TOP w0.14: RE115.1 148.17,10.03 148.13,10.07 v2(147.83,10.07) ; RH577.1 70.69,11.15 70.3,11.15 69.9,11.55 v2(69.81,11.55)
  IN1 w0.076: 101.98,11.51 101.59,11.11 99.91,11.11 99.39,10.59 98.2,10.59 96.96,11.84 96.15,11.84 94.4,13.58 91.89,13.58 91.31,13.01 89.76,13.01 88.8,12.05 86.88,12.05 86.21,11.38 85.61,11.38 85.52,11.47 80.85,11.47 80.69,11.32 79.9,11.32 79.12,10.53 77.26,10.53 76.15,11.64 75.06,11.64 73.59,13.12 73.28,13.12
  IN1 w0.099: v2(69.81,11.55) 70.51,11.55 72.08,13.12 73.28,13.12 ; v2(147.83,10.07) 147.64,9.88 147.07,9.88 146.57,10.38 139.08,10.38 138.49,10.97 136.84,10.97 136.74,11.08 136.74,11.34 136.64,11.44 136.47,11.44 136.34,11.32 136.34,11.05 136.27,10.97 136.03,10.97 135.97,11.04 135.97,12.42 135.89,12.5 135.65,12.5 135.56,12.41 135.56,11.43 135.45,11.32 135.3,11.32 135.18,11.43 135.18,12.33 135.06,12.45 134.9,12.45 134.78,12.33 134.78,11.95 134.67,11.83 132.53,11.83 131.89,12.47 129.33,12.47 128.65,13.15 123.13,13.15 122.43,12.45 119.32,12.45 118.62,13.15 113.13,13.15 112.45,12.47 108.38,12.47 107.92,12 104.41,12 103.86,12.55 103.44,12.55 102.83,11.94 102.41,11.94 101.98,11.51
PCH_SPI_CLK_TPM_R: length 3.3
  TOP w0.14: RE115.2 149.23,9.72 149.52,9.42 C135.1 149.76,9.27 v1(150.32,8.71) 150.53,8.5 U32.19
PCH_SPI_CS#0: length 64.1
  TOP w0.089: v2(74.13,8.73) v5(73.53,8.73)
  IN3 w0.089: 73.28,8.41 73.81,8.41 v2(74.13,8.73)
  IN3 w0.091: v2(67.46,7.03) 67.66,7.22 67.66,7.72 68.01,8.08 69.7,8.08 70.03,7.75 71.27,7.75 71.93,8.41 73.28,8.41
  IN5 w0.089: v2(74.13,8.73) 74.62,9.22 75.31,9.22 75.91,8.62 75.91,7.61 76.68,6.83 78.66,6.83 79.73,5.77 85.64,5.77 86.27,5.14 89.35,5.14 89.77,5.57 93.48,5.57 93.71,5.34 96.22,5.34 96.95,4.61 98.88,4.61 99.33,4.17 100.6,4.17 101.72,5.28 101.72,5.74 101.98,6.01
  IN5 w0.099: 101.98,6.01 102.35,6.38 104.04,6.38 105.62,4.8 112.52,4.8 113.16,5.44 113.16,5.5 v2(113.12,5.54)
  BOTTOM w0.089: 73.28,9.3 73.34,9.3 73.9,8.73 v2(74.13,8.73) 74.13,8.71 74.52,8.33 76.31,8.33 76.52,8.12 UH2.AY47
  BOTTOM w0.14: UH8.1 68.46,10.42 67.87,9.83 67.87,7.94 67.65,7.72 67.65,7.22 v2(67.46,7.03) ; v2(113.12,5.54) 113.26,5.54 113.57,5.85 JSPI1.5 ; RH74.2 71.84,9.4 72.78,9.4 72.89,9.3 73.28,9.3 73.28,9.3
PCH_SPI_CS#1: length 57.1
  IN6 w0.089: 101.98,6.79 101.16,6.79 101.03,6.92 100.36,6.92 100.11,6.66 99.46,6.66 99.08,6.28 94.94,6.28 94.77,6.46 93.36,6.46 93.24,6.58 93.24,6.97 93.08,7.13 92.69,7.13 92.34,6.78 92.34,6.56 92.17,6.39 91.44,6.39 91.25,6.2 90.32,6.2 89.42,5.3 87.46,5.3 86.44,6.32 86.44,8.28 86.6,8.43 86.6,9.7 86.07,10.23 85.67,10.23 85.17,9.74 81.75,9.74 81.3,9.28 80.56,9.28 80.38,9.1 80.38,8.97 79.83,8.43 78.98,8.43 78.56,8.85 78.14,8.85 77.85,8.56 77.06,8.56 76.33,9.29 73.87,9.29 v2(73.67,9.49)
  IN6 w0.099: 101.98,6.79 103.16,6.79 103.39,6.56 104.2,6.56 104.2,6.56 105.23,6.56 107.09,4.7 113.41,4.7 113.75,5.04 113.75,5.73 114.08,6.05 115.13,6.05 116.51,7.43 v2(116.51,7.45)
  BOTTOM w0.089: 74.48,9.21 74.73,9.21 75.17,8.78 UH2.AW48
  BOTTOM w0.14: v2(116.51,7.45) 115.95,7.45 115.57,7.06 JSPI1.1 ; 74.48,9.21 73.95,9.21 v2(73.67,9.49)
PCH_SPI_CS#2: length 96.6
  TOP w0.14: RE133.1 v1(147.96,8.38) 147.83,8.38 147.66,8.55 147.66,8.77 147.54,8.89 147.43,8.89 v2(147.37,8.95)
  IN1 w0.076: v2(79.63,10.32) 79.63,10.76 79.81,10.94 80.02,10.94 80.07,10.89 80.07,10.11 80.21,9.97 80.32,9.97 80.38,10.04 80.38,10.29 80.57,10.48 80.91,10.48 80.99,10.56 80.99,11.07 81.07,11.15 81.22,11.15 81.3,11.07 81.3,10.25 81.37,10.18 81.52,10.18 81.6,10.26 81.6,11.07 81.68,11.15 81.83,11.15 81.91,11.07 81.91,10.56 81.98,10.48 82.87,10.48 83.08,10.68 83.08,11.11 83.25,11.28 83.88,11.28 84.02,11.15 84.02,10.67 84.27,10.41 84.78,10.41 84.85,10.49 84.85,11.19 84.93,11.26 85.39,11.26 85.47,11.19 85.47,11.04 85.39,10.96 85.23,10.96 85.15,10.88 85.15,10.73 85.23,10.66 86.13,10.66 87.35,11.88 89.01,11.88 89.89,12.75 95,12.75 96.08,11.67 96.89,11.67 98.16,10.4 101.36,10.4 101.98,11.02
  IN1 w0.099: 101.98,11.02 102.58,11.62 102.75,11.62 102.84,11.53 102.84,11.32 102.29,10.77 102.29,10.71 102.45,10.55 102.7,10.55 103.25,11.1 103.25,11.94 103.51,12.19 103.76,12.19 104.26,11.7 108.09,11.7 108.56,12.16 113.28,12.16 113.44,12.01 115.99,12.01 116.09,12.11 116.09,12.3 115.99,12.4 114.11,12.4 114.01,12.5 114.01,12.7 114.16,12.85 118.22,12.85 119,12.07 122.68,12.07 123.47,12.85 128.52,12.85 129.22,12.16 131.77,12.16 132.4,11.53 134.45,11.53 135.31,10.67 138.33,10.67 139.03,9.97 145.7,9.97 145.81,10.07 146.42,10.07 146.94,9.55 148.48,9.55 148.81,9.22 148.81,9.21 148.93,9.09 149.85,9.09 150,8.95 150,8.69 149.66,8.35 147.88,8.35 147.66,8.57 147.66,8.77 147.54,8.89 147.43,8.89 v2(147.37,8.95)
  BOTTOM w0.089: v2(79.63,10.32) 79.82,10.13 UH2.AT40
PCH_SPI_CS#2_R: length 2.3
  TOP w0.14: U32.20 149.87,8 RE133.2
PCH_SPI_HOLD#: length 61.2
  TOP w0.14: RH576.2 68.02,9.65 RH78.2 67.41,9.18 67.07,8.84 v2(66.84,8.84)
  IN1 w0.099: v2(66.84,8.84) 66.94,8.84 68.4,7.38 68.4,5.74 68.65,5.5 68.65,5.27 69.31,4.6 71.62,4.6 72.62,5.6 v2(72.62,6.12)
  IN3 w0.089: 75.06,5.84 75.28,5.61 78.63,5.61 79.09,6.07 83.21,6.07 83.25,6.03 84.57,6.03 84.97,6.42 85.91,6.42 86.41,5.92 87.67,5.92 88.1,5.48 89.24,5.48 89.87,6.11 91.33,6.11 91.62,5.82 94.1,5.82 94.57,5.35 95.33,5.35 95.65,5.66 98.57,5.66 99.06,6.14 101.15,6.14 101.61,6.6 101.61,7.04 101.98,7.42
  IN3 w0.091: 101.98,7.42 102.08,7.52 105.08,7.52 105.58,8.03 110.08,8.03 110.64,7.47 v2(112.86,7.47) ; 75.06,5.84 74.52,6.38 73.45,6.38 73.24,6.17 72.67,6.17 v2(72.62,6.12)
  BOTTOM w0.089: 73.72,7.18 73.84,7.29 74.75,7.29 74.93,7.11 76.27,7.11 76.33,7.05 76.55,7.05 76.94,7.43 UH2.BA46
  BOTTOM w0.14: 73.72,7.18 72.67,6.12 v2(72.62,6.12) ; v2(112.86,7.47) 112.57,7.19 JSPI1.7
PCH_SPI_HOLD#_R: length 10
  TOP w0.14: v6(67.36,10.94) 67.88,10.94 RH576.1
  BOTTOM w0.14: 60.78,9.15 61.28,9.15 61.62,9.48 61.62,9.9 63.01,11.29 63.01,11.77 63.69,12.46 v1(65.2,12.46) 66.13,11.53 66.76,11.53 v6(67.36,10.94)
PCH_SPI_SI: length 62
  TOP w0.089: v2(78.69,9.63) 78.69,9.44 v1(78.44,9.18) 78.03,8.78 77.52,8.78 RH5860.2 76.8,9.5 RH489.1
  TOP w0.14: v2(72.62,11.04) 72.62,10.94 72.49,10.81 72.49,10.5 72.12,10.13 RH578.2
  IN1 w0.076: 73.28,11.04 73.46,11.04 73.73,10.77 73.73,9.99 74.62,9.11 75.01,9.11 75.28,8.84 77.75,8.84 78.52,9.61 78.65,9.61 78.66,9.63 v2(78.69,9.63) 78.69,9.44 78.65,9.4 78.65,8.17 78.27,7.78 78.27,7.24 78.54,6.97 78.73,6.97 79.08,6.62 79.08,6.49 79.42,6.15 84.44,6.15 84.57,6.27 87.3,6.27 87.87,6.84 87.87,8.14 88.19,8.46 89.07,8.46 90.14,7.39 90.52,7.39 91.28,8.15 91.28,8.26 91.7,8.68 91.8,8.68 92.24,9.12 94.58,9.12 94.99,9.53 95.77,9.53 96.21,9.08 97.82,9.08 98.27,8.62 98.77,8.62 98.99,8.84 101.43,8.84 101.47,8.88 101.98,8.88
  IN1 w0.099: 101.98,8.88 103.51,8.88 104.08,8.31 110.29,8.31 111.56,7.05 115.2,7.05 116.26,6 v2(116.26,5.57) ; 73.28,11.04 v2(72.62,11.04)
  BOTTOM w0.089: v2(78.69,9.63) 78.72,9.66 78.82,9.66 78.99,9.48 UH2.AU41
  BOTTOM w0.14: JSPI1.2 115.07,6.11 115.19,6 115.8,6 116.23,5.57 v2(116.26,5.57) ; v2(72.62,11.04) 72.49,11.17 RP4.2
PCH_SPI_SI_R: length 13.8
  TOP w0.14: v5(63.56,7.8) 62.9,8.46 v2(62.71,8.46)
  IN1 w0.099: v2(69.28,9.77) 69.04,9.53 66.36,9.53 65.46,8.62 63.64,8.62 63.48,8.46 v2(62.71,8.46)
  BOTTOM w0.089: 69.48,10.56 69.71,10.78 70.32,10.78 70.71,11.17 RP4.7
  BOTTOM w0.14: UH8.5 61.52,6.61 62.79,7.88 62.79,8.38 v2(62.71,8.46) ; v2(69.28,9.77) 69.28,10 69.47,10.19 69.47,10.54 69.48,10.56
PCH_SPI_SI_TPM: length 99.4
  TOP w0.14: v2(70.15,12.02) 69.68,12.02 69.36,11.7 69.36,11.16 69.76,10.76 70.18,10.76 70.81,10.13 RH578.1 ; v2(147.75,12.32) 147.75,11.62 147.17,11.03 146.56,11.03 146.31,10.78 v1(146.31,10.26) 146.77,9.8 146.77,8.94 148.34,7.37 RE114.1
  IN2 w0.089: 101.98,11.54 101.21,10.77 101.21,10.68 100.92,10.39 98.68,10.39 97.5,9.21 96.2,9.21 95.95,9.46 95.25,9.46 95.16,9.37 95.16,9.18 94.73,8.76 92.68,8.76 91.59,9.85 90.86,9.85 90.15,10.55 89.53,10.55 88.73,9.75 87.45,9.75 86.96,10.24 86.64,10.24 86.46,10.42 85.65,10.42 85.13,9.89 83.75,9.89 83.16,9.3 80.48,9.3 79.69,8.51 78.87,8.51 78.14,7.78 76.87,7.78 76.33,8.32 73.41,8.32 73.28,8.45
  IN2 w0.099: v2(147.75,12.32) 147.15,11.72 139.57,11.72 136.93,14.35 129.36,14.35 128.64,15.08 123.38,15.08 122.72,15.74 122.16,15.74 121.1,16.8 115.84,16.8 115.57,16.53 113.97,16.53 113.61,16.17 112.18,16.17 109.74,13.73 109.2,13.73 109.02,13.55 106.37,13.55 105.69,12.88 103.32,12.88 101.98,11.54 ; v2(70.15,12.02) 70.42,12.02 71.99,10.44 71.99,9.66 72.27,9.38 72.79,9.38 73.22,8.96 73.22,8.51 73.28,8.45
PCH_SPI_SI_TPM_R: length 2.2
  TOP w0.14: U32.21 150.86,7.5 150.72,7.37 v1(150.41,7.37) RE114.2
PCH_SPI_SO: length 53.1
  TOP w0.089: v2(77.69,8.14) 77.56,8.14 76.81,8.89 75.17,8.89 74.93,9.13 74.62,9.13 73.52,10.23 73.52,10.37 73.39,10.49 v2(73.31,10.49) 73.28,10.47
  TOP w0.14: 73.28,10.47 73.27,10.45 73.27,9.5 73.13,9.36 72.84,9.36 72.75,9.45 72.23,9.45 71.86,9.09 RH579.2
  IN1 w0.076: v2(77.69,8.14) 77.69,7.87 78.03,7.53 78.03,7.18 78.43,6.78 78.69,6.78 78.91,6.56 78.91,6.25 79.21,5.95 88,5.95 88.15,5.8 88.57,5.8 89.71,6.94 90.31,6.94 90.98,7.61 92.26,7.61 93.6,8.95 94.71,8.95 95.08,9.32 95.74,9.32 96.3,8.76 97.75,8.76 98.14,8.38 98.76,8.38 99.06,8.68 101.88,8.68 101.98,8.57
  IN1 w0.099: 101.98,8.57 102.08,8.57 102.6,8.06 110.22,8.06 111.47,6.81 113.5,6.81 114.75,5.56 v2(114.78,5.56)
  BOTTOM w0.089: v2(77.69,8.14) 77.39,7.85 UH2.BA45 ; 73.28,10.49 v2(73.31,10.49)
  BOTTOM w0.14: 73.28,10.49 72.38,10.49 72.2,10.67 RP4.3 ; JSPI1.3 114.57,6.23 114.78,6.02 v2(114.78,5.56)
PCH_SPI_SO_R: length 3.7
  TOP w0.14: v5(69.84,9.61) 69.84,10.24 v2(69.91,10.31)
  BOTTOM w0.089: RP4.6 70.49,10.67 70.13,10.31 v2(69.91,10.31) 69.85,10.25 69.85,9.67 69.61,9.43
  BOTTOM w0.14: 68.78,9.15 69.32,9.15 69.61,9.43
PCH_SPI_SO_TPM: length 99.8
  TOP w0.14: RH579.1 70.92,9.08 70.45,8.61 69.31,8.61 v2(69.22,8.52) ; v6(146.24,9.68) 146.29,9.64 146.29,8.81 147.94,7.15 147.94,6.52 148.39,6.08 v1(148.39,5.41) 148.39,4.95 149.14,4.19 RE113.1
  IN2 w0.089: 93.52,5.36 93.15,5.73 91.37,5.73 91.08,6.02 89.74,6.02 89.03,5.31 88.01,5.31 87.83,5.49 85.51,5.49 85.2,5.8 80.11,5.8 80.01,5.7 79.57,5.7 78.4,4.53 76.15,4.53 75.06,5.61 ; 96.15,5.24 96.34,5.43 100.72,5.43 101.31,6.01
  IN2 w0.099: 93.52,5.36 93.65,5.24 96.15,5.24 ; v6(146.24,9.68) 145.32,8.75 142.82,8.75 139.8,5.74 136.45,5.74 134.84,7.35 134.84,9.82 133.93,10.72 132.07,10.72 131.42,11.37 125.2,11.37 124.78,10.95 119.05,10.95 117.52,12.48 115.76,12.48 113.93,10.66 113.93,8.71 113.37,8.15 112.56,8.15 111.82,7.42 110.57,7.42 109.91,8.08 105.36,8.08 103.67,6.39 101.6,6.39 101.31,6.1 101.31,6.01 ; 75.06,5.61 74.27,6.4 73.53,6.4 73.39,6.54 71.46,6.54 70.29,7.72 70.06,7.72 69.26,8.52 v2(69.22,8.52)
PCH_SPI_SO_TPM_R: length 3.1
  TOP w0.14: U32.24 151.46,6 151.19,5.73 151.19,4.57 v1(150.81,4.19) RE113.2
PCH_SPI_WP#: length 54.9
  TOP w0.14: v2(72.54,8.95) 72.54,8.69 72.11,8.26 RH573.2 ; RH75.2 73.34,11.15 72.84,10.65 72.84,10.21 v2(72.64,10.01)
  IN1 w0.076: 101.98,7.69 101.83,7.85 101.82,7.85 101.32,8.34 99.2,8.34 98.59,7.74 96.59,7.74 96.01,8.32 93.76,8.32 92.72,7.28 91.88,7.28 91.21,6.61 89.85,6.61 88.7,5.47 88.02,5.47 87.87,5.62 84.63,5.62 84.52,5.5 75.99,5.5 75.57,5.92 75.57,6.35 73.28,8.64
  IN1 w0.099: 73.28,8.64 73.03,8.89 72.6,8.89 v2(72.54,8.95) 72.68,9.09 72.68,9.98 v2(72.64,10.01) ; v2(112.54,5.56) 112.54,5.8 112.32,6.02 111.14,6.02 110.51,6.65 105.84,6.65 105.04,7.46 102.22,7.46 101.98,7.69
  BOTTOM w0.089: UH2.AY48 76.05,8.1 74.49,8.1 74.23,8.36 73.96,8.36
  BOTTOM w0.14: JSPI1.6 113.07,6.21 112.54,5.68 v2(112.54,5.56) ; RP4.4 72.29,10.17 72.45,10.01 v2(72.64,10.01) ; 73.96,8.36 73.43,8.89 72.6,8.89 v2(72.54,8.95)
PCH_SPI_WP#_R: length 3.7
  BOTTOM w0.089: RP4.5 70.37,10.17 70.04,9.84 70.04,9.48 69.98,9.42
  BOTTOM w0.14: 69.98,9.42 69.77,9.21 69.77,8.67 v1(69.85,8.59) 69.85,8.45 69.45,8.04 68.94,8.04 UH8.3
PCH_SPI_WP#_XDP: length 169.9
  TOP w0.14: JXDP.60 120.97,100.51 v2(120.97,100.51) ; v2(105.34,48.1) 105.34,44.33 v1(105.95,43.72) 108.53,41.14 108.53,39.84 106.39,37.7 106.39,33.21 103.93,30.75 85.71,30.75 v2(83.31,33.15) ; v2(69.61,7.6) 69.75,7.74 70.42,7.74 70.92,8.23 RH573.1
  IN2 w0.099: v2(60.05,20.99) 60.05,20.46 62.13,18.38 62.13,16.63 62.22,16.55 62.22,14.31 62.72,13.81 62.72,11.35 66.57,7.5 67.19,7.5 67.65,7.97 68.57,7.97 68.9,7.64 69.57,7.64 v2(69.61,7.6)
  IN4 w0.091: v2(120.97,100.51) 120.55,100.09 120.55,95.05 121,94.61 121,93.79 120.74,93.54 120.31,93.54 120.18,93.68 118.24,93.68 118.11,93.55 118.11,93.26 119.18,92.19 121.31,92.19 121.91,91.6 121.91,86.87 123.93,84.86 123.93,72.07 121.7,69.84 121.7,67.97 117.28,63.55 117.28,50.65 116.18,49.55 113.55,49.55 112.77,48.77 106.31,48.77 105.64,48.1 v2(105.34,48.1) ; v2(60.05,20.99) 60.05,21.7 60.38,22.02 61.08,22.02 61.5,22.44 61.5,23.05 64.07,25.63 64.07,27.48 65.95,29.35 72.05,29.35 77.9,35.21 82.44,35.21 83.31,34.34 v2(83.31,33.15)
PCH_SRTCRST#: length 10.2
  TOP w0.14: v2(72.04,5.83) 72.04,5.82 71.81,5.59 RH83.2 71.5,6.15 CH52.1 72.12,6.77 v1(72.77,6.77)
  IN3 w0.089: v2(76.58,6.36) 76.58,6.12 76.25,5.79 75.72,5.79 75.27,6.24 75.27,6.95 74.86,7.37 74.02,7.37 73.78,7.12
  IN3 w0.091: 73.78,7.12 73.18,6.52 72.17,6.52 72.05,6.4 72.05,5.83 v2(72.04,5.83)
  BOTTOM w0.089: UH2.BD46 76.58,6.11 v2(76.58,6.36)
PCH_SYS_PWROK_XDP: length 156.8
  TOP w0.089: RH489.2 74.65,9.5 74.19,9.95 v2(74.19,10.11) 74.07,10.11 73.74,10.44 73.74,10.94 RH493.2
  TOP w0.14: JXDP.47 126.1,97.51 125.55,96.96 v2(125.55,96.58)
  IN2 w0.089: v2(74.19,10.11) 73.79,10.52 73.79,11.97
  IN2 w0.099: v2(70.61,31.75) 70.61,31.45 71.19,30.87 72.89,30.87 74.77,32.75 78.72,32.75 80.57,30.9 82.97,30.9 86.12,34.05 88.1,34.05 91.2,37.15 96.34,37.15 96.58,36.91 103.33,36.91 104.04,36.2 v2(104.6,36.2) ; v2(65.26,22.75) 67.14,20.87 69.22,20.87 70.83,19.26 70.83,18.05 71.21,17.67 71.21,14.79 73.79,12.22 73.79,11.97
  IN4 w0.091: v2(104.6,36.2) 104.9,36.5 107.02,36.5 110.87,40.35 110.87,41.21 112.81,43.14 113.65,43.14 115.07,44.56 118.05,44.56 121.19,47.7 121.19,52.09 120.61,52.68 120.61,53.87 121.16,54.43 121.16,60.08 122.82,61.73 122.82,62.36 127.18,66.73 127.18,80 129.97,82.8 129.97,84.43 129.73,84.67 129.51,84.67 129.13,85.04 129.13,93 v2(125.55,96.58)
  BOTTOM w0.14: v2(125.55,96.58) 125.55,96.34 126.3,95.58 127.53,95.58 128.6,94.51 RH490.2 ; v2(65.26,22.75) 65.37,22.87 65.37,24.55 66.28,25.46 68.63,25.46 69.45,26.27 69.45,30.75 70.45,31.75 v2(70.61,31.75)
PCH_TBT_PERST#: length 25.9
  IN3 w0.089: 20.58,40.2 20.96,39.81 20.96,39.63 22.74,37.85 23.54,37.85 24.47,38.78 24.47,40.08 25.21,40.82 25.21,41.45 26.54,42.78 26.54,42.99 26.06,43.48 v4(26.06,44.08)
  IN3 w0.091: v2(17.08,47.15) 17.65,46.57 17.65,46.17 19.75,44.07 19.75,41.02 20.58,40.2
  BOTTOM w0.089: UT1.L4 26.33,43.8 v4(26.06,44.08)
  BOTTOM w0.14: RT435.2 16.66,48.24 17.08,47.82 v2(17.08,47.15) ; RT435.2 16.51,48.22 16.22,48.22 16,48.01 16,46.78 RT5855.2 ; RT435.2 16.79,48.52 17.15,48.52 v1(17.65,48.01)
PCH_TP_BALL: length 1.3
  TOP w0.089: T4947.1 82.36,11.83 v2(82.1,12.09)
  BOTTOM w0.089: v2(82.1,12.09) 82.36,12.35 UH2.AL35
PCH_TRIGGER: length 131
  TOP w0.14: v2(180.32,58.44) 180.32,60.9 179.58,61.64 RH167.1
  IN3 w0.089: 101.98,13.12 101.12,13.12 100.59,12.59 100.28,12.59 v2(99.9,12.97)
  IN3 w0.091: 101.98,13.12 102.46,13.12 103.67,14.33 105.51,14.33 107.64,16.46 107.64,17.47 v2(107.62,17.49)
  IN6 w0.099: v2(107.62,17.49) 107.97,17.49 110.98,20.5 169.8,20.5 170.38,21.08 174.44,21.08 174.78,21.41 174.78,21.82 176.25,23.29 176.25,26.55 175.52,27.28 175.52,30.92 186.56,41.96 186.56,49.81 182.09,54.28 182.09,55.59 180.32,57.36 v2(180.32,58.44)
  BOTTOM w0.089: v2(99.9,12.97) 99.69,12.97 99.31,12.59 98.74,12.59 98.58,12.75 98.07,12.75 UH2.AK3
PCH_TRIGGER_R: length 20.9
  TOP w0.14: v2(181.72,64.01) 181.37,63.67 180.21,63.67 179.72,63.17 RH167.2
  IN6 w0.089: 181.1,66.75 179.2,68.65 179.2,69.74 178.29,70.65 178.29,75.3 177.23,76.37 174.25,76.37 v2(173.86,75.97)
  IN6 w0.099: v2(181.72,64.01) 181.72,64.09 181.87,64.23 181.87,65.21 181.87,65.98 181.1,66.75
  BOTTOM w0.076: UH1.H23 173.48,76.34 v2(173.86,75.97)
PCH_XDP_CLK_N: length 108.2
  TOP w0.152: v2(126.02,94.64) 126.02,95.25 125.43,95.84 123.93,95.84 123.76,96.01 JXDP.42
  IN4 w0.089: v2(97.49,16.89) 97.41,16.81 97.41,16.68 97.58,16.51 97.79,16.51 97.97,16.69 97.97,22.43 100.46,24.93 100.46,27.79 100.46,27.79 100.46,27.81
  IN4 w0.099: 100.46,27.81 100.46,28.77 97.85,31.37 97.85,33.23 99.76,35.13 99.76,36.53 100.59,37.35 100.59,38.23 100.9,38.55 106.16,38.55 108.49,40.88 108.49,41.79 109.43,42.72 110,42.72 113.67,46.39 116.88,46.39 117.67,47.18 117.67,48.37 118.37,49.06 118.37,56.01 118.99,56.63 118.99,61.14 119.98,62.13 119.98,62.84 120.87,63.72 121.54,63.72 122.5,64.68 122.5,65.36 123.22,66.08 123.22,69.67 124.98,71.43 124.98,84.99 122.72,87.25 122.72,94.24 123.8,95.31 125.58,95.31 125.82,95.07 125.82,94.84 v2(126.02,94.64)
  BOTTOM w0.089: UH2.Y3 98.01,17.74 98.01,17.52 97.49,17.01 v2(97.49,16.89)
PCH_XDP_CLK_P: length 108
  TOP w0.152: JXDP.40 125.3,95.51 125.66,95.14 125.66,94.89 125.42,94.64 v2(125.38,94.64)
  IN4 w0.089: 100.65,27.81 100.65,27.79 100.64,27.79 100.64,24.85 98.15,22.36 98.15,16.62 97.86,16.33 97.46,16.33 97.19,16.6 97.19,16.7 v2(96.93,16.96)
  IN4 w0.099: v2(125.38,94.64) 125.51,94.64 125.63,94.76 125.63,94.99 125.5,95.12 123.88,95.12 122.91,94.16 122.91,87.33 125.17,85.07 125.17,71.36 123.41,69.59 123.41,66 122.69,65.28 122.69,64.6 121.62,63.53 120.95,63.53 120.17,62.76 120.17,62.05 119.18,61.06 119.18,56.55 118.56,55.93 118.56,48.98 117.86,48.29 117.86,47.1 116.96,46.2 113.75,46.2 110.08,42.53 109.51,42.53 108.68,41.71 108.68,40.8 106.24,38.36 100.98,38.36 100.78,38.15 100.78,37.28 99.95,36.45 99.95,35.05 98.05,33.15 98.05,31.45 100.65,28.85 100.65,27.81
  BOTTOM w0.089: v2(96.93,16.96) 96.93,16.97 97.24,17.28 97.39,17.28 97.63,17.52 97.63,17.65 UH2.Y4
PCI_CLK_LPC1: length 3.1
  TOP w0.089: v2(83.8,7.5) 84,7.3 84.39,7.3 v1(84.71,6.98) 85.21,6.48 RH428.1
  BOTTOM w0.089: UH2.BB34 83.12,7.1 83.49,7.48 83.53,7.48 83.55,7.5 v2(83.8,7.5)
PCI_CLK_LPC1_R: length 0.9
  TOP w0.089: T4945.1 84.38,5.55 RH428.2
PCIE_PRX_C_DTX_N5: length 1.9
  BOTTOM w0.152: CR13.2 338.1,34.33 338.1,34.6 338.58,35.08 UR1.8
PCIE_PRX_C_DTX_P5: length 1.9
  BOTTOM w0.152: UR1.7 338.98,35.2 338.91,35.13 338.91,34.95 338.43,34.47 338.43,34.27 CR10.2
PCIE_PRX_C_TTX_N17: length 7.4
  BOTTOM w0.089: 32.65,32.38 32.63,32.4 32.53,32.4 31.87,33.06 31.87,33.31 30.99,34.2 30.5,34.2 30.01,34.69 30.01,35.07 29.79,35.3 UT1.V22
  BOTTOM w0.152: 32.65,32.38 v3(32.8,32.24) 32.98,32.06 34.26,32.06 34.41,32.21 35.08,32.21 35.08,32.21 CT181.2
PCIE_PRX_C_TTX_N18: length 3.3
  BOTTOM w0.089: UT1.P22 28.18,35.07 28.18,35.07 28.19,35.06 28.19,34.52 28.76,33.96 29.3,33.96 29.73,33.53 29.73,33.27 CT180.2
PCIE_PRX_C_TTX_N19: length 3
  BOTTOM w0.089: CT7.2 27.16,33.44 26.77,33.83 26.5,33.83 26.27,34.07 26.27,34.54 26.35,34.63 26.35,35.06 26.34,35.07 26.34,35.07 UT1.K22
PCIE_PRX_C_TTX_N20: length 2.5
  BOTTOM w0.089: CT3.2 24.93,33.27 24.93,33.58 24.51,33.99 24.51,35.06 24.5,35.07 24.5,35.07 UT1.F22
PCIE_PRX_C_TTX_P17: length 7.4
  BOTTOM w0.089: 32.42,32.15 32.4,32.16 32.4,32.26 31.68,32.98 31.68,33.24 30.91,34.01 30.4,34.01 29.79,34.62 UT1.V23
  BOTTOM w0.152: CT179.2 35.22,31.88 34.55,31.88 34.4,31.73 v3(34.14,31.73) 32.84,31.73 32.56,32 32.42,32.15
PCIE_PRX_C_TTX_P18: length 3.3
  BOTTOM w0.089: UT1.P23 27.95,34.92 27.88,34.99 27.79,34.99 27.72,34.91 27.72,34.62 28.65,33.69 29.19,33.69 29.47,33.42 29.47,33.26 CT178.2
PCIE_PRX_C_TTX_P19: length 2.9
  BOTTOM w0.089: UT1.K23 26.11,34.98 26.04,35.05 25.92,35.05 25.87,35.01 25.87,34.63 26,34.5 26,33.96 26.39,33.57 26.66,33.57 26.87,33.35 CT5.2
PCIE_PRX_C_TTX_P20: length 2.5
  BOTTOM w0.089: CT1.2 24.66,33.28 24.66,33.47 24.25,33.88 24.25,34.41 24.04,34.62 24.04,34.91 24.11,34.99 24.2,34.99 24.27,34.92 UT1.F23
PCIE_PRX_DTX_N1: length 320.8
  IN1 w0.107: v2(338.99,85.85) 338.99,85.11 338.66,84.78 331.46,84.78 329.64,82.96 329.64,79.43 330.7,78.38 330.7,75.38 328.19,72.88 328.19,67.13 331.55,63.78 331.55,60.98 330.96,60.39 330.96,56.57 328.42,54.03 328.42,41.24 326.78,39.6 326.78,38.69 324.11,36.01 315.5,36.01 310.39,30.89 310.39,29.69 308.13,27.43 307.6,27.43 305.52,25.35 304.13,25.35 301.71,22.93 294.83,22.93 293.88,21.98 293.88,21.57 292.6,20.28 290.91,20.28 290.67,20.52 288.36,20.52 287.71,19.86 271.38,19.86 270.17,18.66 268.68,18.66 268.52,18.49 266.32,18.49 264.98,17.16 264.98,16.6 265.34,16.24 265.34,15.18 265.14,14.99 264.8,14.99 v2(264.67,14.86)
  IN3 w0.089: 101.94,25.31 101.84,25.41 100.33,25.41 100.18,25.26 99.65,25.26 96.6,22.21 93.88,22.21 92.38,23.71 91.96,23.71 91.84,23.83 v2(91.56,23.83)
  IN3 w0.099: v2(264.67,14.86) 263.85,14.86 263.69,14.71 261.11,14.71 260.53,14.14 257.09,14.14 256.35,13.4 252.99,13.4 251.98,14.41 250.19,14.41 249.16,13.39 242.57,13.39 241.46,14.5 232.56,14.5 231.97,13.91 204.79,13.91 204.49,14.21 201.02,14.21 200.11,15.11 178.94,15.11 178.38,14.55 152.05,14.55 151.87,14.73 144.84,14.73 144.06,15.52 138.57,15.52 138.32,15.76 127.29,15.76 126.8,16.26 124.76,16.26 124.29,15.79 123.12,15.79 122.49,16.42 121.98,16.42 120.72,17.68 117.2,17.68 114.24,20.63 109.48,20.63 108.71,21.4 108.71,22.51 108.01,23.2 108.01,23.72 106.81,24.93 102.45,24.93 102.07,25.31 101.94,25.31
  BOTTOM w0.089: v2(91.56,23.83) 91.35,24.03 UH2.G17
  BOTTOM w0.152: JNGFF1.35 339.05,85.19 338.91,85.33 338.91,85.78 v2(338.99,85.85)
PCIE_PRX_DTX_N5: length 282.1
  IN3 w0.099: v2(334.1,34.52) 334.06,34.52 333.44,33.9 329.18,33.9 327.15,31.88 324.98,31.88 323.69,33.17 315.95,33.17 314.66,34.46 309,34.46 307.31,32.76 305.55,32.76 305.28,32.49 304.62,32.49 301.49,29.36 297.92,29.36 297.72,29.16 297.15,29.16 295.67,27.68 293.51,27.68 290.84,25.01 289.59,25.01 287.93,23.35 285.48,23.35 284.18,22.05 283.57,22.05 279.55,18.03 269.17,18.03 268.73,17.59 261.8,17.59 259.98,15.77 256.94,15.77 255.8,14.64 253.43,14.64 252.47,15.6 249.66,15.6 248.67,14.61 246.38,14.61 245.3,15.69 231.84,15.69 231.33,15.18 205.42,15.18 205.21,15.4 201.73,15.4 200.79,16.33 178.08,16.33 177.49,15.74 152.58,15.74 152.32,16 145.46,16 144.76,16.7 141.78,16.7 139.62,18.86 121.25,18.86 120.78,19.33 117.42,19.33 114.91,21.84 114.91,24.45 112.95,26.4 109.49,26.4 108.21,27.69 106.62,27.69 106.08,27.15 99.86,27.15 99.08,26.37 97.93,26.37 97.31,25.76 97.31,25.41 96.93,25.03 96.93,24.29 96.07,23.43 94.92,23.43 94.26,24.09 94.26,25.37 93.99,25.64 93.53,25.64 93.19,25.98 93.19,27.98 92.96,28.21 91.35,28.21 91,27.86 91,26.34 89.79,25.13 89.79,24.28 89.95,24.12 90.18,24.12 90.27,24.2 v2(90.27,24.34)
  BOTTOM w0.089: UH2.F20 89.68,24.8 89.59,24.7 89.59,24.43 89.67,24.34 89.81,24.34 89.94,24.22 90.14,24.22 v2(90.27,24.34)
  BOTTOM w0.152: v2(334.1,34.52) 333.8,34.22 333.8,33.65 335.35,32.1 338.2,32.1 338.38,32.28 338.38,32.51 337.81,33.07 CR13.1
PCIE_PRX_DTX_N09: length 198.6
  IN1 w0.107: v2(82.07,24.52) 81.93,24.39 81.93,24.21 82.23,23.91 82.51,23.91 82.98,24.37 82.98,24.94 83.76,25.73 85.51,25.73 86.27,26.49 87.49,26.49 90.97,29.97 91.9,29.97 93.8,31.88 104.71,31.88 106.57,33.73 115.45,33.73 117.05,32.14 136.76,32.14 141.69,27.2 142.75,27.2 144.55,25.4 146.92,25.4 148.54,23.78 148.54,22.01 148.77,21.77 150.08,21.77 150.63,21.22 152.19,21.22 152.54,20.88 154.81,20.88 155.63,20.05 156.01,20.05 157.43,18.63 157.43,18.22 158.39,17.27 251.03,17.27 252.9,15.39 253.44,15.39 253.9,14.93 255.69,14.93 256.5,15.74 256.5,16.8 257.96,18.26 257.96,21.28 258.48,21.8 258.6,21.8 v2(258.87,22.08)
  BOTTOM w0.089: UH2.G36 81.88,24.16 81.88,24.34 v2(82.07,24.52)
  BOTTOM w0.152: v2(258.87,22.08) 258.91,22.08 259.11,21.87 259.63,21.87 259.8,22.04 JNGFF2.5
PCIE_PRX_DTX_N10: length 200.4
  IN1 w0.107: v2(81.93,22.94) 82.1,23.11 82.38,23.11 82.7,22.79 82.7,22.63 83.05,22.28 85.51,22.28 86.37,23.14 86.37,24.63 87.37,25.64 87.8,25.64 90.99,28.83 92.08,28.83 94.31,31.06 105.14,31.06 106.52,32.44 115.33,32.44 116.48,31.29 133.8,31.29 137.28,27.81 139.88,27.81 141.45,26.24 142.46,26.24 143.05,25.64 143.05,21.9 143.89,21.06 148.33,21.06 148.43,20.96 149.73,20.96 150.28,20.4 151.82,20.4 152.17,20.04 154.48,20.04 155.68,18.85 156.02,18.85 156.37,18.5 156.37,18 157.95,16.43 241.7,16.43 242.58,15.55 251.59,15.55 253.27,13.87 256.13,13.87 257.35,15.09 257.35,16.47 258.28,17.4 259.66,17.4 260.18,17.91 260.18,18.89 259.88,19.18 v2(259.22,19.18)
  BOTTOM w0.089: UH2.K37 81.65,22.66 v2(81.93,22.94)
  BOTTOM w0.152: v2(259.22,19.18) 259.31,19.1 259.68,19.1 259.73,19.04 JNGFF2.17
PCIE_PRX_DTX_N11: length 201.1
  IN1 w0.076: 81.17,23.14 81.17,23.16 81.19,23.17 81.19,23.6 80.94,23.84 80.78,23.84 80.67,23.74 80.67,23.56 v2(80.71,23.52)
  IN1 w0.107: v2(258.61,15.37) 258.82,15.58 258.82,15.73 258.77,15.79 258.38,15.79 258.02,15.42 258.02,13.6 256.99,12.57 253.7,12.57 251.82,14.45 242.34,14.45 240.98,15.81 155.46,15.81 151.52,19.75 150,19.75 149.4,20.34 148.18,20.34 148.08,20.44 141.92,20.44 141.56,20.8 141.56,21.58 140.95,22.19 140.95,25.73 139.57,27.1 136.91,27.1 135.46,28.55 125.1,28.55 124.28,29.36 124.28,29.76 123.39,30.65 115.12,30.65 115.08,30.69 114.07,30.69 113.95,30.81 106.48,30.81 105.82,30.15 94.27,30.15 92.31,28.2 91.44,28.2 91.03,27.79 91.03,26.66 90.47,26.1 89.82,26.1 89.04,25.31 89.04,24.03 87.15,22.14 86.31,22.14 86.01,21.84 82.21,21.84 81.17,22.88 81.17,23.14
  BOTTOM w0.089: v2(80.71,23.52) 80.53,23.7 80.53,23.8 UH2.G38
  BOTTOM w0.152: v2(258.61,15.37) 258.76,15.52 258.76,15.77 259.15,16.16 259.66,16.16 259.77,16.04 JNGFF2.29
PCIE_PRX_DTX_P1: length 320.8
  IN1 w0.107: v2(264.67,15.45) 264.93,15.19 265.06,15.19 265.14,15.27 265.14,16.16 264.78,16.51 264.78,17.24 266.24,18.7 268.43,18.7 268.6,18.86 270.09,18.86 271.3,20.07 287.62,20.07 288.28,20.72 290.76,20.72 290.99,20.49 292.51,20.49 293.68,21.65 293.68,22.07 294.74,23.14 301.63,23.14 304.04,25.55 305.44,25.55 307.52,27.64 308.04,27.64 310.19,29.78 310.19,30.98 315.42,36.21 324.02,36.21 326.58,38.77 326.58,39.69 328.22,41.33 328.22,54.12 330.76,56.66 330.76,60.48 331.34,61.06 331.34,63.69 327.99,67.04 327.99,72.96 330.49,75.46 330.49,78.3 329.44,79.35 329.44,83.04 331.38,84.98 338.57,84.98 338.79,85.19 338.79,85.47 v2(338.41,85.85)
  IN3 w0.089: 101.98,25.53 101.92,25.59 100.25,25.59 100.1,25.44 99.58,25.44 96.53,22.39 93.95,22.39 92.45,23.89 92.03,23.89 91.87,24.06 v2(91.87,24.3)
  IN3 w0.099: 101.98,25.53 102.01,25.5 102.15,25.5 102.53,25.12 106.89,25.12 108.21,23.8 108.21,23.28 108.9,22.58 108.9,21.48 109.56,20.82 114.32,20.82 117.28,17.87 120.8,17.87 122.06,16.61 122.57,16.61 123.19,15.98 124.21,15.98 124.68,16.45 126.87,16.45 127.37,15.95 138.4,15.95 138.65,15.71 144.14,15.71 144.92,14.92 151.95,14.92 152.13,14.74 178.3,14.74 178.86,15.3 200.19,15.3 201.1,14.4 204.57,14.4 204.87,14.1 231.89,14.1 232.48,14.69 241.53,14.69 242.65,13.58 249.08,13.58 250.11,14.6 252.06,14.6 253.07,13.59 256.27,13.59 257.01,14.33 260.45,14.33 261.03,14.9 263.61,14.9 263.77,15.05 264.28,15.05 v2(264.67,15.45)
  BOTTOM w0.089: v2(91.87,24.3) UH2.F16
  BOTTOM w0.152: v2(338.41,85.85) 338.58,85.68 338.58,85.33 338.55,85.3 JNGFF1.33
PCIE_PRX_DTX_P5: length 282.1
  IN3 w0.099: v2(333.47,34.51) 333.47,34.2 333.36,34.09 329.1,34.09 327.07,32.07 325.06,32.07 323.77,33.36 316.03,33.36 314.74,34.65 308.92,34.65 307.23,32.95 305.47,32.95 305.2,32.68 304.54,32.68 301.41,29.55 297.84,29.55 297.64,29.35 297.07,29.35 295.59,27.87 293.43,27.87 290.76,25.2 289.51,25.2 287.85,23.54 285.4,23.54 284.1,22.25 283.49,22.25 279.47,18.22 269.09,18.22 268.65,17.78 261.72,17.78 259.9,15.96 256.86,15.96 255.72,14.83 253.51,14.83 252.55,15.79 249.58,15.79 248.59,14.8 246.46,14.8 245.38,15.88 231.76,15.88 231.25,15.37 205.5,15.37 205.28,15.59 201.81,15.59 200.87,16.52 178,16.52 177.41,15.93 152.66,15.93 152.4,16.19 145.54,16.19 144.84,16.89 141.86,16.89 139.7,19.05 121.33,19.05 120.86,19.52 117.5,19.52 115.1,21.92 115.1,24.52 113.03,26.59 109.57,26.59 108.28,27.88 106.54,27.88 106.01,27.34 99.78,27.34 99.01,26.56 97.85,26.56 97.12,25.84 97.12,25.49 96.74,25.11 96.74,24.37 96,23.62 95,23.62 94.45,24.17 94.45,25.44 94.07,25.83 93.61,25.83 93.38,26.06 93.38,28.06 93.04,28.4 91.27,28.4 90.81,27.93 90.81,26.42 89.6,25.21 89.6,24.2 89.88,23.93 90.1,23.93 v2(90.27,23.76)
  BOTTOM w0.089: UH2.G20 v2(90.27,23.76)
  BOTTOM w0.152: CR10.1 338.71,32.14 338.34,31.77 v3(336.54,31.77) 335.21,31.77 333.47,33.52 v2(333.47,34.51)
PCIE_PRX_DTX_P09: length 198.6
  IN1 w0.107: v2(258.87,21.49) 258.77,21.6 258.56,21.6 258.16,21.2 258.16,18.18 256.7,16.72 256.7,15.66 255.78,14.73 253.82,14.73 253.36,15.19 252.82,15.19 250.95,17.06 158.3,17.06 157.23,18.14 157.23,18.55 155.93,19.85 155.55,19.85 154.72,20.68 152.45,20.68 152.11,21.02 150.54,21.02 149.99,21.57 148.69,21.57 148.34,21.92 148.34,23.69 146.83,25.2 144.47,25.2 142.66,27 141.61,27 136.68,31.93 116.96,31.93 115.37,33.53 106.65,33.53 104.8,31.67 93.89,31.67 91.98,29.77 91.06,29.77 87.57,26.29 86.36,26.29 85.6,25.53 83.85,25.53 83.18,24.86 83.18,24.29 82.59,23.7 82.14,23.7 81.81,24.04 v2(81.41,24.14)
  BOTTOM w0.089: UH2.F36 81.51,24.58 81.51,24.25 v2(81.41,24.14)
  BOTTOM w0.152: JNGFF2.7 258.92,21.54 v2(258.87,21.49)
PCIE_PRX_DTX_P10: length 200.4
  IN1 w0.107: v2(259.22,18.6) 259.22,18.6 259.6,18.98 259.8,18.98 259.98,18.8 259.98,18 259.58,17.6 258.19,17.6 257.15,16.56 257.15,15.17 256.05,14.07 253.35,14.07 251.68,15.75 242.67,15.75 241.79,16.63 158.03,16.63 156.57,18.09 156.57,18.59 156.11,19.05 155.76,19.05 154.57,20.25 152.25,20.25 151.9,20.6 150.37,20.6 149.81,21.16 148.52,21.16 148.42,21.26 143.98,21.26 143.26,21.98 143.26,25.73 142.54,26.44 141.54,26.44 139.96,28.02 137.36,28.02 133.88,31.5 116.56,31.5 115.41,32.65 106.44,32.65 105.05,31.26 94.22,31.26 91.99,29.03 90.91,29.03 87.72,25.84 87.29,25.84 86.16,24.71 86.16,23.22 85.43,22.49 83.13,22.49 82.9,22.72 82.9,22.87 82.46,23.31 81.84,23.31 81.74,23.41 v2(81.74,23.57)
  BOTTOM w0.089: UH2.J37 81.35,23.28 81.45,23.28 v2(81.74,23.57)
  BOTTOM w0.152: v2(259.22,18.6) 259.39,18.77 259.55,18.77 259.77,18.54 JNGFF2.19
PCIE_PRX_DTX_P11: length 201.1
  IN1 w0.076: 81.37,23.14 81.37,23.16 81.36,23.17 81.36,23.67 81.01,24.02 v2(80.24,24.02)
  IN1 w0.107: 81.37,23.14 81.37,22.96 82.29,22.04 85.93,22.04 86.22,22.34 87.06,22.34 88.84,24.11 88.84,25.4 89.74,26.3 90.38,26.3 90.83,26.75 90.83,27.87 91.35,28.4 92.23,28.4 94.18,30.35 105.74,30.35 106.4,31.01 114.04,31.01 114.15,30.9 115.16,30.9 115.21,30.85 123.48,30.85 124.49,29.84 124.49,29.45 125.18,28.75 135.54,28.75 136.99,27.31 139.66,27.31 141.15,25.82 141.15,22.28 141.76,21.67 141.76,20.89 142,20.65 148.16,20.65 148.26,20.54 149.49,20.54 150.08,19.95 151.61,19.95 155.55,16.02 241.07,16.02 242.42,14.66 251.9,14.66 253.78,12.78 256.9,12.78 257.81,13.69 257.81,15.51 258.3,15.99 258.86,15.99 259.03,15.82 259.03,15.58 v2(259.24,15.37)
  BOTTOM w0.089: UH2.F39 v2(80.24,24.02)
  BOTTOM w0.152: v2(259.24,15.37) 259.09,15.52 259.09,15.63 259.28,15.83 259.53,15.83 259.81,15.54 JNGFF2.31
PCIE_PRX_TTX_N17: length 56.9
  IN6 w0.089: 75.06,26.21 75.08,26.21 75.09,26.2 75.23,26.2 75.69,25.74 75.69,24.98 77.48,23.19 77.84,23.19 77.92,23.1 v2(78.45,23.1)
  IN6 w0.107: 75.06,26.21 74.61,26.21 74.28,26.54 74.28,26.99 73.7,27.56 73.25,27.56 72.83,27.98 72.83,28.26 72.59,28.51 72.06,28.51 71.81,28.26 71.81,27.98 71.67,27.84 71.32,27.84 71.2,27.97 71.2,28.26 70.95,28.51 70.44,28.51 70.17,28.24 70.17,27.98 70.05,27.86 69.71,27.86 69.15,28.43 68.7,28.43 68.48,28.2 66.05,28.2 64.32,29.94 63.82,29.94 63.58,29.69 63.58,28.89 63.45,28.76 63,28.76 62.87,28.88 62.87,29.68 62.63,29.93 62.1,29.93 61.85,29.68 61.85,28.91 61.69,28.76 61.36,28.76 61.24,28.88 61.24,29.69 60.99,29.94 60.47,29.94 60.22,29.68 60.22,28.89 60.09,28.76 59.73,28.76 59.6,28.89 59.6,29.69 59.35,29.94 58.84,29.94 58.58,29.67 58.58,28.99 58.45,28.86 57.87,28.86 57.39,29.34 56.34,29.34 55.96,29.73 41.8,29.73 39.27,32.26 37.42,32.26 37.13,32.55 37.02,32.55 v2(36.77,32.79)
  BOTTOM w0.089: v2(78.45,23.1) 78.45,22.87 UH2.K43
  BOTTOM w0.152: CT181.1 36.24,32.26 v2(36.77,32.79)
PCIE_PRX_TTX_N18: length 60.8
  IN6 w0.089: v2(79.62,21.85) 79.62,21.67 79.56,21.61 79.36,21.61 78.8,22.17 77.9,22.17 77.43,22.64 77.1,22.64 76.32,23.42 76.32,23.7 75.35,24.68 75.09,24.68 75.08,24.69 75.06,24.69
  IN6 w0.107: 75.06,24.69 74.8,24.69 73.82,25.67 73.53,25.67 72.55,26.64 72.55,26.97 72.31,27.22 71.78,27.22 71.53,26.97 71.53,26.64 71.4,26.51 71.04,26.51 70.92,26.64 70.92,26.97 70.67,27.22 70.14,27.22 69.9,26.97 69.9,26.64 69.77,26.51 69.58,26.51 69.1,27 68.79,27 68.23,27.56 64.27,27.56 63.69,28.14 57.68,28.14 57.09,28.73 56.02,28.73 55.63,29.11 41.53,29.11 39.68,30.96 38.63,30.96 38.1,31.5 36.14,31.5 36.01,31.62 36.01,32 35.76,32.25 35.23,32.25 35.11,32.13 35.11,32.12 34.99,32 34.99,31.62 34.86,31.5 34.5,31.5 34.38,31.62 34.38,31.85 34.13,32.09 33.6,32.09 33.36,31.85 33.36,31.63 33.23,31.5 33.05,31.5 32.75,31.79 32.41,31.79 32.09,31.48 29.82,31.48 29.67,31.63 29.67,31.71 v2(29.89,31.93)
  BOTTOM w0.089: UH2.P41 79.23,20.97 79.23,21.47 v2(79.62,21.85)
  BOTTOM w0.152: v2(29.89,31.93) 29.75,32.07 29.75,32.38 CT180.1
PCIE_PRX_TTX_N19: length 61.3
  IN6 w0.089: v2(78,20.99) 78,20.96 78.38,20.59 78.38,20.47 78.27,20.37 77.51,20.37 75.22,22.66 75.22,22.67 75.2,22.69
  IN6 w0.107: v2(27.46,31.95) 27.24,31.74 27.24,31.34 27.87,30.72 28.73,30.72 29.24,30.2 37.52,30.2 38.57,29.16 39.63,29.16 40.07,28.71 40.07,27.85 40.38,27.55 41.65,27.55 41.97,27.86 42.56,27.86 42.87,27.55 43.29,27.55 43.61,27.86 44.19,27.86 44.51,27.55 44.93,27.55 45.24,27.86 45.83,27.86 46.14,27.55 46.56,27.55 46.88,27.86 54.98,27.86 55.34,27.5 56.55,27.5 57.52,26.53 57.78,26.53 58.14,26.89 58.61,26.89 58.97,26.53 59.42,26.53 59.63,26.74 60.17,26.74 60.98,25.93 61.82,25.93 62.52,25.24 70.66,25.24 71.57,24.33 71.57,23.63 72.26,22.93 73.53,22.93 73.68,23.08 74.61,23.08 74.87,22.82 75.07,22.82 75.1,22.79 75.2,22.69
  BOTTOM w0.089: UH2.M44 78.13,21.56 78.27,21.42 78.27,21.25 v2(78,20.99)
  BOTTOM w0.152: CT7.1 27.31,32.4 27.31,32.1 v2(27.46,31.95)
PCIE_PRX_TTX_N20: length 65.2
  IN6 w0.089: v2(81.83,19.66) 81.62,19.86 81.62,20.14 81.4,20.37 80.85,20.37 80.35,19.87 76.79,19.87 75.36,21.31 75.09,21.31 75.08,21.32 75.06,21.32
  IN6 w0.107: 75.06,21.32 74.6,21.32 73.91,22 72.3,22 71.6,22.7 71.33,22.7 70.72,23.32 70.17,23.32 69.86,23.63 67.49,23.63 67.02,24.1 62.72,24.1 61.63,25.19 60.82,25.19 60.13,25.88 57.17,25.88 56.71,26.34 53.33,26.34 52.43,27.25 47.94,27.25 47.52,26.82 39.43,26.82 38.61,27.64 38.61,28.22 37.31,29.52 29.05,29.52 28.55,30.02 27.56,30.02 26.59,30.99 25.25,30.99 24.88,31.36 24.88,31.76 v2(25.07,31.95)
  BOTTOM w0.089: v2(81.83,19.66) 81.85,19.68 81.85,19.77 UH2.R35
  BOTTOM w0.152: CT3.1 24.95,32.42 24.95,32.07 v2(25.07,31.95)
PCIE_PRX_TTX_P17: length 56.8
  IN6 w0.089: 75.06,26 75.08,26 75.09,26.01 75.15,26.01 75.5,25.66 75.5,24.91 77.41,23 77.76,23 77.84,22.92 78.12,22.92 78.19,22.84 v2(78.19,22.58)
  IN6 w0.107: v2(36.77,32.16) 36.96,32.34 37.04,32.34 37.33,32.06 39.19,32.06 41.72,29.53 55.87,29.53 56.26,29.14 57.31,29.14 57.79,28.66 58.54,28.66 58.78,28.9 58.78,29.59 58.93,29.73 59.27,29.73 59.4,29.61 59.4,28.8 59.65,28.56 60.17,28.56 60.3,28.68 60.3,28.68 60.42,28.8 60.42,29.59 60.56,29.73 60.91,29.73 61.03,29.61 61.03,28.8 61.28,28.55 61.78,28.55 62.05,28.83 62.05,29.59 62.19,29.73 62.54,29.73 62.67,29.6 62.67,28.8 62.79,28.68 62.79,28.68 62.91,28.55 63.53,28.55 63.78,28.8 63.78,29.61 63.91,29.73 64.23,29.73 65.97,28 68.56,28 68.79,28.22 69.06,28.22 69.63,27.65 70.13,27.65 70.38,27.9 70.38,28.16 70.52,28.31 70.87,28.31 70.99,28.18 70.99,27.89 71.24,27.64 71.76,27.64 72.01,27.9 72.01,28.18 72.14,28.31 72.5,28.31 72.63,28.18 72.63,27.9 73.17,27.36 73.62,27.36 74.07,26.91 74.07,26.45 74.52,26 75.06,26
  BOTTOM w0.089: UH2.K44 78.19,22.76 v2(78.19,22.58)
  BOTTOM w0.152: CT179.1 36.16,31.88 36.32,31.88 36.6,32.16 v2(36.77,32.16)
PCIE_PRX_TTX_P18: length 60.8
  IN6 w0.089: 75.06,24.48 75.08,24.48 75.09,24.49 75.27,24.49 76.14,23.62 76.14,23.34 77.03,22.45 77.35,22.45 77.82,21.98 78.73,21.98 79.29,21.42 79.66,21.42 v2(79.78,21.3)
  IN6 w0.107: v2(29.29,31.93) 29.47,31.76 29.47,31.55 29.74,31.28 32.17,31.28 32.49,31.59 32.67,31.59 32.96,31.3 33.31,31.3 33.56,31.54 33.56,31.76 33.69,31.89 34.05,31.89 34.17,31.76 34.17,31.54 34.42,31.29 34.95,31.29 35.19,31.54 35.19,31.92 35.32,32.04 35.68,32.04 35.81,31.91 35.81,31.54 36.05,31.29 38.02,31.29 38.55,30.76 39.59,30.76 41.44,28.91 55.55,28.91 55.93,28.52 57,28.52 57.59,27.93 63.61,27.93 64.19,27.36 68.14,27.36 68.7,26.8 69.01,26.8 69.5,26.31 69.85,26.31 70.1,26.56 70.1,26.89 70.23,27.02 70.59,27.02 70.71,26.89 70.71,26.56 70.96,26.31 71.49,26.31 71.73,26.56 71.73,26.89 71.86,27.02 72.22,27.02 72.35,26.89 72.35,26.56 73.44,25.47 73.73,25.47 74.71,24.48 75.06,24.48
  BOTTOM w0.089: UH2.R40 80.07,21.01 v2(79.78,21.3)
  BOTTOM w0.152: CT178.1 29.42,32.42 29.42,32.06 v2(29.29,31.93)
PCIE_PRX_TTX_P19: length 61.2
  IN6 w0.089: v2(78.56,20.93) 78.56,20.4 78.35,20.19 77.43,20.19 75.09,22.53 75.07,22.53 75.06,22.55
  IN6 w0.107: 75.06,22.55 74.98,22.62 74.79,22.62 74.53,22.88 73.76,22.88 73.61,22.73 72.18,22.73 71.36,23.54 71.36,24.25 70.57,25.03 62.43,25.03 61.74,25.73 60.9,25.73 60.09,26.54 59.71,26.54 59.5,26.33 58.88,26.33 58.52,26.69 58.22,26.69 57.86,26.33 57.43,26.33 56.47,27.29 55.26,27.29 54.89,27.66 46.96,27.66 46.65,27.34 46.06,27.34 45.74,27.66 45.33,27.66 45.01,27.34 44.42,27.34 44.11,27.66 43.69,27.66 43.37,27.34 42.79,27.34 42.47,27.66 42.06,27.66 41.74,27.34 40.29,27.34 39.87,27.77 39.87,28.63 39.54,28.96 38.48,28.96 37.44,30 29.16,30 28.64,30.51 27.78,30.51 27.04,31.25 27.04,31.79 v2(26.87,31.95)
  BOTTOM w0.089: UH2.N42 78.56,21.19 v2(78.56,20.93)
  BOTTOM w0.152: v2(26.87,31.95) 26.98,32.06 26.98,32.42 CT5.1
PCIE_PRX_TTX_P20: length 65.2
  IN6 w0.089: 75.06,21.11 75.08,21.11 75.09,21.12 75.28,21.12 76.71,19.69 80.43,19.69 80.93,20.18 81.32,20.18 81.44,20.07 81.44,19.96 v2(81.16,19.68)
  IN6 w0.107: 75.06,21.11 74.51,21.11 73.83,21.8 72.22,21.8 71.52,22.5 71.25,22.5 70.63,23.11 70.09,23.11 69.77,23.43 67.4,23.43 66.93,23.9 62.64,23.9 61.54,24.99 60.73,24.99 60.04,25.68 57.08,25.68 56.62,26.14 53.25,26.14 52.35,27.04 48.02,27.04 47.6,26.62 39.35,26.62 38.41,27.56 38.41,28.14 37.23,29.31 28.97,29.31 28.47,29.82 27.48,29.82 26.51,30.79 25.16,30.79 24.68,31.27 24.68,31.76 v2(24.49,31.95)
  BOTTOM w0.089: v2(81.16,19.68) 81.16,19.74 81.57,20.15 UH2.R37
  BOTTOM w0.152: CT1.1 24.62,32.41 24.62,32.09 v2(24.49,31.95)
PCIE_PTX_C_DRX_N1: length 14.2
  BOTTOM w0.152: JNGFF1.29 337.55,85.24 337.45,85.35 337.45,85.9 336.28,87.08 332.51,87.08 331.57,86.14 v3(331.57,82.98) 331.57,82.78 332.51,81.84 332.51,81.2 332.41,81.1 332.07,81.1 CN20.2
PCIE_PTX_C_DRX_N5: length 1.9
  BOTTOM w0.152: CR9.2 340.74,34.24 340.74,34.37 340.25,34.86 340.25,35.11 340.18,35.18 UR1.4
PCIE_PTX_C_DRX_N09: length 2.6
  BOTTOM w0.152: CD43.2 258.26,20.46 259.46,20.46 259.55,20.54 JNGFF2.11
PCIE_PTX_C_DRX_N10: length 2.8
  BOTTOM w0.152: CD45.2 258.09,17.43 259.66,17.43 259.77,17.54 JNGFF2.23
PCIE_PTX_C_DRX_N11: length 3
  BOTTOM w0.152: CD53.2 257.88,14.46 259.39,14.46 259.48,14.54 JNGFF2.35
PCIE_PTX_C_DRX_P1: length 14.2
  BOTTOM w0.152: JNGFF1.27 337.05,85.28 337.12,85.35 337.12,85.77 336.14,86.75 332.65,86.75 331.9,86 331.9,82.92 332.84,81.98 332.84,81.07 332.55,80.77 332.03,80.77 331.9,80.65 331.9,80.38 CN21.2
PCIE_PTX_C_DRX_P5: length 1.9
  BOTTOM w0.152: UR1.3 340.58,35 341.07,34.5 341.07,34.29 CR7.2
PCIE_PTX_C_DRX_P09: length 2.6
  BOTTOM w0.152: CD44.2 258.33,20.13 259.46,20.13 259.55,20.04 JNGFF2.13
PCIE_PTX_C_DRX_P10: length 2.8
  BOTTOM w0.152: CD46.2 258.2,17.1 259.69,17.1 259.74,17.04 JNGFF2.25
PCIE_PTX_C_DRX_P11: length 3
  BOTTOM w0.152: CD51.2 257.89,14.13 259.39,14.13 259.48,14.04 JNGFF2.37
PCIE_PTX_C_TRX_N17: length 4.6
  BOTTOM w0.076: 32.69,33.75 32.6,33.75 32.32,34.04 31.8,34.04 31.29,34.55 31.08,34.55 30.92,34.7 30.92,35.09 UT1.Y22
  BOTTOM w0.152: 32.69,33.75 33.1,33.35 v3(33.41,33.35) 34.04,33.35 34.04,33.35 CT177.1
PCIE_PTX_C_TRX_N18: length 3.6
  BOTTOM w0.089: CT174.1 30.98,33.27 30.98,33.51 30.66,33.83 30.19,33.83 29.54,34.48 29.2,34.48 29.09,34.58 29.09,35.08 UT1.T22
PCIE_PTX_C_TRX_N19: length 3
  BOTTOM w0.089: UT1.M22 27.26,35.07 27.26,35.07 27.27,35.06 27.27,34.52 27.38,34.42 27.64,34.42 28.56,33.5 28.56,33.24 CT8.1
PCIE_PTX_C_TRX_N20: length 2.7
  BOTTOM w0.089: CT4.1 26.15,33.2 26.15,33.49 25.75,33.89 25.75,34.24 25.43,34.56 25.43,35.06 25.42,35.07 25.42,35.07 UT1.H22
PCIE_PTX_C_TRX_P17: length 4.5
  BOTTOM w0.076: 32.46,33.53 32.46,33.64 32.24,33.86 31.73,33.86 31.22,34.37 31,34.37 30.71,34.67 UT1.Y23
  BOTTOM w0.152: CT176.1 34.08,33.02 32.96,33.02 32.46,33.52 32.46,33.53
PCIE_PTX_C_TRX_P18: length 3.6
  BOTTOM w0.089: UT1.T23 28.87,34.94 28.81,35 28.69,35 28.63,34.94 28.63,34.66 29.09,34.21 29.43,34.21 30.08,33.56 30.55,33.56 30.72,33.4 30.72,33.24 CT175.1
PCIE_PTX_C_TRX_P19: length 3
  BOTTOM w0.089: UT1.M23 27.03,34.92 26.96,34.99 26.87,34.99 26.8,34.91 26.8,34.62 27.27,34.15 27.53,34.15 28.29,33.39 28.29,33.28 CT6.1
PCIE_PTX_C_TRX_P20: length 2.7
  BOTTOM w0.089: CT2.1 25.88,33.21 25.88,33.38 25.48,33.78 25.48,34.13 24.96,34.66 24.96,34.91 25.03,34.99 25.12,34.99 25.19,34.92 UT1.H23
PCIE_PTX_DRX_N1: length 313.9
  IN1 w0.107: v2(330.73,81.03) 330.96,80.8 331.19,80.8 331.55,80.44 331.55,75.35 329.49,73.29 329.49,66.72 332.7,63.51 332.7,59.44 331.76,58.5 331.76,56.39 329.95,54.57 329.95,52.07 329.19,51.31 329.19,40.2 327.09,38.1 327.09,37.4 324.61,34.93 315.47,34.93 313.14,32.6 313.14,30.48 311.85,29.19 311.21,29.19 306.6,24.59 305.26,24.59 302.99,22.32 295.08,22.32 294.51,21.75 294.51,20.45 293.68,19.61 290.55,19.61 289.46,18.52 288.03,18.52 287.43,17.91 284.72,17.91 284.08,18.55 276.09,18.55 275.41,19.23 271.96,19.23 270.21,17.48 266.19,17.48 265.71,16.99 265.71,16.74 265.84,16.61 266,16.61 v2(266.17,16.79)
  IN3 w0.089: v2(91.5,27.69) 91.68,27.51 91.97,27.51 92.16,27.32 92.16,25.8 93.23,24.73 93.23,24.17 94.36,23.04 96.31,23.04 99.99,26.72 101.95,26.72 101.96,26.72 101.98,26.72
  IN3 w0.099: v2(266.17,16.79) 263.97,16.79 263.72,16.53 261.69,16.53 260.12,14.96 256.75,14.96 255.99,14.2 253.3,14.2 252.3,15.2 249.85,15.2 248.85,14.2 246.15,14.2 245.07,15.28 232.07,15.28 231.52,14.73 205.12,14.73 204.86,14.99 201.51,14.99 200.59,15.91 178.44,15.91 177.86,15.34 152.38,15.34 152.16,15.56 145.18,15.56 144.44,16.3 138.89,16.3 138.62,16.57 127.64,16.57 127,17.21 122.32,17.21 120.6,18.93 117.25,18.93 114.76,21.42 110.01,21.42 109.55,21.88 109.55,25.68 107.99,27.24 106.96,27.24 106.45,26.72 101.98,26.72
  BOTTOM w0.089: v2(91.5,27.69) 91.12,27.31 UH2.A17
  BOTTOM w0.152: CN20.1 331.13,80.85 330.91,80.85 v2(330.73,81.03)
