# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N135772492: length 1
  TOP w0.254: PR252.2 23.12,16.66 PU202.2
N135776099: length 4.1
  BOTTOM w0.14: v1(18.1,34.81) PU201.1
  BOTTOM w0.254: PU201.1 17.77,33.67 16.87,32.77 16.87,31.62 PR214.2
N135776158: length 2.3
  BOTTOM w0.254: PU201.2 17.65,33.02 17.32,32.69 17.32,32.13 17.78,31.67 PR215.2
N135776395: length 3.1
  BOTTOM w0.14: PR216.2 11.68,32.11 v1(11.56,31.98)
  BOTTOM w0.508: PQ205.2 13.65,33.05 12.71,32.11 PR216.2
N135782958: length 2
  BOTTOM w0.14: PR284.2 52.06,17.99 52.06,16.86 52.4,16.51 PQ227.5
N135788915: length 3.5
  TOP w0.203: PU1900.21 51.44,15.31 52.38,16.26 53.71,16.26 PR1913.2
N135795991: length 15
  TOP w0.254: PR1902.1 46.61,7.88 47.63,6.86 49.96,6.86 50.88,7.77 52.17,7.77 v1(52.43,8.04) 53.56,9.17 56.99,9.17 57.43,9.61 57.43,10.09 v2(57.58,10.24)
  BOTTOM w0.254: v2(57.58,10.24) 57.58,10.1 57.15,9.67 PR1900.3
N135796052: length 9.7
  TOP w0.254: v2(56.9,10.16) 57.03,10.03 57.03,9.71 56.85,9.53 53.34,9.53 v1(53.18,9.36) 52.01,8.19 50.04,8.19 PR1901.1
  BOTTOM w0.254: v2(56.9,10.16) 56.9,10.28 57.15,10.54 PR1900.2
N135896425: length 9.9
  TOP w0.14: R276.2 170.46,4.41 v1(171.18,3.69) 171.97,2.9 177.08,2.9 QRTC1.1
N137529606: length 5.6
  TOP w0.14: v1(297.94,3.15) 298.16,2.93 299.47,2.93 299.77,3.24 QE10.2 299.77,4.11 299.98,4.32 300.48,4.32 301,4.84 RE69.2
N137781553: length 5.7
  BOTTOM w0.14: v1(344.44,46.38) 344.68,46.14 RR43.2 RR44.2 343.76,45.44 343.68,45.36 343.39,45.36 D74.1 343.35,45.85 343.49,45.99 343.49,47.04 342.75,47.78 JTS1.5
N137787212: length 11.4
  BOTTOM w0.14: JTS.2 350.99,57.14 351.2,56.93 v5(351.2,49.6) 350.74,49.14 349.59,49.14 DI1.2
N137827497: length 31.9
  TOP w0.076: UE3.H2 299.76,11.58 299.36,11.98 v2(299.36,12.57)
  TOP w0.14: v2(276.35,12.57) 276.35,13.46 T6004.1
  IN5 w0.099: v2(299.36,12.57) 299.36,11.98 298.66,11.29 295.97,11.29 295.73,11.53 295.73,11.85 295.73,12.38 294.92,13.19 294.92,14.87 293.29,16.5 290.84,16.5 289.98,15.63 287.98,15.63 286.93,14.58 286.56,14.58 286.41,14.73 279.04,14.73 276.89,12.57 v2(276.35,12.57)
N137853671: length 2.6
  BOTTOM w0.14: CZ104.1 4.22,16.36 v1(4.22,16.83)
  BOTTOM w0.254: UA3.6 4.84,15.74 CZ104.1
N138188578: length 7.6
  BOTTOM w0.14: JEDP1.36 50.23,34.99 49.25,34.01 v1(49.25,31.56) 49.58,31.22 49.58,30.05 RV110.2
N138408347: length 1.2
  TOP w0.076: UE3.D6 v2(296.16,14.17)
  BOTTOM w0.076: T4948.1 296.56,13.77 v2(296.16,14.17)
N138608845: length 3.8
  TOP w0.14: v1(246.48,106.52) v2(246.48,107.09) 246.78,107.39 PR1643.2 PR1651.1
  BOTTOM w0.14: v2(246.48,107.09) 246.23,106.85 PU1600.9
N138923567: length 2.5
  TOP w0.076: UE3.F5 298.18,13.77 v2(298.56,13.38)
  BOTTOM w0.076: T6000.1 298.96,12.13 298.96,12.98 v2(298.56,13.38)
N139113922: length 2.7
  TOP w0.089: T6002.1 87.76,6.86 88.01,6.61 88.78,6.61 v2(89.09,6.92)
  BOTTOM w0.089: UH2.BD21 89.15,6.17 89.15,6.81 89.09,6.86 v2(89.09,6.92)
N139274499: length 2.3
  TOP w0.14: v1(64.29,17.41) 63.68,16.8 PR1940.1 63.58,16.28 PU1901.4
N139301189: length 4.1
  TOP w0.14: v1(105.49,63.44) 105.64,63.29 v2(105.64,62.8) 104.82,61.98 PR851.1 104.81,61.62 104.94,61.48 PR852.2
  BOTTOM w0.14: v2(105.64,62.8) 105.64,62.3 105.81,62.14 PU800.9
N139308180: length 6.1
  TOP w0.14: PR951.2 246.23,116.32 245.99,116.56 244.81,116.56 244.57,116.32 PR952.1 v1(244.57,114.83) 243.91,114.16 v2(243.91,113.9)
  BOTTOM w0.14: PU900.9 243.56,114.49 243.91,114.14 v2(243.91,113.9)
N139527854: length 2.9
  TOP w0.14: UZ29.6 123.21,14.97 CZ105.1 122.94,16.02 v1(122.58,16.37)
N139871071: length 4.9
  TOP w0.14: v1(144.53,16.26) 144.37,16.1 R5832.2
  TOP w0.254: R5832.2 144.37,14.78 144.12,14.53 QH1.2 RH5868.2
N139871074: length 4
  TOP w0.14: RH5868.1 141.35,16.26 141.23,16.38 v1(140.72,16.38) 140.46,16.38 139.13,15.05 QE20.1
N140262314: length 2.4
  TOP w0.14: UZ29.3 127.92,14.97 RZ1952.2 v1(128.94,14.9)
N140286428:
  vias: v1(77.74,30.34)
N140286440: length 3
  TOP w0.14: PR263.2 80.09,30.54 v1(80.57,31.01)
  TOP w0.406: PQ219.3 78.98,31.44 79.49,30.93 PR263.2
N140286558: length 7.2
  TOP w0.14: v1(73.09,22.94) 72.91,22.94 72.27,23.58 v2(72.27,23.64)
  TOP w0.305: PR295.1 71.32,23.55 71.54,23.77 72.15,23.77 v2(72.27,23.64)
  TOP w0.508: v2(73.5,24.9) 73.44,24.9 73.04,25.3 PQ225.2
  IN3 w0.508: v2(73.5,24.9) 73.5,24.84 73.78,24.56 73.78,23.31 73.34,22.87 72.71,22.87 72.27,23.31 v2(72.27,23.64)
N140286564: length 8.7
  TOP w0.508: PR276.2 71.6,28.57 PU204.4 71.24,28.42 PQ225.1 70.72,24.79 v1(70.16,24.23) 70.16,23.35 PC222.1 69.74,22.88 PR280.1
N140286576:
  vias: v1(70.74,31.03)
N140286584:
  vias: v1(75.35,29.82)
N140286624: length 18
  TOP w0.14: v2(78.39,31.12) 78.39,31.65 78.26,31.78 78.26,32.25 PQ219.2 ; v2(70.45,22.69) 70.55,22.6 70.92,22.6 71.05,22.73 PC221.1 71.68,22.28 PR271.2 71.85,22.28 v1(72.48,21.65)
  IN4 w0.089: 75.06,27.39 76.07,27.39 77.7,29.02 77.7,29.21
  IN4 w0.091: 77.7,29.21 77.7,29.83 78.39,30.51 v2(78.39,31.12) ; v2(70.45,22.69) 70.18,22.97 70.18,24.73 72.83,27.39 75.06,27.39
N140286634: length 9.7
  TOP w0.254: PQ219.5 79.41,33.4 v2(79.41,32.81)
  IN2 w0.508: v2(72.16,32.28) 73.72,33.83 79.07,33.83 79.5,33.4 79.5,32.89 v2(79.41,32.81)
  vias: v1(71.81,32.69)
N140583188: length 4.4
  TOP w0.14: QV91.2 218.6,42.22 RV1084.2 220.71,42.22 220.73,42.23 UV29.4 221.22,41.74 v1(221.76,41.2)
N140796616: length 37.3
  TOP w0.076: v2(303.18,9.54) 302.82,9.54 302.48,9.88 302.48,10.87 302.16,11.18 UE3.L2
  TOP w0.14: T6003.1 271.71,7.55 v2(271.71,8.94)
  IN2 w0.099: v2(303.18,9.54) 303.18,8.93 302.22,7.98 291.87,7.98 291.7,8.15 287.45,8.15 286.68,8.92 283.74,8.92 283.59,8.76 271.88,8.76 v2(271.71,8.94)
N141287628: length 7.5
  TOP w0.305: PR290.2 74.5,33.64 74.5,33.24 74.91,32.83 75.89,32.83 76.51,33.44 76.86,33.44 v1(77.63,34.21) 78.13,34.21 78.47,33.86 78.95,33.86 PQ219.6
N141309349: length 1.2
  BOTTOM w0.254: PU1200.5 135.58,113.94 PR1224.1
N141310932: length 0.8
  BOTTOM w0.254: PC1201.1 PR1224.2
N141315330: length 1.3
  BOTTOM w0.254: PR1225.1 149.51,120.16 149.77,119.89 PU1201.5
N141318175: length 1.2
  BOTTOM w0.254: PR1226.1 158.96,119.68 PU1202.5
N141348246: length 1.1
  BOTTOM w0.14: v1(241.76,104.08) 242.29,103.54 PC1601.1
N142820714: length 3.2
  TOP w0.14: v1(240.16,9.15) RD100.2 238.84,9.27 238.86,9.29 v2(238.86,9.84)
  BOTTOM w0.14: v2(238.86,9.84) JHDD.16
N143232395: length 1.9
  TOP w0.14: CE48.1 293.99,32.73 RE62.2 v1(292.93,33.47)
N143234416: length 4.6
  TOP w0.14: v1(239.52,53.72) 239.78,53.98 241.43,53.98 241.63,53.77 CZ2155.1 242.27,52.45 UZ30.6
N143234582: length 2
  TOP w0.14: UZ30.3 246.69,52.45 RZ1964.2
N143489306: length 4.2
  TOP w0.14: R5842.2 277.67,25.66 Q5.5 276.62,25.66 276.48,25.79 276.48,26.16 276.62,26.31 Q5.6 276.92,26.48 277.75,27.31 v1(278.13,27.31)
N143489317: length 2.7
  TOP w0.14: R5843.1 272.59,24.94 v1(272.42,24.77)
  TOP w0.381: R5843.1 274.13,25.01 Q5.3
N143674886: length 2.5
  TOP w0.14: RZ1953.2 109.73,46.55 v1(109.17,47.11) UZ26.2
N144550342: length 3.4
  TOP w0.14: UZ16.4 188.05,42.97 188.21,42.8 RZ72.2 190.25,43.77 v1(190.25,44.2)
N144805281: length 1.5
  TOP w0.254: UZ32.6 274.45,6.99 CZ39.1
N147476941: length 4.1
  TOP w0.14: JXDP.41 129.21,96.01 129.33,95.89 129.74,95.48 131.6,95.48 TC287.1
N12449474450: length 3.7
  BOTTOM w0.081: 24.86,54.45 24.86,54.61 24.86,54.61 24.86,55.63 UT4.B9
  BOTTOM w0.14: 24.86,54.45 25.15,54.15 25.15,52.7 T191.1
N12449474451: length 1.6
  BOTTOM w0.081: UT4.A9 24.62,54.45
  BOTTOM w0.14: 24.62,54.45 24.62,53.99 T192.1
N14775150118: length 2.6
  TOP w0.203: PR1925.1 49.51,19.66 PU1900.27

## Copper pours and planes (outline as drawn)
1.2V_B+ on TOP (solid shape): 276.89,33.47 277.1,33.4 277.3,33.47 278,33.47 278.13,33.34 278.13,31.24 277.56,30.67 275.53,30.67 275.27,30.42 275.27,29.85 275.21,29.78 274.7,29.78 274.64,29.84 274.64,30.26 273.78,31.12 273.78,33.15 274.1,33.47
1.2V_B+ on BOTTOM: 278.86,33.19 278.86,32.79 279.2,32.79 279.25,32.74 279.25,32.21 279.24,32.21 278.71,32.21 278.69,32.18 278.69,31.5 278.72,31.47 279.24,31.47 279.25,31.46 279.25,31.02 279.22,30.99 278.7,30.99 278.7,30.99 278.7,30.29 278.71,30.27 279.24,30.27 279.24,30.27 279.24,29.59 278.46,28.81 278.46,27.23 278.26,27.03 276.99,27.03 276.99,27.03 276.99,28.48 277.28,28.78 277.28,29.3 276.89,29.69 274.78,29.69 274.65,29.82 274.65,30.28 274.45,30.48 273.99,30.48 273.91,30.56 273.2,30.56 272.89,30.86 272.8,30.86 272.54,31.12 272.54,33.91 272.67,34.04 275.12,34.04 275.73,33.43 275.98,33.43 275.98,33.43 278.62,33.43
5VS_FAN2 on BOTTOM: 335.31,50.5 335.15,50.65 335.15,52.48 336.78,54.1 337.87,54.1 338.08,54.31 338.08,55.17 337.85,55.4 336.5,55.4 336.35,55.55 336.35,55.89 336.51,56.06 338.71,56.06 339.09,55.68 339.09,52.96 336.63,50.5
+0.6VS on TOP (solid shape): 282.37,28.52 282.87,28.52 282.87,29.06 283.17,29.06 283.17,28.52 283.67,28.52 283.67,29.06 284.44,29.06 284.61,28.89 284.61,26.78 283.61,25.78 282.6,25.78 282.6,25.79 281.7,25.79 281.39,26.1 281.39,28.9 281.55,29.06 282.37,29.06
+0.6VS on TOP: 173.5,19.74 173.56,19.79 174.18,19.79 174.55,19.43 177.75,19.43 177.9,19.28 177.9,18.35 177.89,18.34 177.89,17.87 177.4,17.39 173.68,17.39 173.5,17.57
+0.6VS on TOP: 252.45,14.95 250.81,16.59 250.47,16.59 249.51,17.55 249.33,18.17 249.33,20.09 249.44,20.21 249.44,21.18 249.71,21.45 251.54,21.45 254.69,18.3 255.57,18.3 256.75,17.11 257.31,16.56 257.31,12.35 257.07,12.12 255.84,12.12 253.01,14.95
+0.6VS on VCC: 249.92,16.89 249.28,17.53 174.35,17.53 173.48,18.39 173.48,26.31 174.6,27.43 242.34,27.43 249.45,20.32 253.64,20.32 254.64,19.33 254.64,17.51 254.02,16.89
+0.6VSP on TOP (solid shape): 287.82,32.68 287.83,32.68 287.86,32.64 287.86,31.33 286.57,30.04 285.31,30.04 284.46,29.19 283.55,29.19 283.55,28.65 283.3,28.65 283.3,29.19 282.75,29.19 282.75,28.65 282.5,28.65 282.5,29.19 281.54,29.19 281.43,29.29 281.43,29.49 281.47,29.5 281.75,29.84 281.47,30.19 281.43,30.2 281.43,31.76 281.53,31.86 282.15,31.86 282.45,31.56 286.13,31.56 286.26,31.43 286.87,31.43 287.14,31.7 287.14,32.67 287.31,32.85 287.65,32.85
+0.6VSP on BOTTOM (solid shape): 286.62,31.07 287.21,31.07 287.29,31 287.29,30.89 287.22,30.82 285.35,30.82 285.18,30.99 285.18,31.5 285.24,31.56 286.13,31.56
+0.95VSP on TOP (solid shape): 118.9,62.3 118.89,62.27 118.86,62.1 118.94,61.95 118.94,60.41 118.77,60.25 115.52,60.25 115.12,60.65 115.12,63.43 115.31,63.63 117.57,63.63
+0.95VSP on BOTTOM (solid shape): 117.41,65.94 117.43,65.86 117.43,64.9 117.43,64.9 117.43,64.75 117.97,64.75 117.97,64.45 117.96,64.45 117.96,64.34 117.43,64.34 117.4,64.32 117.4,63.58 117.43,63.55 117.97,63.55 117.97,63.18 117.94,63.15 117.45,63.15 117.43,63.12 117.43,62.39 117.53,62.28 118.77,62.28 118.94,62.11 118.94,60.47 118.75,60.28 115.57,60.28 115,60.85 115,62.87 114.49,63.37 111.7,63.37 111.34,63.74 111.34,66.53 111.58,66.78 116.58,66.78
+1.2V_DDR on TOP: outline of 146 points within 109.23,16.36 259.44,50.86
+1.2V_DDR on BOTTOM: 255.14,25.34 255.78,25.34 255.78,24.82 256.48,24.82 256.48,25.34 256.98,25.34 256.98,24.82 257.68,24.82 257.68,25.34 257.78,25.34 257.81,25.37 258.51,25.37 258.76,25.12 258.76,23.84 258,23.07 258,21.91 257.72,21.63 254.83,21.63 253.87,22.58 253.87,22.61 253.18,22.61 252.1,21.53 250.45,21.53 250,21.97 250,24.96 251.02,25.97 251.02,30.35 250.57,30.8 248.86,30.8 245.56,34.1 245.56,39.43 246.76,40.64 253.81,40.64 255.4,39.05 255.4,28.58 255.02,28.2 255.02,25.46
+1.2V_DDR on BOTTOM: 14.61,66.68 14.73,66.55 14.73,65.53 14.56,65.36 13.35,65.36 13.2,65.52 13.2,65.8 12.85,66.14 12.85,66.34 13.19,66.68
+1.2V_DDR on IN1: 259.72,24.7 255.02,24.7 254.64,24.32 254.64,22.04 255.14,21.53 257.81,21.53 258.89,22.61 259.72,22.61 260.03,22.92 260.03,24.39
+1.2V_DDR on IN1: outline of 108 points within 12.6,61.36 29.01,72.64
+1.2V_DDR on IN2: 117.95,35.4 113.96,39.4 108.35,39.4 105.72,42.04 96.71,42.04 95.17,40.5 95.17,39.51 95.25,39.43 96.39,39.43 96.4,39.44 101.28,39.44 102.49,38.23 104.15,38.23 107.94,34.44 116.15,34.44 116.76,33.84 116.76,33.45 116.64,33.34 113.09,33.34 111.7,31.94 111.7,30.61 112.27,30.04 113.06,30.04 113.71,29.38 114.99,29.38 115.44,29.82 115.44,31.02 115.72,31.3 121.08,31.3 121.25,31.48 121.25,33.91 119.76,35.4
+1.2V_DDR on IN3: 12.57,65.36 11.93,66 11.93,72 12.55,72.62 17.16,72.62 19.7,70.08 26.51,70.08 28.4,68.19 28.4,63.83 28.89,63.34 28.89,62.04 28.99,61.94 28.99,61.69 28.87,61.58 28.17,61.58 27.1,62.65 27.1,64.51 25.84,65.77 22.18,65.77 21.74,66.21 19.12,66.21 17.68,67.65 15.19,67.65 14.14,66.59 14.14,65.47 14.03,65.36
+1.2V_DDR on IN4: 82.84,35.31 77.16,35.31 74.92,33.07 59.76,33.07 58.72,34.11 48.42,34.11 48.41,34.12 48.41,34.13 48.16,34.38 46.31,34.38 46.29,34.36 45.41,34.36 44.47,35.31 39.56,35.31 36.45,38.42 36.45,40.58 37.25,41.38 37.25,42.2 37.39,42.35 37.39,43.4 37.71,43.71 40.89,40.79 44.43,38.33 47.2,37.14 50.18,36.73 81.82,36.73 82.47,36.75 83.13,36.81 84.52,36.81 85.37,35.96 85.37,35.96 86.56,34.77 91.49,34.77 94.18,37.46 94.18,38.94 95.95,40.7 96.27,40.7 96.37,40.7 96.48,40.59 96.48,36.27 93.08,32.87 85.27,32.87
+1.2V_DDR on IN4: 28.78,63.26 28.34,63.26 28,62.92 28,61.43 28.08,61.35 28.39,61.35 28.59,61.55 28.87,61.55 29.01,61.69 29.01,61.97 28.86,62.12 28.86,63.18
+1.2V_DDR on VCC: 39.54,34.99 37.85,36.68 35.8,36.68 35.19,37.29 35.19,43.05 33.48,44.77 33.48,44.77 31.62,46.63 31.62,48.51 30.42,49.7 30.41,49.72 30.41,50.15 28.09,52.47 28.09,55.76 27.16,56.69 27.16,62.59 27.75,63.18 28.83,63.18 28.83,62.6 31.56,52.73 37.24,44.21 40.62,41.01 44.43,38.33 47.2,37.14 50.18,36.73 81.82,36.73 84.8,37.14 87.57,38.33 90.86,40.59 93.84,43.25 94.55,43.25 94.55,43.24 95.77,43.24 96.38,42.63 96.38,40.3 91.07,34.99 84.01,34.99 84.01,34.99
+1.2V_DDR on IN5: 247.39,27.41 250.86,27.41 251.91,26.36 259.07,26.36 259.37,26.06 259.37,19.86 259.1,19.59 249.47,19.59 249.46,19.59 235.77,19.59 235.06,20.3 185.23,20.3 184.73,20.8 184.73,28.13 187.64,31.04 243.76,31.04
+1.2V_DDR on IN6: 111.53,18.88 111.28,18.63 111.28,17.45 111.29,17.43 111.29,16.68 111.41,16.57 118.49,16.57 118.99,17.06 121.21,17.06 121.55,17.41 121.55,18.57 121.26,18.86 120.68,18.86 120.66,18.88
+1.2V_DTH on BOTTOM (solid shape): outline of 231 points within 12.96,59.95 25.1,77.17
+1.2V_MEN_P on BOTTOM (solid shape): 283.81,32.14 283.81,31.14 283.27,31.14 283.27,30.71 283.81,30.71 283.81,30.41 283.76,30.36 282.87,30.36 282.43,30.8 282.43,32.19 282.57,32.32 283.63,32.32
+1.2V_MEN_P on BOTTOM (solid shape): 263.89,33.96 263.89,30.2 263.15,29.45 263.13,29.45 261.05,27.37 261.05,26.42 260.16,25.53 257.57,25.53 257.57,25.46 257.56,25.46 257.56,24.95 257.11,24.95 257.11,25.46 257.08,25.46 257.08,25.47 256.38,25.47 256.38,25.46 256.36,25.46 256.36,24.95 255.91,24.95 255.91,25.46 255.88,25.46 255.88,25.47 255.2,25.47 255.2,28.08 255.68,28.56 255.68,31.43 258.48,31.43 258.48,31.38 258.49,31.33 258.51,31.28 258.54,31.23 258.57,31.19 258.61,31.15 258.65,31.12 258.7,31.1 258.75,31.09 258.81,31.08 258.86,31.08 258.91,31.09 258.96,31.1 259.01,31.12 259.06,31.15 259.09,31.19 259.13,31.23 259.15,31.28 259.17,31.33 259.19,31.38 259.19,31.43 259.19,31.49 259.17,31.54 259.15,31.59 259.13,31.63 259.09,31.68 259.06,31.71 259.01,31.74 258.96,31.77 258.91,31.78 258.86,31.79 258.81,31.79 258.75,31.78 258.7,31.77 258.65,31.74 258.61,31.71 258.57,31.68 258.54,31.63 258.51,31.59 258.49,31.54 258.48,31.49 258.48,31.43 255.68,31.43 255.68,32.47 256.16,32.96 260.43,32.96 261.31,33.84 261.31,34.01 261.36,34.07 263.78,34.07
+1.2V_MEN_P on IN1 (solid shape): 263.28,29.79 263.28,29.52 263.78,29.02 263.78,28.77 263.59,28.58 262.76,28.58 262.07,29.27 262.07,29.89 262.23,30.05 263.02,30.05
+1.2V_MEN_P on IN1: 282.09,32.51 283.7,32.51 283.9,32.32 283.9,30.72 283.79,30.61 282.42,30.61 281.71,31.32 281.71,32.14
+1.2V_VCCPLL_OC on IN6: 142.36,67.48 142.09,67.74 142.09,70.04 142.86,70.82 160.07,70.82 160.07,70.81 169.08,70.81 169.76,70.13 174.08,70.13 174.28,69.93 174.8,69.93 175.58,69.14 175.6,69.14 175.7,69.04 175.7,68.41 175.67,68.4 175.55,68.3 175.48,68.16 174.82,68.1 175.48,68.04 175.55,67.89 175.67,67.8 175.7,67.78 175.7,67.63 175.67,67.61 175.61,67.58 175.56,67.53 175.48,67.5 175.4,67.53 174.95,67.57 174.88,67.12 174.88,66.71 174.83,66.58 174.84,66.44 174.84,66.41 174.56,66.13 173.64,66.13 173.4,66.37 173.4,67.2 173.15,67.45 172.5,67.45 171.94,66.89 165.4,66.89 165.23,67.06 165.23,67.08 165.14,67.35 164.88,67.44 164.86,67.44 164.82,67.48 164.3,67.48 164.27,67.51 161.18,67.51 159.8,68.89 155.34,68.89 153.93,67.48
+1.8V_3.3V_ALW_VTR3 on TOP: 276.67,2.99 276.35,3.3 276.35,4.83 276.48,4.95 277.12,4.95 277.24,4.83 277.24,4.19 277.37,4.07 277.88,4.07 278,3.94 278,3.15 277.84,2.99
+1.8V_GFX_AON on TOP (solid shape): 215.39,49.09 215.39,47.5 215.52,47.37 215.52,46.51 215.42,46.41 214.85,46.41 214.51,46.07 213.79,46.07 213.65,46.21 213.65,46.93 213.98,47.27 214.07,47.3 214.15,47.24 214.34,47.07 214.6,47.08 214.78,47.24 214.81,47.49 214.77,47.59 214.69,47.68 214.69,48.39 214.19,48.9 214.19,49.4 214.25,49.47 215.01,49.47
+1.8V_GFX_AON on BOTTOM (solid shape): 215.24,65.25 215.24,65.14 215.45,64.93 215.45,64.58 215.63,64.4 215.63,64.21 215.49,64.07 215.24,64.07 214.99,64.19 214.74,64.07 214.56,64.07 214.07,64.57 214.07,65.2 214.25,65.38 215.11,65.38
+1.8V_GFX_AON on TOP: 214.53,61.4 214.53,61.41 214.41,61.66 214.17,61.75 214.09,61.75 214.01,61.72 213.83,61.72 213.77,61.78 213.77,62.52 213.76,62.54 213.76,63.26 213.96,63.46 213.96,63.83 214.05,63.92 214.05,65.3 214.19,65.44 215.5,65.44 215.54,65.41 215.86,65.41 215.87,65.42 216.32,65.42 216.52,65.22 217.93,65.22 217.93,65.21 219.22,65.21 219.75,64.69 219.94,64.89 221.93,64.89 222.21,64.61 222.21,62.42 224.68,59.95 224.68,58.55 223.62,57.49 221.9,57.49 219.22,60.17 219.22,61.3 217.87,62.65 216.7,62.65 216.33,62.27 216.32,62.08 216.41,61.91 216.44,61.84 216.41,61.77 216.4,61.77 216.4,61.62 216.36,61.55 215.96,61.15 215.46,61.15 215.45,61.16 214.77,61.16
+1.8V_GFX_AON on TOP: 240.4,50.29 239.77,50.93 239.27,50.93 238.89,50.55 235.08,50.55 234.06,51.56 234.06,52.58 234.19,52.71 239.9,52.71 239.95,52.66 241.73,52.66 242.32,52.07 243.33,52.07 243.46,51.94 243.46,50.93 242.83,50.29
+1.8V_GFX_AON on TOP: 208.74,52.48 208.93,52.29 208.93,50.98 208.83,50.88 208.83,50.16 208.73,50.06 206.89,50.06 206.75,50.2 206.75,51.72 207.51,52.48
+1.8V_GFX_AON on TOP: 227.15,49.91 229.89,49.91 231.41,51.43 231.41,52.04 231.5,52.13 232.18,52.13 232.25,52.06 232.25,49.63 231.14,48.52 227.89,48.52 227.5,48.13 227.5,46.91 226.92,46.33 226.92,45.99 226.68,45.75 226.44,45.75 226.3,45.9 226.3,47.75 225.97,48.08 223.78,48.08 223.58,47.87 223.58,46.16 223.09,45.67 220.93,45.67 220.4,45.14 219.21,45.14 219.08,45.26 219.08,45.87 219.19,45.98 219.72,45.98 220.05,46.31 222.1,46.31 222.96,47.16 222.96,48.54 222.23,49.26 221.46,49.26 221.45,49.27 221.45,49.88 221.48,49.91 224.87,49.91 225.02,49.76 225.02,49.25 225.03,49.24 225.03,49.14 225.08,49.09 225.09,49.01 225.41,48.54 225.77,48.97 225.8,49.05 225.87,49.09 226.83,49.09 226.88,49.14 226.88,49.64
+1.8V_GFX_AON on TOP: 198.16,49.05 199.18,49.05 199.18,49.06 199.74,49.62 199.74,49.86 200,50.12 200,50.45 200.18,50.62 200.76,50.62 200.89,50.75 200.89,51.56 200.81,51.64 200.36,51.64 199.65,52.35 199.65,53.24 199.32,53.56 199.32,54.1 199.33,54.1 199.52,54.29 200.22,54.29 200.43,54.08 200.43,52.5 200.56,52.38 201.83,52.38 201.93,52.27 201.93,49.71 201.09,48.87 200.66,48.87 200.63,48.9 200.27,48.9 199.9,48.53 199.9,47.29 199.8,47.19 199.26,47.19 199.13,47.31 198.96,47.35 198.16,46.55 198.16,46.18 197.83,45.85 197.3,45.85 197.21,45.94 197.21,47.14 197.31,47.25 197.97,47.25 198.01,47.28 198.01,48.9
+1.8V_GFX_AON on BOTTOM: 211.7,48.29 211.67,48.38 211.73,48.46 211.86,49.04 211.27,48.92 211.2,48.86 211.11,48.89 210.76,49.23 207.94,49.23 207.06,48.35 203.27,48.35 201.3,50.33 201.3,52.58 200.72,53.15 198.88,53.15 198.69,53.34 198.69,54.17 198.76,54.23 201.35,54.23 202.05,53.53 202.06,53.53 207.78,53.53 207.98,53.73 207.98,55.26 208.2,55.48 209.47,55.48 209.64,55.31 209.64,54.76 209.65,54.75 209.65,54.71 209.69,54.71 210.05,54.35 210.21,54.35 210.22,54.35 211.27,54.35 212.09,55.17 212.85,55.17 213.17,54.85 213.17,54.18 215.91,51.44 215.91,47.97 215.54,47.59 212.4,47.59
+1.8V_GFX_AON on IN2: 206.95,52.8 219,52.8 221.79,50.01 233.9,50.01 234.64,50.76 246.08,50.76 246.43,50.4 246.43,46.29 245.61,45.47 236.38,45.47 235.86,45.99 218.99,45.99 217.95,47.03 214.3,47.03 213.53,47.79 208.7,47.79 206.71,49.79 206.71,52.55
+1.8V_GFX_AON on IN5: 213.77,47.91 212.35,49.34 208.22,49.34 206.93,48.05 205.34,48.05 205.07,48.33 205.07,52.03 205.44,52.4 206.58,52.4 209.23,55.06 209.23,62.99 212.33,66.09 215.77,66.09 215.93,65.94 215.93,63.47 215.97,63.43 215.97,61.79 216.11,61.64 216.11,61.15 215.84,60.88 215.84,59.25 215.77,59.19 215.77,58.53 215.73,58.52 215.44,58.17 215.73,57.82 215.77,57.81 215.77,57.69 215.77,57.61 215.77,57.45 215.72,57.36 215.61,57.37 215.43,57.44 215.24,57.41 215.13,57.33 215.06,57.2 215.23,56.77 215.68,56.88 215.73,56.9 215.77,56.87 215.77,56.86 215.77,56.84 215.84,56.77 216.06,56.56 216.43,56.56 220.86,52.13 225.51,52.13 227.1,50.54 228.78,50.54 229.02,50.78 229.05,50.77 229.41,50.93 229.41,51.33 229.38,51.36 229.45,51.43 229.66,51.22 229.65,51.19 230.26,50.87 229.94,51.47 229.91,51.47 229.51,51.87 227.29,51.87 226.93,52.23 226.91,52.34 227,52.4 238.67,52.4 238.68,52.36 239.03,52.07 239.38,52.36 239.39,52.4 250.07,52.4 252.37,50.1 253.82,48.65 253.82,48.02 253.75,47.94 240.79,47.94 240.76,47.91
+1.8V_GFX_AON on IN5: 245.28,110.03 245.28,110.49 245.46,110.67 246.88,110.67 246.88,110 246.67,109.79 245.52,109.79
+1.8V_GFX_RUN on BOTTOM (solid shape): 199.96,57.6 199.96,57.15 199.65,56.83 199.65,55.88 199.39,55.63 197.99,55.63 197.8,55.82 197.8,57.85 198.12,58.17 199.39,58.17
+1.8V_GFX_RUN on IN1 (solid shape): 191.52,89.54 191.52,88.01 190.95,87.44 190.56,87.44 190.18,87.82 190.18,88.96 190.88,89.66 191.39,89.66
+1.8V_GFX_RUN on TOP: 197.69,56.88 197.55,57.02 197.55,58 196.39,59.17 195.73,59.17 195.12,59.78 195.12,63.12 196.6,64.6 198.93,64.6 200.08,65.75 200.3,65.75 200.81,66.26 200.96,66.26 201.05,66.34 201.05,66.76 201.17,66.88 201.98,66.88 202.06,66.8 202.06,65.26 201.37,64.57 201.32,64.57 200.49,63.75 200.49,62.52 200.37,62.39 199.13,62.39 198.67,61.94 198.21,61.94 197.86,61.59 197.86,60.53 198.13,60.26 200.09,60.26 200.85,59.5 200.85,57.72 200.01,56.88
+1.8V_GFX_RUN on TOP: 210.26,50.02 210.18,50.11 210.18,50.9 210.29,51 211.08,51 211.71,51.64 211.71,53.02 210.5,54.23 210.5,54.24 208.74,56.01 208.74,58.87 209.5,59.63 209.54,59.74 209.54,59.82 209.56,59.89 209.62,59.93 209.74,59.99 209.82,60.11 209.82,60.12 209.94,60.24 209.99,60.23 209.99,63.82 210.5,64.33 212.87,64.33 213.09,64.12 213.47,64.12 213.57,64.02 213.57,60.59 213.18,60.2 213.18,58.7 213.11,58.63 213.11,57.21 213.24,57.08 213.24,56.53 213.34,56.43 213.34,56.41 213.36,56.32 213.41,56.24 213.42,56.23 213.42,56.22 213.49,56.15 213.49,53.32 213.49,51.03 213.49,50.22 213.29,50.02
+1.8V_GFX_RUN on TOP: 192.53,86.2 190.85,86.2 190.38,86.67 190.38,89.47 190.83,89.92 192.53,89.92 193.04,89.41 193.04,86.7
+1.8V_GFX_RUN on IN1: 199.58,59.37 201.33,57.63 204.25,57.63 206.57,59.95 206.57,64.45 207.46,65.34 214.29,65.34 214.74,64.9 214.74,63.95 214.45,63.65 214.45,63.24 212.22,61.01 210.9,61.01 210.59,60.71 210.59,58.84 212.22,57.21 212.22,55.86 210.18,53.82 199.87,53.82 197.42,56.26 197.42,58.93 197.87,59.37
+1.8V_GFX_RUN on IN3: 213.54,64.33 213.54,62.28 213.13,61.88 212.62,61.88 212.27,61.52 212.27,58.9 212.98,58.19 212.98,56.36 211.91,55.3 209.86,55.3 208.57,56.58 206.34,56.58 205.79,57.13 205.79,57.78 204.39,59.18 202.19,59.18 200.06,57.06 198.98,57.06 197.55,58.48 197.55,61.34 197.87,61.66 202.04,61.66 204.87,64.49 213.37,64.49
+1.8V_GFX_RUN_R on BOTTOM (solid shape): outline of 535 points within 194.8,68.21 202.25,81.79
+1.8V_GFX_RUN_R on TOP: outline of 102 points within 193.46,67.62 203,85.41
+1.8V_GFX_RUN_R on IN1: 199.49,82.23 199.57,82.23 199.58,82.21 199.84,82.01 200.15,82.1 200.22,82.13 200.29,82.1 200.53,81.85 200.53,79.88 201.48,78.93 201.51,78.85 201.47,78.78 201.43,78.24 201.97,78.28 202.04,78.32 202.12,78.29 202.5,77.92 202.5,69.66 201.55,68.71 200.66,68.71 200.34,69.03 200.34,72.32 200.29,72.38 200.28,72.41 199.94,72.65 199.6,72.41 199.59,72.39 196.6,72.39 194.37,74.61 194.37,81.79 194.64,82.05 194.71,82.08 194.78,82.05 195.12,81.95 195.38,82.2 195.39,82.23 195.48,82.23 195.49,82.19 195.84,81.92 196.18,82.19 196.19,82.23 196.27,82.23 196.28,82.2 196.62,81.94 196.97,82.2 196.98,82.23 197.08,82.23 197.1,82.2 197.44,81.94 197.78,82.2 197.79,82.23 197.87,82.23 197.88,82.2 198.21,81.97 198.55,82.2 198.56,82.23 198.83,82.23 198.85,82.21 199.16,82.02 199.48,82.21
+1.8V_PCH on TOP: 96.19,13.16 95.62,13.73 92.95,13.73 92.69,13.47 92.69,12.18 93.72,11.15 93.72,10.24 93.67,10.19 92.86,10.19 91.01,12.05 90.53,12.05 90.46,12.12 90.46,12.55 90.03,12.98 90.03,14.37 90.27,14.61 90.91,14.61 91.08,14.78 91.08,15.46 91.18,15.56 91.79,15.56 93,16.77 101.53,16.77 102.26,16.03 102.26,13.51 101.91,13.16
+1.8V_PCH on TOP: 119.76,11.43 119.64,11.56 119.64,13.47 120.01,13.84 120.53,13.84 120.88,14.2 122.06,14.2 122.47,14.61 124.72,14.61 124.84,14.48 124.84,13.09 124.49,12.74 123.74,12.74 123.57,12.57 123.57,11.46 123.54,11.43
+1.8V_PCH on BOTTOM: 92.35,11.76 92.1,11.76 91.92,11.58 91.92,10.24 92.23,9.93 92.23,8.56 92.36,8.42 92.36,8.33 93.51,7.17 93.74,7.17 93.99,6.92 94.17,6.92 94.27,7.02 94.27,7.22 93.99,7.51 93.72,7.51 93.34,7.88 93.34,8.13 93.34,8.13 93.34,9.89 93.32,9.91 93.32,10.53 93.49,10.7 93.84,10.7 93.95,10.81 93.95,11.12 93.85,11.22 93.56,11.22 93.37,11.22 93.18,11.03 92.77,11.03 92.47,11.34 92.47,11.64
+1.8V_PCH on IN4: 118.75,13.08 118.75,13.59 119,13.84 120.71,13.84 120.97,13.59 120.97,12.96 120.71,12.7 119.13,12.7
+1.8V_PCH on IN4: 100.97,14.61 100.97,14.1 101.22,13.84 102.36,13.84 103.25,14.73 103.25,15.11 103,15.37 103,15.75 102.74,16 102.24,16 102.11,16.13 101.98,16.13 101.73,15.88 101.73,15.37
+1.8V_PCH_I_LDO on BOTTOM: 90.93,14.61 89.54,14.61 89.41,14.48 89.41,14.29 89.73,13.97 90.87,13.97 91.06,14.16 91.06,14.48
+1.8V_PCH_LDO on TOP: 90.81,14.82 90.24,14.82 89.75,15.31 89.75,16.13 89.91,16.3 90.87,16.3 91.08,16.09 91.08,15.81 90.91,15.65 90.91,14.92
+1.8V_PCH_LDO on BOTTOM: 89.41,14.92 90.58,14.92 91.08,15.41 91.08,16.09 91,16.17 90.71,16.17 90.61,16.07 90.61,15.71 90.51,15.61 90.23,15.61 90.09,15.75 89.87,15.75 89.33,15.2 89.33,15
+1.8V_PLLVDD on TOP (solid shape): 204.47,62.29 204.47,61.34 203.2,60.07 203.2,57.98 202.95,57.72 201.55,57.72 201.23,58.04 201.23,59.44 199.9,60.77 199.9,62.1 199.96,62.17 200.41,62.17 200.47,62.1 200.47,61.22 201.11,60.58 202.44,60.58 203.01,61.15 203.01,62.29 203.07,62.36 204.41,62.36
+1.8V_PLLVDD on BOTTOM: 199.84,55.88 199.84,56.77 200.15,57.09 200.15,57.85 200.53,58.23 201.49,58.23 201.61,58.36 201.61,58.61 201.93,58.93 203.33,58.93 203.46,58.8 203.46,57.02 203.14,56.71 201.68,56.71 201.55,56.58 201.55,54.61 201.3,54.36 198.44,54.36 198.38,54.42 198.38,55.25 198.63,55.5 199.45,55.5
+1.8V_PLLVDD on IN1: 201.68,57.79 203.58,57.79 204.6,58.8 204.6,66.8 203.52,67.88 199.2,67.88 193.42,73.66 193.42,83.69 191.26,85.85 190.31,85.85 189.49,85.03 189.49,71.5 196.91,64.07 196.91,62.55
+1.8V_PLLVDD on IN2: outline of 130 points within 189.74,78.78 213.63,84.96
+1.8VALW on TOP (solid shape): 246.38,51.69 248.79,51.69 248.92,51.56 248.92,50.86 248.35,50.29 245.49,50.29 244.79,50.99 244.79,52.01 244.86,52.07 246,52.07
+1.8VALW on BOTTOM (solid shape): 243.64,96.97 243.64,96.46 243.66,96.44 244.34,96.44 244.37,96.48 244.37,96.97 244.38,96.98 244.82,96.98 244.83,96.97 244.83,96.47 244.83,96.44 244.84,96.43 245.56,96.43 245.57,96.45 245.57,96.97 245.58,96.98 246.1,96.98 246.36,96.73 246.36,93.65 245.97,93.27 243.13,93.27 242.85,93.55 242.85,96.29 242.86,96.3 242.86,96.77 243.08,96.99 243.62,96.99
+1.8VALW on TOP: 275.67,3 274.19,3 274.1,3.09 274.1,4.73 274.32,4.95 275.59,4.95 275.85,4.7 275.85,3.18
+1.8VALW on TOP: 126.13,13.32 126.13,14.48 126.29,14.63 127.03,14.63 127.27,14.4 127.27,9.6 129.91,6.96 129.91,6.22 130.4,5.72 132.18,5.72 132.34,5.57 132.34,4.45 131.83,3.94 131.83,3.81 131.32,3.3 129.13,3.3 128.11,4.33 128.11,6.2 126.79,7.52 123.06,7.52 122.34,8.25 122.34,10.65 122.94,11.26 123.92,11.26 124.29,11.63 124.29,12.33 124.47,12.51 125.7,12.51 125.98,12.78 125.98,13.16
+1.8VALW on BOTTOM: 245.24,10.56 246.94,10.56 249.12,12.74 249.12,13.88 249.47,14.23 252.25,14.23 252.88,13.59 252.88,10.44 248.68,6.24 246.77,6.24 242.19,1.65 232.16,1.65 231.27,2.54 231.27,4.95 231.78,5.46 238,5.46 238.76,6.22 241.17,6.22 241.43,6.48 241.43,7.24 241.68,7.49 243.84,7.49 244.1,7.75 244.1,9.42
+1.8VALW on BOTTOM: 6.2,10.92 6.19,10.91 6.19,10.28 6.05,10.14 5.21,10.14 5.1,10.25 5.1,12.56 5.2,12.66 6.09,12.66 6.2,12.55
+1.8VALW on IN1: 62.51,20.68 65.14,20.68 65.62,20.21 65.62,19.37 65.36,19.12 61.95,19.12 61.04,20.03 58.44,20.03 55.05,23.42 52.09,23.42 50.99,22.33 49.68,22.33 49.31,22.69 47.88,22.69 47.75,22.82 47.75,23.32 48.07,23.63 49.51,23.63 50.38,24.5 55.12,24.5 57.73,21.89 61.2,21.89 61.74,21.35 61.74,20.76 61.85,20.65 62.49,20.65
+1.8VALW on IN4: 245.14,96.16 234.97,96.16 231.42,92.61 231.42,52.31 233.83,49.91 239.51,49.91 239.52,49.91 248.81,49.91 248.98,50.09 248.98,53.53 247.94,54.58 242.38,54.58 241.1,55.85 235.76,55.85 235.59,56.03 235.59,89.72 236.89,91.03 239.45,91.03 239.5,90.97 243.36,90.97 245.48,93.08 245.48,95.83
+1.8VALW on VCC: 205.37,1.17 204.76,1.96 204.07,2.52 203.2,2.72 186.44,2.72 186.42,5.68 185.64,6.48 184.99,6.48 177.31,6.48 176.43,5.59 152.04,5.59 148.87,2.41 133.96,2.41 132.31,4.07 114.25,4.07 112.88,5.44 112.88,7.33 113.3,7.75 114.22,7.75 115.75,6.22 129.14,6.22 130.54,7.62 139.17,7.62 140.7,9.15 145.82,9.15 146.33,8.64 232.79,8.65 235.11,5.76 235.92,5.79 267.46,5.79 268.45,4.83 275.17,4.82 275.5,4.83 275.78,4.56 275.78,2.97 251.95,2.97 251.26,2.82 250.7,2.41 248.54,4.42 246.16,2.69 245.76,1.17
+1.8VALW on IN6: 252.1,13.4 248.86,13.4 245.81,16.45 245.81,26.1 252.15,32.44 252.15,42.42 245.75,48.82 245.75,51.12 246.44,51.82 249.37,51.82 256.34,44.84 256.34,28.88 252.79,25.34 252.79,14.1
+1.8VS_AUDIO on BOTTOM: 6.68,11.95 6.46,12.18 6.46,13.97 5.25,13.97 5.18,14.04 5.18,15.09 5.21,15.11 7.92,15.11 8.14,14.89 8.14,12.89 7.82,12.56 7.82,12.11 7.76,12.06 7.29,12.06 7.28,12.06 7.15,12.06 7.04,11.95
+1.35VS_B+ on TOP: 194.95,113.67 199.77,113.67 199.9,113.54 199.9,112.27 199.77,112.14 198.12,112.14 197.61,112.65 196.22,112.65 195.26,111.7 194.76,111.7 194.69,111.76 194.69,113.41
+1.35VS_B+ on BOTTOM: 195.2,115.32 198.12,115.32 198.12,113.41 198.25,113.29 199.77,113.29 199.9,113.16 199.9,112.14 199.77,112.02 198.12,112.02 197.36,111.25 193.55,111.25 193.3,111.51 193.3,112.4 194.57,113.67 194.57,114.68
+1.35VS_VGAP on TOP (solid shape): 216.44,119.6 216.44,115.73 215.65,114.94 212.47,114.94 211.58,115.83 208.53,115.83 207.9,116.46 207.9,118.75 208.34,119.19 215.33,119.19 215.9,119.76 216.28,119.76
+1.35VS_VGAP on BOTTOM (solid shape): 216.44,119.6 216.44,115.67 215.79,115.01 209.75,115.01 209.17,114.43 206.76,114.43 206.63,114.56 206.63,119.06 206.76,119.19 215.08,119.19 215.65,119.76 216.28,119.76
+1.35VS_VGAP on IN1 (solid shape): 216.03,119 216.03,115.32 215.77,115.06 208.54,115.06 208.28,115.32 208.28,119 208.54,119.25 215.77,119.25
+1.35VS_VGAP on IN2 (solid shape): 216.03,119 216.03,115.32 215.77,115.06 208.54,115.06 208.28,115.32 208.28,119 208.54,119.25 215.77,119.25
+1.35VS_VGAP on IN3 (solid shape): 216.03,119 216.03,115.32 215.77,115.06 208.54,115.06 208.28,115.32 208.28,119 208.54,119.25 215.77,119.25
+1.35VS_VGAP on IN4 (solid shape): 216.03,119 216.03,115.32 215.77,115.06 208.54,115.06 208.28,115.32 208.28,119 208.54,119.25 215.77,119.25
+1.35VS_VGAP on IN5 (solid shape): 216.03,119 216.03,115.32 215.77,115.06 208.54,115.06 208.28,115.32 208.28,119 208.54,119.25 215.77,119.25
+1.35VS_VGAP on IN6 (solid shape): 216.03,119 216.03,115.32 215.77,115.06 208.54,115.06 208.28,115.32 208.28,119 208.54,119.25 215.77,119.25
+1.35VSDGPU on TOP (solid shape): 211.84,113.81 211.84,112.57 211.8,112.53 204.36,112.53 204.24,112.65 204.24,113.73 204.41,113.89 211.75,113.89
+1.35VSDGPU on TOP (solid shape): 219.57,119.77 219.57,116.85 219.91,116.51 220.7,116.51 220.78,116.43 220.78,116.16 220.27,115.65 220.27,114.96 220.8,114.43 220.8,112.37 220.63,112.19 217.25,112.19 216.59,112.85 216.59,116.99 217.13,116.99 217.15,117.01 217.15,119.74 217.55,120.14 219.2,120.14
+1.35VSDGPU on TOP (solid shape): 223.7,88.46 223.9,88.46 223.98,88.38 223.98,87.95 223.88,87.85 222.62,87.85 222.34,87.56 221.68,87.56 221.68,87.57 221.28,87.57 221.21,87.64 220.33,87.64 220.22,87.76 219.52,87.76 219.44,87.84 219.44,88.46 219.44,88.46 219.44,88.6 219.47,88.62 223.53,88.62
+1.35VSDGPU on TOP (solid shape): 207.87,80.1 207.87,78.89 207.79,78.81 207.02,78.81 206.96,78.74 204.84,78.74 204.78,78.75 204.71,78.74 204.1,78.74 203.92,78.91 203.92,79.99 204.02,80.09 204.3,80.09 204.47,80.27 207.71,80.27
+1.35VSDGPU on TOP (solid shape): 245.92,63.1 246.21,63.1 246.35,62.95 246.35,62.64 246.14,62.42 243.9,62.42 243.73,62.6 243.73,63.03 244.59,63.03 244.59,62.98 244.6,62.93 244.61,62.88 244.64,62.83 244.67,62.79 244.7,62.75 244.75,62.72 244.79,62.7 244.84,62.68 244.89,62.67 244.94,62.67 245,62.68 245.05,62.7 245.09,62.72 245.13,62.75 245.17,62.79 245.2,62.83 245.22,62.88 245.24,62.93 245.25,62.98 245.25,63.03 245.24,63.08 245.22,63.13 245.2,63.18 245.17,63.22 245.13,63.26 245.09,63.29 245.05,63.31 245,63.33 244.94,63.34 244.89,63.34 244.84,63.33 244.79,63.31 244.75,63.29 244.7,63.26 244.67,63.22 244.64,63.18 244.61,63.13 244.6,63.08 244.59,63.03 243.73,63.03 243.73,63.22 243.83,63.32 244.55,63.32 244.72,63.5 244.78,63.47 244.84,63.46 244.89,63.45 244.95,63.45 245,63.47 245.05,63.49 245.08,63.5 245.52,63.5
+1.35VSDGPU on TOP (solid shape): outline of 83 points within 248.48,78.8 251.14,82.49
+1.35VSDGPU on BOTTOM (solid shape): 219.57,119.77 219.57,116.85 219.91,116.51 220.7,116.51 220.78,116.43 220.78,116.16 220.27,115.65 220.27,114.96 220.8,114.43 220.8,112.37 220.63,112.19 217.25,112.19 216.59,112.85 216.59,116.99 217.13,116.99 217.15,117.01 217.15,119.74 217.55,120.14 219.2,120.14
+1.35VSDGPU on TOP: 210.37,78.81 209.67,78.81 209.67,80.01 209.42,80.26 209.49,80.33 209.93,80.33 209.95,80.35 209.97,80.34 210.14,80.36 210.27,80.45 210.32,80.53 210.36,80.61 210.37,80.65 211.31,80.65 211.32,80.61 211.57,80.36 211.91,80.44 212.03,80.33 213.37,80.33 213.45,80.25 213.45,79.15 213.04,78.74 211.71,78.74 211.47,78.5 211.44,78.51 211.31,78.53 211.18,78.49 211.17,78.49 210.68,78.49
+1.35VSDGPU on BOTTOM: outline of 134 points within 199.98,64.04 216.56,80.52
+1.35VSDGPU on IN1: outline of 395 points within 200.79,64.2 219.33,82.77
+1.35VSDGPU on IN3: outline of 350 points within 202.19,54.42 250.67,117.48
+1.35VSDGPU on VCC: 221.47,53.6 221.11,53.95 221.11,81.01 204.22,97.9 204.22,109.14 204.6,109.52 204.6,117.53 205.14,118.05 227.29,118.05 230.68,114.68 241.6,114.68 246.55,109.73 250.33,109.73 250.33,99 250.51,98.25 251.01,97.66 251.83,97.05 251.83,65.9 252.45,59.63 254.28,53.6
+1V_MPHY_MPHYPLL on BOTTOM: 70.04,27.76 70.04,26 70.38,25.66 72.82,25.66 73.52,24.96 75.27,24.96 75.59,25.28 75.59,26.43 75.47,26.56 75.34,26.56 74.92,26.98 74.92,27.59 74.62,27.9 70.18,27.9
+1V_PCH on BOTTOM (solid shape): 85.19,19.69 86.69,19.69 86.86,19.52 86.86,19.3 86.96,19.2 87.36,19.2 87.36,19.19 87.43,19.12 87.43,18.74 87.17,18.48 84.27,18.48 83.95,18.8 83.95,19.05 84.55,19.66 84.67,19.66 84.7,19.68 85.17,19.68
+1V_PCH on BOTTOM (solid shape): 90.68,19.15 90.68,18.14 90.51,17.97 87.8,17.97 87.76,18.02 87.76,18.46 88.05,18.74 88.06,18.75 88.13,18.76 88.18,18.8 88.49,18.8 88.62,18.67 88.88,18.67 88.99,18.77 89.36,18.77 89.44,18.69 89.7,18.69 90.29,19.28 90.55,19.28
+1V_PCH on BOTTOM (solid shape): 84.7,16.45 84.7,16.12 84.64,16.06 84.64,15.67 84.71,15.6 84.71,15.39 84.54,15.22 84.54,14.36 84.43,14.26 84.42,14.25 84.34,14.2 84.28,14.12 83.72,14.12 83.45,14.39 83.45,15.25 83.46,15.32 83.45,15.39 83.45,15.47 83.34,15.58 83.33,15.58 83.33,16.09 83.54,16.3 84.08,16.3 84.21,16.43 84.22,16.43 84.28,16.46 84.34,16.5 84.65,16.5
+1V_PCH on TOP: outline of 83 points within 74.45,11.47 113.29,31.31
+1V_PCH on BOTTOM: 99.77,28.63 104.52,28.63 104.67,28.47 104.67,27.43 104.45,27.2 100.13,27.2 98.88,25.96 98.55,25.96 98.38,26.14 98.38,26.42 98.22,26.57 97.92,26.57 97.82,26.67 97.82,26.9 97.87,26.95 98.81,26.95 98.93,27.08 98.93,27.43 99.52,28.02 99.52,28.37
+1V_PCH on BOTTOM: 113.17,10.85 112.3,11.72 111.68,11.72 111.35,11.39 110.94,11.39 110.64,11.69 110.64,17.29 110.78,17.43 118.2,17.43 118.37,17.25 118.37,15.69 117.79,15.1 114.31,15.1 113.95,14.74 113.95,14.1 114.87,13.17 114.87,10.85
+1V_PCH on VCC: 83.51,13.33 83.06,13.78 83.06,19.7 93.7,19.7 103.84,29.84 104.57,29.11 104.57,27.2 105.11,26.67 107.2,26.67 110.6,26.67 111.99,28.07 120.93,28.07 121.41,27.58 121.41,26.67 121.41,13.79 121.41,13.75 121.14,13.47 120.84,13.46 118.11,13.46 114.79,13.46 113.39,14.86 106.96,14.86 105.42,13.33 101.2,13.33 100.43,14.1 91.59,14.1 90.82,13.33
+1V_PCH_CLK5 on BOTTOM: 99.43,21.16 99.39,21.2 97.76,21.2 97.66,21.1 97.66,20.88 97.78,20.76 97.91,20.76 98.03,20.64 98.52,20.64 99.18,19.98 100.75,19.98 101.07,19.66 101.07,19.24 101.18,19.13 101.74,19.13 101.74,20.85 102.11,21.22 102.11,21.83 102.26,21.98 102.26,22.94 102.2,23.01 101.5,23.01 101.36,22.87 101.36,21.33 101.19,21.16
+1V_PCH_PRIM on BOTTOM (solid shape): 85.61,17.17 85.88,17.17 85.99,17.29 86.26,17.29 86.37,17.17 86.79,17.17 86.93,17.04 86.93,15.12 86.64,14.83 86.35,14.83 86.29,14.89 86.26,14.94 86.22,14.99 86.22,15.03 85.83,15.42 85.52,15.42 84.99,14.89 84.83,14.89 84.68,15.05 84.68,15.19 84.81,15.32 84.84,15.35 84.84,15.74 84.76,15.81 84.76,15.95 84.81,15.99 84.81,16.5 84.75,16.56 84.75,16.85 85.19,17.3 85.48,17.3
+1V_PCH_PRIM on BOTTOM (solid shape): 89.28,17.27 89.28,17.26 89.55,16.99 89.78,16.99 90.07,16.7 90.07,16.18 89.63,15.73 89.5,15.73 89.22,16.01 89.22,16.02 89.08,16.16 88.52,16.16 88.41,16.04 88.41,15.21 87.79,14.6 87.54,14.6 87.42,14.73 87.42,14.91 87.51,15 87.51,15.38 87.39,15.5 87.39,15.69 87.49,15.82 87.49,15.98 87.49,16 87.44,16.07 87.38,16.12 87.38,16.33 87.55,16.5 87.55,16.58 87.55,16.58 87.55,16.84 87.39,17 87.39,17.14 87.94,17.68 88.87,17.68
+1V_PCH_PRIM on TOP: 84.96,17.02 85.17,17.22 86.26,17.22 86.34,17.15 86.34,17.14 86.39,17.09 86.39,16.5 86.45,16.43 86.61,16.43 86.91,16.13 86.91,15.54 86.34,14.97 86.34,14.48 86.21,14.35 85.4,14.35 84.96,14.78
+1V_PCH_PRIM on BOTTOM: 114.66,14.95 119.42,14.95 119.64,14.73 119.64,13.34 119.38,13.08 119.25,13.08 119.25,13.46 119.22,13.5 117.77,13.5 117.73,13.46 117.73,13.08 117.6,13.08 117.37,13.31 115.09,13.31 114.28,14.12 114.28,14.57
+1V_PCH_PRIM on IN2: 86.56,15.08 86.53,15.12 84.57,15.12 84.33,15.37 84.33,15.89 84.42,15.98 84.74,15.98 85.02,16.26 85.02,17.31 85.12,17.41 90.16,17.41 90.28,17.29 90.28,15.56 89.76,15.8 89.8,15.23 89.07,15.23 88.93,15.08
+1V_PCH_PRIM on IN5: 104.72,11.87 104.49,12.1 101.82,12.1 101.78,12.14 101.41,12.14 101.18,12.24 100.96,12.14 95.53,12.14 95.3,12.24 95.07,12.14 94.84,12.14 94.82,12.17 94.59,12.37 94.3,12.26 94.22,12.22 94.14,12.26 93.85,12.38 93.61,12.18 93.6,12.14 91.34,12.14 91.33,12.15 91.23,12.16 91.14,12.15 91.13,12.14 88.85,12.14 88.83,12.17 85.67,12.17 84.1,13.73 84.1,17.4 86.59,19.89 100.43,19.89 104.14,16.18 107.24,16.18 107.54,16.49 107.55,16.49 108.49,17.42 117.15,17.42 119.09,15.49 119.09,13.79 118.86,13.56 115.9,13.56 115.47,13.13 110.49,13.13 109.2,11.84 104.77,11.84 104.73,11.87
+1VALW on BOTTOM (solid shape): 194.45,56.69 194.45,53.99 194.12,53.66 192.6,53.66 192.15,54.1 192.15,55.69 191.71,56.14 191.71,58.04 193.1,58.04
+1VALW on BOTTOM (solid shape): 184.54,85.37 184.54,82.89 184.5,82.85 182.86,82.85 182.8,82.92 182.14,82.92 181.77,83.29 181.01,83.29 180.91,83.38 180.91,83.9 180.98,83.96 181.6,83.96 181.67,83.89 182.69,83.89 182.86,84.05 182.86,85.2 182.59,85.47 182.59,85.52 182.57,85.54 182.57,85.65 182.58,85.65 182.58,86.31 182.68,86.41 183.5,86.41
+1VALW on IN4 (solid shape): 184.16,86.17 184.16,85.14 184.88,84.42 184.88,84.05 184.16,83.33 183.64,83.33 182.59,84.38 182.59,86.25 182.87,86.53 183.81,86.53
+1VALW on IN4 (solid shape): 193.41,58.94 193.41,56.83 193.2,56.62 191.99,56.62 191.79,56.82 191.79,58.89 191.97,59.08 193.27,59.08
+1VALW on TOP: 181.31,86.74 182.02,86.74 182.23,86.54 182.6,86.44 182.87,86.71 182.88,86.74 183.55,86.74 184.13,86.17 184.13,83.57 183.52,82.96 179.43,82.96 179.38,83.01 179.38,84.62 179.45,84.7 180.63,84.7 180.77,84.83 180.77,86.2 181.14,86.57 181.14,86.57
+1VALW on BOTTOM: 121.15,17.37 143.31,17.37 143.57,17.63 173.69,17.63 176.79,20.73 176.79,26.93 178.12,28.26 178.12,32.2 179.2,33.28 180.72,33.28 182.5,31.5 182.5,25.98 180.94,24.42 180.94,23.03 181.97,22 181.97,18.21 177.72,13.97 137.69,13.97 134.44,10.72 125.66,10.72 122.43,7.49 122.43,7.48 122.33,7.38 121.81,7.38 121.8,7.38 121.8,7.93 121.79,7.93 121.06,7.93 121.05,7.92 121.05,7.39 121.05,7.38 120.6,7.38 120.6,7.39 120.6,7.92 120.59,7.93 119.87,7.93 119.85,7.92 119.85,7.39 119.85,7.38 116.93,7.38 115.01,9.3 115.01,12.92 115.25,13.15 116.96,13.15 117.43,12.69 119.44,12.69 119.99,13.23 119.99,16.21
+1VS_GFX on TOP (solid shape): 225.33,117.74 225.33,115.76 225.11,115.54 223.73,115.54 222.51,116.76 222.51,117.48 222.86,117.83 225.24,117.83
+1VS_GFX on BOTTOM: 225.16,117.87 225.3,117.73 225.3,116.52 225.24,116.46 224.68,116.46 224.68,115.95 225.24,115.95 225.3,115.89 225.3,114.62 224.96,114.28 222.31,114.28 221.82,114.77 221.82,117.49 222.2,117.87
+1VS_GFX on IN4: 195.64,87.41 197.74,87.41 201.36,83.79 201.38,83.76 201.41,83.72 201.44,83.68 201.47,83.6 201.41,83.52 201.25,83.08 201.68,82.86 201.68,82.87 201.74,82.87 201.74,82.73 201.68,82.73 201.53,82.7 201.4,82.61 201.36,82.57 201.28,82.52 201.19,82.56 200.68,82.64 200.63,82.13 200.7,82.07 200.78,82.02 201.02,82.02 201.2,82.17 201.28,82.22 201.37,82.17 201.4,82.13 201.44,82.1 201.55,82.03 201.68,82.02 201.74,82.02 201.74,81.88 201.68,81.88 201.31,81.54 201.65,81.17 201.71,81.14 201.74,81.07 201.74,78.94 201.74,78.94 201.74,68.38 201.74,68.38 201.74,68.09 201.7,68.06 201.66,68.03 201.53,67.89 201.53,65.91 201.74,65.69 201.74,61.28 205.26,57.76 226.52,57.76 227.35,58.59 227.35,91.44 221.01,97.78 221.01,117.23 221.49,117.71 224.05,117.71 224.66,117.1 224.66,101.7 231.08,95.28 231.08,55.45 230.14,54.51 195.75,54.51 193.68,56.58 193.68,85.45
+1VSP on TOP: 126.71,7.28 127.06,6.92 127.06,6.16 126.82,5.92 124.33,5.92 123.98,5.56 123.98,5.03 124.05,4.95 124.54,4.95 124.77,5.18 126.52,5.18 126.77,4.93 126.77,4.27 126.77,4.27 126.77,4.12 126.59,3.94 120.02,3.94 119.76,4.19 119.76,6.63 120.41,7.28
+1VSP on BOTTOM: 119.34,7.24 119.93,7.24 119.99,7.24 119.99,7.25 119.99,7.31 119.99,7.78 120,7.79 120.45,7.79 120.46,7.78 120.46,7.25 120.47,7.24 121.17,7.24 121.19,7.26 121.19,7.77 121.2,7.79 121.65,7.79 121.66,7.78 121.66,7.25 121.67,7.24 122.74,7.24 123.5,7.99 126.5,7.99 127.06,7.43 127.06,4.44 126.5,3.88 126.03,3.88 126.01,3.86 119.6,3.86 119.36,4.1 119.36,6.52 119.23,6.64 119.23,7.14
+2.5V_MEM on BOTTOM (solid shape): 250.45,30.16 250.45,27.12 250.27,26.94 249.62,26.94 249.51,27.05 249.51,28.64 249.52,28.66 249.52,29.88 249.87,30.23 250.38,30.23
+2.5V_MEM on BOTTOM (solid shape): 177.55,29.72 177.55,28.68 175.83,26.96 173.3,26.96 173.21,27.05 173.21,29.67 173.38,29.85 177.42,29.85
+2.5V_MEM on IN5 (solid shape): 250.45,31.05 250.45,29.21 250.25,29.02 249.56,29.02 249.3,29.27 249.3,30.86 249.75,31.31 250.19,31.31
+2.5V_MEM on IN5 (solid shape): 180.6,31.34 180.6,30.91 178.08,28.4 176.05,28.4 175.87,28.58 175.87,29.16 176.63,29.92 177.7,29.92 179.53,31.75 180.19,31.75
+2.5V_MEM on TOP: 180.7,17.4 180.5,17.21 178.83,17.21 178.59,17.45 178.59,20.91 178.28,21.21 178.28,25.5 175.83,27.95 175.83,29.15 176.2,29.51 177.93,29.51 181.5,25.94 181.5,23.21 181.96,22.75 181.96,20.92 181.79,20.75 180.95,20.75 180.7,20.5
+3.3V_1.8V_PGPPA on TOP: 118.49,9.65 119.76,9.65 119.81,9.7 119.81,10.5 119.38,10.92 119.38,12.83 119.1,13.11 118.41,13.11 118.24,12.94 118.24,9.91 118.24,9.91
+3.3VDX_SSD on TOP: 275.21,6.54 275.02,6.73 275.02,7.43 274.83,7.62 274.83,8.76 274.96,8.89 275.51,8.89 276.4,9.78 277.24,9.78 277.37,9.91 277.37,10.92 277.5,11.05 278.64,11.05 278.77,11.18 278.77,11.43 278.89,11.56 279.91,11.56 280.04,11.43 280.04,10.29 278,8.26 278,6.67 277.88,6.54
+3.3VDX_SSD on BOTTOM: 276.18,5.64 275.02,4.48 267.41,4.48 267.21,4.69 267.21,5.84 267.33,5.96 269.99,5.96 270.77,6.73 270.77,6.74 270.95,6.93 270.95,9.78 268.95,11.79 268.95,14.03 269.3,14.39 269.3,17.4 269.3,17.41 269.3,18.22 268.89,18.62 267.32,18.62 267.2,18.74 267.2,20.33 267.34,20.47 268.73,20.47 268.99,20.73 268.99,21.9 268.75,22.14 267.31,22.14 267.23,22.22 267.23,22.78 267.69,23.24 271.47,23.24 272.86,21.85 272.86,18.12 273.61,17.37 273.61,14.52 276.18,11.95
+3.3VDX_SSD on IN1: 269.2,12.47 270.77,12.47 271.06,12.18 271.06,9.95 270.35,9.23 269.88,9.23 269.73,9.39 269.73,9.55 268.89,10.38 268.89,12.16
+3.3VDX_SSD on IN3: 269.11,12.32 271.02,12.32 272.04,13.34 280.54,13.34 280.8,13.08 280.8,10.42 280.42,10.03 271.4,10.03 270.38,9.02 269.88,9.02 268.86,10.03 268.86,12.07
+3.3VDX_SSD on IN6: 271.65,14.23 279.15,14.23 280.54,12.83 280.54,9.4 279.78,8.64 274.07,8.64 272.04,10.67 268.61,10.67 268.1,11.18 268.1,12.7 268.48,13.08 270.51,13.08
+3V_LDOP on TOP: 73.37,29.9 73.01,29.9 72.14,29.03 72.14,28.86 73.62,27.38 73.62,26.58 73.87,26.33 74.67,26.33 75.1,26.76 75.1,27.21 73.89,28.43 73.89,29.38
+3V_PCH on BOTTOM (solid shape): 81.83,17.47 81.83,17.47 81.92,17.38 81.92,16.82 82.09,16.64 82.55,16.64 82.67,16.52 82.67,15.31 82.32,14.96 81.33,14.96 81.2,15.09 81.2,17.4 81.31,17.5 81.8,17.5
+3V_PCH on BOTTOM (solid shape): 87.5,12 89.15,12 89.43,11.73 89.43,11.55 89.34,11.45 88.96,11.45 88.58,11.07 88.34,11.12 88.13,10.99 88.11,10.97 88.05,10.97 87.62,10.99 87.77,10.59 87.77,10.45 86.03,10.45 85.93,10.55 85.9,10.64 85.96,10.71 86.15,11.12 85.76,11.34 85.68,11.36 85.64,11.44 85.64,11.93 85.71,12 86.89,12 87.07,12.18 87.33,12.18
+3V_PCH on TOP: 99.95,3.49 99.95,4.72 99.95,4.72 100,4.76 100.75,4.76 100.84,4.67 101.25,4.67 101.63,5.05 101.63,5.21 101.8,5.37 102.53,5.37 102.62,5.28 102.62,4.36 102.57,4.36 101.73,3.52 101.73,1.76 101.46,1.49 100.34,1.49 100.12,1.71 100.12,2.73 100.13,2.74 100.13,3.31
+3V_PCH on TOP: 81.89,17.6 82.2,17.6 82.32,17.48 82.32,17.19 82.62,16.89 82.62,15.6 83.31,14.91 83.31,14.33 85.07,12.57 85.8,12.57 86.16,12.22 86.16,11.69 86.01,11.53 85.85,11.53 85.42,11.96 84.3,11.96 82.22,14.05 82.22,14.48 81.84,14.86 80.07,14.86 79.92,15.01 79.92,15.43 79.8,15.55 79.04,15.55 78.69,15.91 78.69,16.7 78.72,16.73 79.27,16.73 79.42,16.59 79.92,16.59 80.42,17.09 80.42,17.47 80.24,17.65 79.83,17.65 79.71,17.78 79.71,18.39 79.96,18.64 79.96,21.08 81.43,22.56 87.71,22.56 88.02,22.24 88.02,20.61 88.16,20.47 88.61,20.47 88.65,20.43 88.65,19.69 88.65,19.69 88.65,19.38 88.52,19.25 87.86,19.25 86.18,20.93 84.41,20.93 83.44,19.97 81.03,19.97 80.87,19.81 80.87,18.62
+3V_PCH on TOP: 107.09,3.89 107.06,3.92 107.06,4.49 107.16,4.59 108.69,4.59 108.83,4.74 108.83,5.95 108.33,6.45 108.33,7.09 109.14,7.9 111.46,7.9 112.27,8.71 112.57,8.71 113.01,9.15 113.18,9.15 113.56,8.76 114.22,8.76 115.06,7.93 115.39,7.93 115.98,8.51 116.41,8.51 116.61,8.71 116.61,10.08 116.74,10.21 117.3,10.21 117.37,10.14 117.37,8.26 116.82,7.7 116.38,7.7 115.85,7.16 115.84,7.16 114.63,5.96 112.15,5.96 111.98,5.78 111.98,5.3 113.25,4.03 113.25,2.07 113.07,1.89 112.64,1.89 112.45,2.08 112.45,3.56 112.12,3.89
+3V_PCH on TOP: 87.62,2.67 88.21,2.08 94.58,2.08 94.98,2.49 94.98,3.15 93.85,4.28 93.85,6.35 93.98,6.48 93.98,7.24 94.55,7.81 94.84,7.81 95.17,8.14 95.62,8.14 96.24,7.52 96.24,5.63 96.7,5.18 96.7,1.35 96.52,1.17 85.94,1.17 85.69,1.42 85.69,2.62 85.74,2.67
+3V_PCH on TOP: outline of 93 points within 58.46,1.17 78.43,15.88
+3V_PCH on BOTTOM: 94.9,8.45 94.9,8.2 94.92,8.18 94.92,7.78 95.65,7.05 95.65,6.81 95.74,6.71 95.97,6.71 96.01,6.75 96.01,8.32 95.76,8.57 95.03,8.57
+3V_PCH on BOTTOM: 111.6,8.88 111.6,9.41 111.71,9.51 112.07,9.51 112.26,9.32 113.34,9.32 113.49,9.16 113.49,8.56 113.33,8.4 112.08,8.4
+3V_PCH on VCC: 62.15,1.17 61.85,1.62 61.85,4.1 62.08,4.33 66.92,4.33 67.28,4.69 67.7,5.11 74.19,5.08 74.4,5.08 78.21,5.08 87.77,5.09 87.77,5.09 88.77,5.1 89.65,5.1 89.68,5.07 99.4,5.07 109.35,5.08 112.52,5.08 114.04,3.56 132.1,3.56 133.75,1.91 149.08,1.91 152.25,5.08 176.64,5.08 177.53,5.97 184.99,5.98 185.43,5.98 185.92,5.47 185.93,5.35 185.93,2.72 153,2.72 152.24,2.53 151.64,2.02 151.03,1.17
+3V_PCH_AZIO on TOP: 93.25,6.5 93.3,6.45 93.63,6.45 93.7,6.38 93.7,5.96 93.65,5.91 92.36,5.91 92.13,6.14 92.13,6.66 92.43,6.96 92.43,7.72 92.6,7.89 93.3,7.89 93.4,7.79 93.4,7.19 93.25,7.04
+3V_PCH_BR on TOP (solid shape): 58.32,4.9 58.32,4.29 57.94,3.91 57.81,3.91 57.77,3.87 57.77,3.01 57.75,2.99 56.11,2.99 55.82,3.28 55.82,4.89 55.88,4.95 58.26,4.95
+3V_PCH_DSW on TOP: 145.9,13.09 146.64,13.09 147.02,13.46 147.02,14.99 146.89,15.11 146.03,15.11 145.9,14.99 145.9,14.64 145.8,14.55 145.8,13.18
+3V_PCH_DSW on IN1: 80.09,3.1 73.66,3.1 73.51,2.95 73.51,2.45 73.66,2.3 77.12,2.3 77.71,1.71 77.83,1.71 77.84,1.7 81.33,1.7 81.79,2.16 81.79,2.64 81.69,2.74 80.44,2.74
+3V_PCH_DSW_RR on TOP: 141.51,13.3 141.3,13.09 141.3,11.54 141.66,11.17 143.17,11.17 143.68,11.68 143.68,12.59 144.17,13.07 145.4,13.07 145.46,13.14 145.46,13.7 145.42,13.74 143.62,13.74 143.18,13.3
+3V_PS8723 on TOP: 326.74,38.49 326.74,34.1 326.51,33.87 325.79,33.87 325.17,34.5 324.41,34.5 324.27,34.36 324.27,33.23 324.53,32.98 327.68,32.98 327.71,33 328.22,33 328.81,33.59 328.81,36.54 329.08,36.81 329.08,38.89 329.06,38.9 329.06,40.15 328.65,40.56 326.79,40.56 326.73,40.5 326.73,38.49
+3V_PS8723 on TOP: 318.64,35.18 318.14,35.18 317.93,35.38 317.93,38.02 318.08,38.17 319.97,38.17 321.14,37 321.14,36.63 321.12,36.6 320.28,36.6 320.2,36.68 320.2,36.98 319.63,37.54 318.87,37.54 318.74,37.41 318.74,35.28
+3V_PS8723 on BOTTOM: 326.58,38.37 326.58,35.61 326.94,35.25 328.41,35.25 328.78,35.63 328.78,36.81 329.14,37.17 329.14,38.21 328.7,38.65 326.86,38.65
+3V_PS8723 on IN2: 316.83,36.86 316.83,34.04 317.59,33.28 319.03,33.28 319.7,33.95 319.7,36.79 320.05,37.13 323.88,37.13 324.1,36.91 328.82,36.91 328.95,37.04 328.95,38.55 328.64,38.86 318.83,38.86
