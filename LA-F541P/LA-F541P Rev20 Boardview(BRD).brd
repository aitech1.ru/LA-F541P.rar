# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_DP2_AUXP: length 184.9
  TOP w0.152: v2(35.93,35.99) 35.82,36.11 35.82,37.02 35.64,37.2 35.64,38.37 v3(35.06,38.94) 34.75,39.26 34.06,39.26 CT108.2
  IN3 w0.089: v2(174.52,78.32) 174.68,78.49 174.68,78.63 174.6,78.72 174.36,78.72 174.05,78.41 173.86,78.41 173.66,78.62 173.66,79.42 172.46,80.62 170.99,80.62 170.65,80.28 ; 80.84,29.21 80.86,29.2 80.86,29.19 81.04,29 85.76,29
  IN3 w0.099: 85.76,29 88.43,29 92.37,32.95 95.9,32.95 100.99,38.04 114.95,38.04 134.45,57.54 134.73,57.54 134.74,57.54 134.76,57.54 ; 80.84,29.21 80.71,29.34 80.15,29.34 79.68,28.87 77.13,28.87 76.48,29.52 75.31,29.52 75.08,29.29 74.04,29.29 73.96,29.38 71.49,29.38 70.1,27.99 68.58,27.99 68.01,28.56 55.86,28.56 55.36,29.06 53.3,29.06 52.65,28.41 43.64,28.41 40.93,31.11 40.93,31.78 40.15,32.57 40.15,33.38 39.44,34.09 38.98,34.09 37.58,35.49 35.94,35.49 35.76,35.68 35.76,35.82 v2(35.93,35.99)
  IN3 w0.112: 134.76,57.54 135.5,57.54 137.4,59.45 137.4,65.8 137.15,66.05 137.15,68.62 137.75,69.22 137.75,70.99 138.11,71.36 139.94,71.36 140.62,72.03 141.4,72.03 142.21,72.84 142.76,72.84 143.04,73.12 143.04,79.46 143.57,80 152.27,80 153.12,79.15 169.51,79.15 170.65,80.28
  BOTTOM w0.076: v2(174.52,78.32) 174.83,78.63 UH1.F26
CPU_DP2_AUXP_C: length 4.6
  TOP w0.089: v2(30.61,40.22) 30.49,40.11 30.49,40.02 30.7,39.82 30.79,39.82 31.09,40.12 31.19,40.12 31.29,40.02 31.29,39.89 31.15,39.75 v1(31.15,39.63) 31.31,39.48 31.84,39.48 32.03,39.29 33.28,39.29 CT108.1
  BOTTOM w0.102: UT1.Y12 v2(30.61,40.22)
CPU_DP2_N0: length 191.8
  IN3 w0.099: v2(174.35,83.92) 174.1,84.16 174.1,84.25 173.81,84.55 173.81,88.22 174.34,88.75 174.34,89.82 173.44,90.72 169.33,90.72 168.67,91.38 164.45,91.38 163.15,92.68 136.04,92.68 135.88,92.68 132.37,89.18 132.37,87.11 130.82,85.56 130.82,83.36 127.6,80.15 127.6,67.22 122.84,62.47 122.4,62.47 119.8,59.87 119.8,53.73 116.42,50.34 116.42,49.02 114.85,47.46 110.84,47.46 110.41,47.89 108.45,47.89 103.79,43.23 97.91,43.23 94.72,40.04 93.23,40.04 90.98,37.8 90.22,37.8 85.55,33.13 84.84,33.13 84.2,33.77 83.04,33.77 82.93,33.65 81.5,33.65 80.6,34.55 73.21,34.55 72.85,34.18 70.18,34.18 68.91,32.91 66.62,32.91 65.73,33.8 61.45,33.8 61.05,34.19 58.98,34.19 58.59,33.8 49.68,33.8 48.9,33.01 46.79,33.01 44.27,35.54 43.41,35.54 42,36.95 42,37.23 41.16,38.08 40.96,38.08 v2(40.74,38.29)
  BOTTOM w0.076: v2(174.35,83.92) 174.04,83.61 UH1.H33
  BOTTOM w0.152: CT30.2 35.22,38.16 36.42,38.16 36.61,37.97 v3(38.74,37.97) 39.25,37.97 39.52,38.24 40.69,38.24 v2(40.74,38.29)
CPU_DP2_N0_C: length 3.2
  BOTTOM w0.102: UT1.AC15 32.01,38.52 31.94,38.59 31.94,38.68 32.02,38.75 32.37,38.75 32.49,38.64 32.49,38.57 32.9,38.15 33.1,38.15
  BOTTOM w0.152: 33.1,38.15 34.37,38.15 CT30.1
CPU_DP2_N1: length 186.8
  IN3 w0.099: v2(176.88,89.32) 176.88,89.15 176.76,89.03 176.57,89.03 176.27,89.32 176.27,90.48 174.2,92.56 172.05,92.56 170.69,93.92 164.78,93.92 163.7,95 134.11,95 129.21,90.09 129.21,89.01 124.55,84.35 124.55,71.57 122.27,69.29 122.27,67.34 117.87,62.94 117.87,57.95 114.27,54.35 112.23,54.35 103.01,45.12 95.62,45.12 90.08,39.59 89.41,39.59 87.48,37.66 86.33,37.66 85.56,36.89 83.04,36.89 82.95,36.81 47.22,36.81 46.65,37.38 45.39,37.38 44.25,38.52 43.62,38.52 43.18,38.96 42.23,38.96 41.98,38.7 41.98,38.61 v2(41.58,38.22)
  BOTTOM w0.076: v2(176.88,89.32) 176.88,88.76 176.82,88.7 175.12,88.7 174.62,88.2 174.62,87.33 174.55,87.26 174.31,87.26 174.2,87.15 174.2,86.99 174.32,86.86 UH1.G38
  BOTTOM w0.152: CT32.2 37.09,36.89 40.6,36.89 41.7,38 41.7,38.1 41.62,38.18 v2(41.58,38.22)
CPU_DP2_N1_C: length 5.1
  BOTTOM w0.102: UT1.AC17 32.01,37.6 31.94,37.67 31.94,37.76 32.02,37.83 32.37,37.83 32.49,37.72 32.49,37.59 32.73,37.34 33.26,37.34 33.39,37.21
  BOTTOM w0.152: 33.39,37.21 33.43,37.18 35.21,37.18 35.38,37.01 36.09,37.01 CT32.1
CPU_DP2_N2: length 188.7
  IN3 w0.099: v2(42.73,37.56) 42.9,37.39 43.12,37.39 43.44,37.07 43.44,36.55 43.82,36.17 44.55,36.17 45.38,35.35 47.89,35.35 48.7,34.54 49.67,34.54 50.02,34.89 52.76,34.89 53.04,34.61 54.68,34.61 54.93,34.86 55.47,34.86 55.82,35.21 58.63,35.21 58.98,34.87 61.07,34.87 61.15,34.79 65.94,34.79 67.09,33.64 68.79,33.64 70.12,34.97 71.02,34.97 71.25,35.19 71.77,35.19 72.15,35.57 80.42,35.57 81.7,34.29 82.49,34.29 82.61,34.42 84.42,34.42 84.96,33.88 85.47,33.88 89.98,38.39 90.7,38.39 93,40.69 94.3,40.69 97.46,43.85 103.56,43.85 108.19,48.48 112.76,48.48 115.58,51.3 116.21,51.3 119.13,54.23 119.13,60.33 121.98,63.18 122.6,63.18 126.99,67.57 126.99,80.38 130.04,83.43 130.04,87.07 130.91,87.94 130.91,88.95 132.47,90.51 132.47,91.31 134.76,93.6 163.15,93.6 164.76,91.99 168.9,91.99 169.56,91.33 173.69,91.33 174.99,90.03 174.99,88.72 174.44,88.16 174.44,85.87 174.87,85.43 174.87,84.82 v2(175.08,84.61)
  BOTTOM w0.076: UH1.F35 174.99,84.61 v2(175.08,84.61)
  BOTTOM w0.152: v2(42.73,37.56) 42.63,37.46 42.32,37.46 40.87,36.01 v3(40.3,36.01) 39.39,36.01 38.92,35.55 38.54,35.55 CT34.2
CPU_DP2_N2_C: length 6.8
  BOTTOM w0.089: 33.8,35.83 33.74,35.83 32.85,36.72 32.49,36.72 32.29,36.92 32.01,36.92 31.93,36.84 31.93,36.75 32.01,36.68 UT1.AC19
  BOTTOM w0.152: CT34.1 37.66,35.54 v3(36.5,35.54) 34.8,35.54 34.65,35.69 33.94,35.69 33.8,35.83
CPU_DP2_N3: length 186.6
  IN3 w0.099: v2(43.8,37.24) 44.04,37 44.04,36.84 44.28,36.6 44.71,36.6 45.47,35.84 46.7,35.84 46.88,36.02 83.37,36.02 83.39,36.04 84.91,36.04 85.08,35.87 86.84,35.87 89.76,38.8 90.43,38.8 95.93,44.3 103.37,44.3 110.09,51.02 111.36,51.02 112.16,51.82 113.9,51.82 114.54,52.46 114.54,53.51 118.72,57.68 118.72,62.6 119.81,63.69 121.62,63.69 123.96,66.03 123.96,69.06 126.16,71.26 126.16,84.81 130.75,89.4 130.75,90.3 134.59,94.14 153.06,94.14 163.27,94.14 165,92.41 169.05,92.41 169.69,91.77 173.84,91.77 175.42,90.19 175.42,88.82 174.98,88.38 174.98,88.11 v2(175.63,87.47)
  BOTTOM w0.076: v2(175.63,87.47) 175.67,87.42 175.67,86.54 175.79,86.41 175.79,86.08 175.48,85.77 UH1.E36
  BOTTOM w0.152: CT36.2 36.47,34.56 v3(39.83,34.56) 42.28,34.56 43.95,36.23 43.95,37.1 v2(43.8,37.24)
CPU_DP2_N3_C: length 5.3
  BOTTOM w0.089: 33.66,34.4 33.63,34.4 33.6,34.36 33.06,34.36 32.71,34.71 32.71,35.49 32.47,35.73 32.47,35.9 32.37,36 32.11,36 32.03,35.92 32.03,35.82 UT1.AC21
  BOTTOM w0.152: 33.66,34.4 34.31,34.4 34.39,34.48 v3(34.84,34.48) 35.58,34.48 CT36.1
CPU_DP2_P0: length 191.7
  IN3 w0.099: v2(173.53,83.91) 173.79,83.91 173.91,84.04 173.91,84.17 173.62,84.47 173.62,88.3 174.15,88.83 174.15,89.74 173.36,90.53 169.25,90.53 168.59,91.19 164.37,91.19 163.07,92.49 135.96,92.49 132.56,89.1 132.56,87.03 131.01,85.48 131.01,83.29 127.79,80.07 127.79,67.15 122.92,62.28 122.48,62.28 119.99,59.79 119.99,53.65 116.61,50.26 116.61,48.94 114.93,47.27 110.76,47.27 110.33,47.7 108.53,47.7 103.87,43.04 97.99,43.04 94.8,39.85 93.31,39.85 91.06,37.61 90.3,37.61 85.63,32.94 84.76,32.94 84.12,33.58 83.12,33.58 83,33.46 81.42,33.46 80.52,34.35 73.29,34.35 72.92,33.99 70.26,33.99 68.99,32.72 66.54,32.72 65.65,33.6 61.37,33.6 60.97,34 59.06,34 58.66,33.6 49.76,33.6 48.98,32.82 46.72,32.82 44.19,35.35 43.33,35.35 41.81,36.87 41.81,37.15 41.08,37.89 40.92,37.89 v2(40.74,37.71)
  BOTTOM w0.076: v2(173.53,83.91) 173.55,83.91 UH1.H34
  BOTTOM w0.152: CT29.2 35.26,37.83 36.28,37.83 36.47,37.64 39.39,37.64 39.66,37.91 40.54,37.91 v2(40.74,37.71)
CPU_DP2_P0_C: length 3.2
  BOTTOM w0.102: UT1.AB15 31.86,38.29 32.36,38.29 32.83,37.82 33.06,37.82
  BOTTOM w0.152: 33.06,37.82 34.34,37.82 CT29.1
CPU_DP2_P1: length 186.8
  IN3 w0.099: v2(42.17,38.21) 42.17,38.62 42.31,38.77 43.1,38.77 43.54,38.33 44.17,38.33 45.31,37.19 46.57,37.19 47.14,36.62 83.03,36.62 83.12,36.7 85.64,36.7 86.41,37.47 87.56,37.47 89.49,39.4 90.16,39.4 95.7,44.93 103.09,44.93 112.31,54.16 114.35,54.16 118.06,57.87 118.06,62.86 122.46,67.26 122.46,69.21 124.74,71.49 124.74,84.28 129.4,88.93 129.4,90.01 134.19,94.81 163.62,94.81 164.7,93.73 170.61,93.73 171.97,92.37 174.12,92.37 176.08,90.4 176.08,89.24 176.49,88.84 v2(177.32,88.84)
  BOTTOM w0.076: UH1.F37 174.69,86.7 174.87,86.89 174.87,88.09 175.23,88.45 176.93,88.45 v2(177.32,88.84)
  BOTTOM w0.152: v2(42.17,38.21) 42.03,38.07 42.03,37.86 40.73,36.56 37.12,36.56 CT31.2
CPU_DP2_P1_C: length 5
  BOTTOM w0.089: 33.66,36.85 v3(33.57,36.85)
  BOTTOM w0.102: UT1.AB17 31.86,37.37 32.31,37.37 32.61,37.06 33.15,37.06 33.33,36.88
  BOTTOM w0.152: CT31.1 36.08,36.68 35.24,36.68 35.08,36.85 33.66,36.85 ; v3(33.57,36.85) 33.36,36.85 33.33,36.88
CPU_DP2_P2: length 188.7
  IN3 w0.099: v2(42.73,36.97) 42.96,37.2 43.04,37.2 43.25,36.99 43.25,36.47 43.74,35.98 44.47,35.98 45.3,35.16 47.81,35.16 48.62,34.35 49.75,34.35 50.1,34.7 52.69,34.7 52.96,34.42 54.76,34.42 55.01,34.67 55.55,34.67 55.9,35.02 58.55,35.02 58.9,34.68 60.99,34.68 61.07,34.6 65.86,34.6 67.01,33.45 68.87,33.45 70.2,34.78 71.1,34.78 71.32,35 71.85,35 72.23,35.38 80.34,35.38 81.62,34.1 82.57,34.1 82.69,34.23 84.34,34.23 84.88,33.69 85.54,33.69 90.06,38.2 90.78,38.2 93.08,40.5 94.38,40.5 97.53,43.66 103.63,43.66 108.27,48.29 112.84,48.29 115.66,51.11 116.29,51.11 119.32,54.15 119.32,60.26 122.06,62.99 122.68,62.99 127.18,67.49 127.18,80.3 130.23,83.35 130.23,86.99 131.1,87.86 131.1,88.88 132.66,90.43 132.66,91.23 134.84,93.41 163.07,93.41 164.68,91.8 168.82,91.8 169.48,91.14 173.61,91.14 174.8,89.95 174.8,88.8 174.25,88.24 174.25,85.79 174.68,85.36 174.68,84.77 174.49,84.58 v2(174.3,84.58)
  BOTTOM w0.076: UH1.F34 174.37,84.58 v2(174.3,84.58)
  BOTTOM w0.152: v2(42.73,36.97) 42.58,37.13 42.45,37.13 41.01,35.68 39.52,35.68 39.06,35.22 38.56,35.22 CT33.2
CPU_DP2_P2_C: length 6.9
  BOTTOM w0.089: 33.56,35.59 33.56,35.62 32.74,36.45 31.86,36.45 UT1.AB19
  BOTTOM w0.152: 33.56,35.59 33.8,35.36 34.51,35.36 34.66,35.21 37.66,35.21 CT33.1
CPU_DP2_P3: length 186.6
  IN3 w0.099: v2(44.39,37.24) 44.23,37.08 44.23,36.92 44.36,36.79 44.79,36.79 45.55,36.03 46.63,36.03 46.8,36.21 83.29,36.21 83.31,36.23 84.99,36.23 85.16,36.07 86.76,36.07 89.69,38.99 90.35,38.99 95.85,44.49 103.29,44.49 110.01,51.21 111.28,51.21 112.08,52.01 113.82,52.01 114.35,52.54 114.35,53.59 118.53,57.76 118.53,62.67 119.73,63.88 121.54,63.88 123.77,66.11 123.77,69.14 125.97,71.34 125.97,84.89 130.56,89.48 130.56,90.38 134.51,94.33 163.35,94.33 165.08,92.6 169.13,92.6 169.77,91.96 173.92,91.96 175.61,90.27 175.61,88.74 175.17,88.3 175.17,88.19 175.31,88.05 v2(175.59,88.05)
  BOTTOM w0.076: v2(175.59,88.05) 175.21,87.68 175.21,87.34 175.49,87.07 175.49,86.23 UH1.E37
  BOTTOM w0.152: CT35.2 36.51,34.23 42.42,34.23 44.28,36.1 44.28,37.13 v2(44.39,37.24)
CPU_DP2_P3_C: length 5.3
  BOTTOM w0.089: UT1.AB21 31.86,35.53 32.29,35.53 32.44,35.38 32.44,34.6 32.52,34.52 32.52,34.51 32.94,34.1 33.6,34.1 33.63,34.07 33.66,34.07
  BOTTOM w0.152: CT35.1 35.49,34.15 34.53,34.15 34.45,34.07 33.66,34.07
CPU_DP3_AUXN: length 244.1
  TOP w0.152: v2(14.98,71.51) 14.98,71.37 15.05,71.3 15.46,71.3 CM46.2
  IN6 w0.089: v2(177.08,79.14) 177.17,79.05 177.26,79.05 177.46,79.25 177.46,80.04 178.98,81.56 179.87,81.56 179.88,81.57 179.9,81.57
  IN6 w0.107: v2(14.98,71.51) 14.55,71.07 14.48,71.07 14.32,71.24 14.32,71.58 14.68,71.93 15.54,71.93 15.79,71.68 16.57,71.68 16.72,71.83 18.33,71.83 18.71,71.45 25.33,71.45 26.7,70.07 26.7,65.56 27.28,64.99 27.28,60.6 27.94,59.94 27.94,58.39 28.46,57.87 28.46,56.2 28.78,55.89 28.78,54.13 30.54,52.38 31.23,52.38 31.87,51.74 31.87,50.08 33.91,48.04 33.91,47.4 35.95,45.35 35.95,45.03 42.52,38.47 43.9,38.47 45.17,37.2 46.49,37.2 47.1,36.59 71.13,36.59 72.35,35.37 75.06,35.37 75.81,36.12 85.19,36.12 85.54,35.77 86.86,35.77 87.85,36.75 87.85,37.53 89.79,39.47 93.46,39.47 98.94,44.96 103.13,44.96 107.59,49.43 107.59,54.82 108.35,55.58 111.93,55.58 112.41,56.06 114.97,56.06 116.97,58.05 116.97,64.34 117.75,65.12 119,65.12 124.79,70.92 124.79,72.8 125.68,73.69 125.68,75.98 130.21,80.51 130.21,83.85 130.79,84.42 130.79,85.29 132.69,87.2 132.69,88.64 136.29,92.24 164.3,92.24 165.12,91.42 174.14,91.42 175.61,89.94 177.04,89.94 178.82,88.16 179.94,88.16 180.72,87.38 180.72,82.02 180.27,81.57 179.9,81.57
  BOTTOM w0.076: UH1.B27 177.44,79.5 177.44,79.11 177.32,78.99 177.11,78.99 177.08,79.03 v2(177.08,79.14)
CPU_DP3_AUXN_C: length 3.5
  TOP w0.152: CM21.1 17.64,71.04 17.64,71.24 17.92,71.53 18.1,71.53 18.2,71.43 18.2,71.21 18.31,71.1 18.48,71.1 18.79,71.41 18.79,71.67 19.23,72.11 19.46,72.11 UM1.C8
CPU_DP3_AUXN_R: length 1.9
  TOP w0.152: CM21.2 17.2,70.82 16.83,71.18 v2(16.7,71.18) 16.37,71.18 CM46.1
  BOTTOM w0.152: RM26.2 16.71,71.19 v2(16.7,71.18)
CPU_DP3_AUXP: length 244.1
  TOP w0.152: CM45.2 15.36,70.97 15.07,70.97 v2(14.98,70.87)
  IN6 w0.089: 179.9,81.37 179.88,81.37 179.87,81.37 179.06,81.37 177.65,79.96 177.65,79.27 v2(177.8,79.12)
  IN6 w0.107: v2(14.98,70.87) 14.98,70.87 14.4,70.87 14.12,71.15 14.12,71.66 14.59,72.14 15.62,72.14 15.88,71.88 16.49,71.88 16.64,72.04 18.42,72.04 18.8,71.65 25.41,71.65 26.91,70.16 26.91,65.65 27.48,65.07 27.48,60.68 28.14,60.02 28.14,58.48 28.66,57.95 28.66,56.29 28.98,55.97 28.98,54.22 30.62,52.58 31.31,52.58 32.07,51.83 32.07,50.16 34.11,48.12 34.11,47.48 36.16,45.44 36.16,45.12 42.6,38.67 43.99,38.67 45.26,37.4 46.57,37.4 47.18,36.79 71.21,36.79 72.43,35.57 74.97,35.57 75.73,36.33 85.27,36.33 85.63,35.97 86.78,35.97 87.64,36.84 87.64,37.61 89.71,39.68 93.37,39.68 98.86,45.16 103.04,45.16 107.39,49.51 107.39,54.9 108.27,55.78 111.84,55.78 112.32,56.26 114.89,56.26 116.76,58.14 116.76,64.42 117.67,65.33 118.91,65.33 124.59,71 124.59,72.88 125.48,73.77 125.48,76.06 130.01,80.59 130.01,83.93 130.58,84.5 130.58,85.38 132.49,87.28 132.49,88.72 136.21,92.44 164.39,92.44 165.21,91.62 174.22,91.62 175.69,90.15 177.12,90.15 178.9,88.37 180.02,88.37 180.92,87.46 180.92,81.93 180.36,81.37 179.9,81.37
  BOTTOM w0.076: UH1.A27 v2(177.8,79.12)
CPU_DP3_AUXP_C: length 3.5
  TOP w0.152: CM20.1 17.87,70.23 18.41,70.77 18.61,70.77 19.12,71.27 19.12,71.53 19.41,71.83 19.97,71.83 UM1.C7
CPU_DP3_AUXP_R: length 2.6
  TOP w0.152: CM45.1 16.37,70.55 16.68,70.55 16.69,70.55 v2(16.72,70.55) 17.04,70.23 CM20.2
  BOTTOM w0.152: v2(16.72,70.55) 16.62,70.55 16.11,71.06 RM25.2
CPU_DP3_N0: length 231.3
  TOP w0.152: CM7.2 19.91,68.22 19.91,67.97 v2(20.07,67.82)
  IN6 w0.089: v2(175.79,83.85) 175.95,84.01 175.95,84.29 176.14,84.48 176.87,84.48 177.1,84.71 177.1,85.17 176.6,85.68 175.81,85.68 175.24,86.25 170.8,86.25 170.11,86.94 170.11,87.8 169.19,88.72 162.85,88.72 162.4,89.17 162.39,89.17
  IN6 w0.107: 162.39,89.17 139.42,89.17 138.83,88.57 138.83,86.83 138.18,86.18 138.18,82.95 137.7,82.47 135.62,82.47 133.78,80.64 133.78,80.13 133.38,79.74 133.17,79.74 132.06,78.62 132.06,77.93 128.3,74.17 128.3,71.88 127.61,71.19 127.61,69.62 127.08,69.09 127.08,68.12 124.8,65.84 123.89,65.84 123.32,65.27 123.32,64.76 121.65,63.1 120.65,63.1 120.2,62.65 120.2,61.65 119.94,61.38 119.94,56.56 117.86,54.48 117.86,52.82 116.52,51.49 114.89,51.49 112.09,48.69 112.09,47.92 110.51,46.34 109.28,46.34 104.87,41.93 102.9,41.93 97.72,36.76 96.58,36.76 96.45,36.88 90.9,36.88 90.54,36.52 90.54,35.26 85.18,29.91 77.76,29.91 76.66,31 67.76,31 67.57,30.81 66.96,30.81 64.76,33.01 60.46,33.01 60.08,33.39 59.4,33.39 58.97,32.96 48.97,32.96 48.51,32.51 46.19,32.51 44.7,33.99 41.43,33.99 40.19,35.23 38.75,35.23 37.43,36.55 35.74,36.55 33.67,38.62 33.67,41.62 33.01,42.28 32.52,42.28 30.3,44.5 27.54,44.5 25.21,46.82 25.21,47.69 24.44,48.47 24.44,52.62 20.98,56.07 20.98,56.7 21.03,56.75 21.03,60.07 21.01,60.1 21.01,61.13 19.79,62.35 19.79,64.69 18.79,65.68 18.79,66.47 18.23,67.03 18.23,68.17 18.77,68.71 19.8,68.71 20.07,68.45 v2(20.07,67.82)
  BOTTOM w0.076: v2(175.79,83.85) 176.13,84.19 UH1.D34
CPU_DP3_N0_C: length 1.8
  TOP w0.152: UM1.A7 20.14,70.4 20.14,69.59 19.97,69.41 19.97,69.06 CM7.1
CPU_DP3_N1: length 225.7
  TOP w0.152: CM15.2 22.1,68.05 v2(22.37,67.78)
  IN6 w0.089: 174.12,89.73 174.13,89.73 174.13,89.7 175.19,88.64 176.31,88.64 176.36,88.58 178.09,86.85 178.45,86.85 178.73,86.58 178.73,86.19 178.99,85.93 178.99,85.36 v2(178.63,85)
  IN6 w0.107: v2(22.37,67.78) 22.17,67.59 22.17,66.92 23.29,65.8 23.29,65.27 23.69,64.87 23.69,63.9 24.91,62.68 24.91,60.85 25.88,59.87 25.88,59.16 26.12,58.93 26.47,58.93 26.91,58.5 26.91,57.97 27.44,57.44 27.44,55.91 26.62,55.09 26.62,54.18 26.35,53.92 26.35,51.73 28.55,49.53 30.93,49.53 31.88,48.58 31.88,47.05 31.75,46.93 31.75,46.48 32.06,46.18 32.68,46.18 33.54,45.31 33.54,45.08 33.97,44.65 33.97,43.46 35.13,42.3 35.13,39.23 36.31,38.05 38.31,38.05 39.68,36.68 40.81,36.68 42.07,35.43 47.83,35.43 48.76,34.5 49.68,34.5 50.08,34.9 52.73,34.9 53.01,34.62 54.67,34.62 54.95,34.89 55.46,34.89 55.64,35.08 56.28,35.08 56.43,35.23 58.64,35.23 59,34.87 60.87,34.87 61.18,34.57 66.77,34.57 68.33,33.01 69.79,33.01 70.31,33.53 75.25,33.53 76.01,34.29 80.11,34.29 80.67,33.73 81.38,33.73 82.4,32.71 85.49,32.71 88.97,36.19 88.97,37.17 90.21,38.4 95.13,38.4 100.53,43.8 104.17,43.8 109.39,49.02 109.39,50.29 112.31,53.21 112.31,53.77 113.53,55 115.45,55 118.15,57.7 118.15,63.34 118.87,64.06 119.45,64.06 125.96,70.57 125.96,72.25 126.75,73.03 126.75,75.55 131.27,80.07 131.27,83.09 133.84,85.66 133.84,88 136.95,91.11 163,91.11 163.83,90.28 173.57,90.28 174.12,89.73
  BOTTOM w0.076: v2(178.63,85) 178.61,85.02 178.34,85.02 178.34,85.02 177.75,85.02 177.61,84.88 177.61,84.87 UH1.B34
CPU_DP3_N1_C: length 1.9
  TOP w0.152: CM15.1 21.95,69.11 21.95,69.5 21.72,69.72 21.72,70.37 UM1.A5
CPU_DP3_N2: length 226.2
  TOP w0.152: CM17.2 23.5,67.95 v2(23.58,67.87)
  IN6 w0.089: v2(175.82,83.05) 175.82,82.84 175.88,82.78 176.1,82.78 176.23,82.91 176.23,83.21 176.29,83.27 178.22,83.27 178.43,83.48 178.86,83.48 179.38,84 179.38,87.51 179.06,87.83 177.79,87.83 176.48,89.14 175.72,89.14 175.16,89.7 175.16,89.72 175.14,89.73
  IN6 w0.107: v2(23.58,67.87) 23.37,67.65 23.37,66.97 23.47,66.87 23.89,66.87 24.48,66.28 25.16,66.28 26.86,64.58 26.86,60.4 27.53,59.73 27.53,58.22 28.05,57.7 28.05,55.82 28.34,55.53 28.34,53.96 29.62,52.68 29.62,51.73 33.5,47.85 33.5,46.24 34.14,45.59 34.14,45.35 34.61,44.88 34.61,43.79 35.76,42.63 35.76,40.92 36.55,40.13 37.92,40.13 38.67,39.38 38.67,38.56 39.93,37.3 41.07,37.3 42.23,36.13 69.69,36.13 70.78,35.05 70.78,34.6 71.22,34.16 74.95,34.16 75.74,34.95 80.49,34.95 81.1,34.34 83.97,34.34 84.57,33.74 85.47,33.74 88.27,36.54 88.27,37.35 89.96,39.04 93.65,39.04 99.13,44.52 103.38,44.52 108.5,49.63 108.5,50.55 110.95,53.01 110.95,53.62 112.95,55.62 115.14,55.62 117.4,57.87 117.4,63.66 118.42,64.68 119.15,64.68 125.22,70.75 125.22,72.48 126.11,73.36 126.11,75.82 130.64,80.35 130.64,83.46 133.2,86.01 133.2,88.38 136.61,91.79 163.73,91.79 164.54,90.97 173.9,90.97 175.14,89.73
  BOTTOM w0.076: UH1.E33 175.48,83.39 v2(175.82,83.05)
CPU_DP3_N2_C: length 1.8
  TOP w0.152: CM17.1 23.32,69.18 23.32,70.37 UM1.A3
CPU_DP3_N3: length 235.2
  TOP w0.152: CM19.2 24.85,68.2 24.85,67.78 v2(24.93,67.69)
  IN6 w0.089: v2(177.62,84.18) 177.62,83.81 177.73,83.7 178,83.7 178.12,83.82 178.12,84.32 177.76,84.67 177.76,85.8 176.66,86.9 171.41,86.9 171.13,87.18 171.13,88.18 169.74,89.58 163.38,89.58 163.26,89.7 163.26,89.72 163.24,89.73
  IN6 w0.107: v2(24.93,67.69) 24.5,67.26 24.5,67.13 24.71,66.92 25.05,66.92 25.38,67.26 25.38,68.12 24.87,68.63 21.81,68.63 21.27,68.09 21.27,66.68 22.58,65.37 22.58,62.58 22.7,62.46 23.83,62.46 24.28,62.01 24.28,60.33 25.24,59.37 25.24,58.53 25.48,58.29 25.48,55.91 25.95,55.43 25.95,54.53 25.72,54.3 25.72,50.79 25.85,50.65 25.85,49.36 27.27,47.95 27.27,47.41 27.51,47.17 27.51,45.73 27.98,45.25 30.6,45.25 32.8,43.05 33.5,43.05 34.49,42.06 34.49,38.97 36.08,37.39 37.81,37.39 39.13,36.07 40.53,36.07 41.79,34.81 45.16,34.81 46.65,33.33 48.17,33.33 48.65,33.81 58.44,33.81 58.86,34.23 60.58,34.23 60.91,33.9 65.89,33.9 67.42,32.37 70.23,32.37 70.76,32.89 73.11,32.89 74.01,32 78.82,32 79.54,31.28 85.21,31.28 89.59,35.66 89.59,36.81 90.55,37.77 95.61,37.77 100.66,42.83 104.27,42.83 110.99,49.54 110.99,50.65 112.31,51.97 113.76,51.97 116.16,54.38 116.57,54.38 118.97,56.78 118.97,59.97 118.83,60.11 118.83,63.06 119.2,63.42 119.74,63.42 120.31,63.99 121.39,63.99 122.48,65.08 122.48,66.15 126.7,70.37 126.7,71.83 127.47,72.6 127.47,75.29 132.23,80.06 132.23,81 134.55,83.32 134.55,87.69 137.15,90.28 162.69,90.28 163.24,89.73
  BOTTOM w0.076: UH1.B33 177.62,83.64 v2(177.62,84.18)
CPU_DP3_N3_C: length 1.8
  TOP w0.152: UM1.A1 24.99,70.45 24.99,70.44 24.89,70.34 24.89,69.1 CM19.1
CPU_DP3_P0: length 231.3
  TOP w0.152: CM6.2 19.58,68.23 19.58,67.97 v2(19.43,67.82)
  IN6 w0.089: v2(176.45,83.86) 176.25,83.86 176.13,83.97 176.13,84.21 176.22,84.3 176.95,84.3 177.29,84.63 177.29,85.25 176.67,85.86 175.89,85.86 175.31,86.43 170.88,86.43 170.3,87.02 170.3,87.88 169.27,88.91 162.92,88.91 162.46,89.37
  IN6 w0.107: 162.46,89.37 139.34,89.37 138.62,88.65 138.62,86.92 137.97,86.27 137.97,83.03 137.62,82.68 135.53,82.68 133.58,80.72 133.58,80.22 133.3,79.94 133.09,79.94 131.86,78.71 131.86,78.02 128.1,74.26 128.1,71.97 127.41,71.27 127.41,69.71 126.87,69.17 126.87,68.2 124.72,66.05 123.81,66.05 123.11,65.35 123.11,64.85 121.57,63.3 120.57,63.3 120,62.73 120,61.73 119.74,61.47 119.74,56.64 117.65,54.56 117.65,52.91 116.43,51.69 114.8,51.69 111.89,48.78 111.89,48.01 110.42,46.54 109.19,46.54 104.79,42.14 102.82,42.14 97.64,36.96 96.66,36.96 96.54,37.09 90.82,37.09 90.34,36.6 90.34,35.35 85.1,30.11 77.84,30.11 76.75,31.21 67.67,31.21 67.48,31.01 67.04,31.01 64.84,33.21 60.55,33.21 60.17,33.6 59.31,33.6 58.88,33.17 48.88,33.17 48.42,32.71 46.27,32.71 44.79,34.19 41.52,34.19 40.28,35.43 38.84,35.43 37.52,36.75 35.82,36.75 33.87,38.71 33.87,41.7 33.09,42.48 32.6,42.48 30.38,44.71 27.62,44.71 25.42,46.91 25.42,47.78 24.64,48.55 24.64,52.7 21.18,56.16 21.18,56.62 21.24,56.67 21.24,60.16 21.21,60.18 21.21,61.22 19.99,62.43 19.99,64.78 19,65.77 19,66.55 18.43,67.12 18.43,68.09 18.85,68.51 19.72,68.51 19.86,68.37 19.86,68.25 v2(19.43,67.82)
  BOTTOM w0.076: v2(176.45,83.86) 176.45,84.33 176.51,84.38 176.66,84.38 UH1.C34
CPU_DP3_P0_C: length 1.9
  TOP w0.152: UM1.A8 19.81,70.35 19.81,69.72 19.64,69.55 19.64,69.17 CM6.1
CPU_DP3_P1: length 225.7
  TOP w0.152: v2(21.78,67.73) 21.46,68.05 CM14.2
  IN6 w0.089: 173.93,89.63 175.11,88.45 176.23,88.45 178.01,86.67 178.37,86.67 178.54,86.5 178.54,86.23 178.31,85.99 178.31,85.84 178.41,85.74 v2(178.6,85.74)
  IN6 w0.107: v2(21.78,67.73) 21.97,67.54 21.97,66.83 23.09,65.71 23.09,65.18 23.48,64.79 23.48,63.82 24.7,62.6 24.7,60.76 25.68,59.78 25.68,59.08 26.03,58.73 26.39,58.73 26.7,58.41 26.7,57.89 27.23,57.36 27.23,55.99 26.41,55.17 26.41,54.26 26.15,54 26.15,51.64 28.46,49.33 30.84,49.33 31.67,48.49 31.67,47.14 31.55,47.01 31.55,46.4 31.97,45.98 32.59,45.98 33.34,45.23 33.34,45 33.77,44.56 33.77,43.37 34.93,42.22 34.93,39.14 36.22,37.85 38.22,37.85 39.59,36.48 40.73,36.48 41.99,35.22 47.75,35.22 48.68,34.29 49.76,34.29 50.16,34.7 52.64,34.7 52.93,34.41 54.76,34.41 55.03,34.69 55.54,34.69 55.73,34.87 56.36,34.87 56.52,35.03 58.55,35.03 58.91,34.67 60.79,34.67 61.09,34.36 66.69,34.36 68.25,32.81 69.87,32.81 70.39,33.33 75.33,33.33 76.09,34.09 80.02,34.09 80.59,33.52 81.29,33.52 82.31,32.5 85.57,32.5 89.18,36.11 89.18,37.08 90.29,38.2 95.21,38.2 100.61,43.59 104.25,43.59 109.59,48.93 109.59,50.21 112.51,53.13 112.51,53.69 113.62,54.79 115.53,54.79 118.35,57.62 118.35,63.26 118.96,63.86 119.54,63.86 126.16,70.49 126.16,72.16 126.95,72.95 126.95,75.47 131.47,79.99 131.47,83.01 134.04,85.58 134.04,87.91 137.04,90.91 162.91,90.91 163.74,90.08 173.49,90.08 173.93,89.63
  BOTTOM w0.076: UH1.B36 177.38,85.09 177.43,85.04 177.52,85.04 177.67,85.2 178.27,85.2 178.6,85.53 v2(178.6,85.74)
CPU_DP3_P1_C: length 1.9
  TOP w0.152: CM14.1 21.62,69.11 21.62,69.36 21.39,69.59 21.39,70.37 UM1.A6
CPU_DP3_P2: length 226.2
  TOP w0.152: v2(22.95,67.87) 23.02,67.94 23.02,68.25 CM16.2
  IN6 w0.089: v2(175.19,83.03) 175.61,83.45 178.14,83.45 178.36,83.67 178.78,83.67 179.2,84.08 179.2,87.43 178.99,87.64 177.71,87.64 176.4,88.96 175.64,88.96 175.03,89.57 175.02,89.57 175,89.59
  IN6 w0.107: 175,89.59 173.82,90.77 164.46,90.77 163.64,91.59 136.7,91.59 133.4,88.29 133.4,85.93 130.84,83.37 130.84,80.26 126.31,75.73 126.31,73.28 125.43,72.39 125.43,70.66 119.24,64.47 118.5,64.47 117.6,63.57 117.6,57.79 115.23,55.41 113.03,55.41 111.16,53.54 111.16,52.92 108.7,50.47 108.7,49.55 103.47,44.31 99.21,44.31 93.74,38.84 90.04,38.84 88.47,37.27 88.47,36.45 85.55,33.53 84.49,33.53 83.88,34.14 81.01,34.14 80.4,34.75 75.82,34.75 75.03,33.96 71.13,33.96 70.57,34.52 70.57,34.96 69.61,35.93 42.15,35.93 40.98,37.1 39.85,37.1 38.47,38.47 38.47,39.3 37.84,39.93 36.46,39.93 35.56,40.83 35.56,42.55 34.41,43.7 34.41,44.8 33.94,45.27 33.94,45.51 33.29,46.15 33.29,47.77 29.42,51.64 29.42,52.6 28.14,53.87 28.14,55.44 27.85,55.74 27.85,57.61 27.32,58.14 27.32,59.65 26.66,60.31 26.66,64.5 25.08,66.08 24.39,66.08 23.81,66.66 23.39,66.66 23.17,66.88 23.17,67.65 v2(22.95,67.87)
  BOTTOM w0.076: UH1.F33 175.19,83.09 v2(175.19,83.03)
CPU_DP3_P2_C: length 1.8
  TOP w0.152: UM1.A4 22.99,70.37 22.99,69.13 CM16.1
CPU_DP3_P3: length 235.2
  TOP w0.152: v2(24.3,67.69) 24.52,67.91 24.52,68.25 CM18.2
  IN6 w0.089: v2(177.12,83.9) 177.12,84.19 177.58,84.65 177.58,85.72 176.58,86.72 171.33,86.72 170.95,87.1 170.95,88.1 169.66,89.39 163.31,89.39 163.12,89.57 163.11,89.57 163.1,89.59
  IN6 w0.107: 163.1,89.59 162.6,90.08 137.24,90.08 134.76,87.6 134.76,83.23 132.44,80.91 132.44,79.98 127.67,75.21 127.67,72.52 126.9,71.75 126.9,70.28 122.68,66.07 122.68,65 121.47,63.79 120.39,63.79 119.82,63.22 119.28,63.22 119.04,62.98 119.04,60.2 119.18,60.06 119.18,56.7 116.65,54.17 116.25,54.17 113.84,51.77 112.4,51.77 111.19,50.56 111.19,49.46 104.35,42.62 100.75,42.62 95.69,37.57 90.64,37.57 89.79,36.72 89.79,35.58 85.29,31.08 79.45,31.08 78.73,31.8 73.93,31.8 73.03,32.69 70.84,32.69 70.31,32.16 67.33,32.16 65.8,33.7 60.83,33.7 60.5,34.02 58.94,34.02 58.52,33.6 48.74,33.6 48.25,33.12 46.56,33.12 45.08,34.61 41.7,34.61 40.45,35.87 39.05,35.87 37.73,37.19 35.99,37.19 34.29,38.89 34.29,41.98 33.42,42.85 32.72,42.85 30.52,45.05 27.9,45.05 27.31,45.64 27.31,47.08 27.07,47.32 27.07,47.86 25.65,49.28 25.65,50.57 25.52,50.7 25.52,54.38 25.75,54.62 25.75,55.35 25.27,55.82 25.27,58.21 25.04,58.44 25.04,59.28 24.08,60.24 24.08,61.93 23.75,62.26 22.62,62.26 22.38,62.5 22.38,65.28 21.07,66.6 21.07,68.18 21.73,68.84 24.95,68.84 25.58,68.21 25.58,67.17 25.13,66.72 24.62,66.72 24.3,67.04 v2(24.3,67.69)
  BOTTOM w0.076: v2(177.12,83.9) 177.12,83.79 UH1.C33
CPU_DP3_P3_C: length 1.8
  TOP w0.152: CM18.1 24.56,69.13 24.56,70.4 UM1.A2
CPU_ID: length 5.5
  TOP w0.089: v2(89.03,7.94) 89.06,7.91 89.2,7.91 89.73,8.43 v1(89.96,8.43) 89.97,8.42 90.86,8.42 RH5875.2 91.1,8.62 92.1,8.62 RH5876.1
  BOTTOM w0.089: UH2.AW24 88.61,8.55 89.03,8.13 89.03,7.95 v2(89.03,7.94)
CPU_TRIGGER: length 129.5
  TOP w0.14: v2(189.1,53.06) 189.1,53.6 191.58,56.07 191.58,60.96 191.72,61.1 RH192.1
  IN3 w0.089: 101.98,13.41 99.58,13.41 99.24,13.07 99.18,13.07 99.06,12.95 v2(98.94,12.95)
  IN3 w0.091: v2(107.11,17.2) 106.89,16.97 106.89,16.13 105.39,14.63 103.44,14.63 102.22,13.41 101.98,13.41
  IN6 w0.099: v2(107.11,17.2) 107.18,17.2 107.29,17.09 107.99,17.09 110.96,20.06 170.14,20.06 170.74,20.66 175.68,20.66 176.61,21.59 176.61,26.68 178.19,28.26 178.19,32.54 187.13,41.49 187.13,51.26 188.94,53.06 v2(189.1,53.06)
  BOTTOM w0.089: UH2.AK2 98.52,13 98.89,13 v2(98.94,12.95)
CPU_TRIGGER_R: length 32
  TOP w0.14: RH192.2 191.14,63.12 190.59,62.57 v1(188.65,62.57) 188.56,62.66 187.28,62.66 v2(186.81,62.19)
  IN4 w0.089: v2(173.84,76.74) 173.84,76.63 174.88,75.59 177.06,75.59 177.74,74.91 177.74,63.94 179.49,62.19 179.9,62.19
  IN4 w0.091: v2(186.81,62.19) 179.9,62.19
  BOTTOM w0.076: v2(173.84,76.74) 173.21,76.74 UH1.J23
CPU_VCCIO_PWR_GATE#: length 6.9
  BOTTOM w0.089: 101.98,9.16 101.63,9.16 101.45,8.98 RH5835.2 100.83,8.64 100.58,8.39 98.24,8.39 97.97,8.12 UH2.AY3
  BOTTOM w0.14: 101.98,9.16 103.66,9.16 T4949.1
CPU_XDP_TCK: length 41.2
  TOP w0.14: JXDP.57 129.33,100.01 129.48,100.15 130.07,100.15 130.82,100.9 v2(131.3,100.9) 131.3,101.37 130.57,102.11 130.57,103.08 v5(130.7,103.21) 130.99,103.51 RH491.2 132,103.62 RH498.2
  IN2 w0.089: v2(135.41,79.89) 134.85,79.34 134.62,79.34
  IN2 w0.099: 128.98,86.71 130.67,85.03 130.67,81.95 133.09,79.52 133.97,79.52 134.16,79.34 134.62,79.34
  IN2 w0.102: 128.98,86.71 128.98,89.81 130.88,91.7 131.95,91.7 133.68,93.43 133.68,94.98 132.56,96.1 132.56,96.83 131.49,97.91 130.76,98.64 130.76,100.36 v2(131.3,100.9)
  BOTTOM w0.076: UH1.BR28 137.81,79.78 137.47,79.78 137.21,79.52 135.78,79.52 v2(135.41,79.89)
CPU_XDP_TDI: length 28.7
  TOP w0.14: v2(139.36,98.62) v5(139.36,98.04)
  IN2 w0.102: v2(140.39,82.77) 139.96,83.2 137.72,83.2 137.29,83.62 135.69,83.62 135.4,83.92 135.4,89.27 139.36,93.24 v2(139.36,98.62)
  BOTTOM w0.076: v2(140.39,82.77) 140.58,82.96 UH1.BL32
  BOTTOM w0.14: v2(139.36,98.62) 138.83,99.15 137.41,99.15 136.89,98.63 136.89,98.53 135.69,97.33 RH541.2 RH495.2
CPU_XDP_TDO: length 28.3
  TOP w0.14: v5(134.01,96.65) 133.33,96.65 v2(133.22,96.75)
  IN2 w0.099: v2(133.22,96.75) 133.37,96.6 133.37,95.86 134.09,95.15 134.09,93 132.26,91.17 131.89,91.17 130.72,90 129.89,90 129.39,89.5 129.39,86.88
  IN2 w0.102: 129.39,86.88 131.09,85.18 131.09,82.1 132.24,80.95 133.44,80.95 133.88,80.5 135.43,80.5 136.04,79.89 v2(136.05,79.89)
  BOTTOM w0.076: UH1.BT28 137.29,80.24 136.39,80.24 136.05,79.9 v2(136.05,79.89)
  BOTTOM w0.14: RH540.2 RH496.2 133.67,97.19 v2(133.22,96.75)
CPU_XDP_TMS: length 35.6
  TOP w0.14: v2(134.2,79.89) v5(134.2,80.51)
  IN2 w0.099: v2(134.2,79.89) 133.35,80.74 132.16,80.74 130.87,82.03 130.87,85.11 129.19,86.79 129.19,89.72 130.97,91.5 132.11,91.5 133.89,93.27 133.89,95.06 132.77,96.18 132.77,96.92 131.24,98.44 v2(131.24,99.16)
  BOTTOM w0.076: 134.62,80.27 134.64,80.29 134.91,80.29 135.02,80.41 138.42,80.41 UH1.BP28
  BOTTOM w0.127: 134.6,80.27 134.57,80.27 v2(134.2,79.89)
  BOTTOM w0.14: 134.62,80.27 134.6,80.27 134.6,80.27 ; v2(131.24,99.16) 131.17,99.08 131.17,97.86 RH494.2 131.7,96.52 131.4,96.23 130.97,96.23 130.91,96.29 RH542.2
CPU_XDP_TRST#: length 108.6
  TOP w0.14: v2(131.94,82.26) v5(131.37,82.26)
  IN3 w0.089: 101.98,12.78 101.09,12.78 100.62,12.31 99.76,12.31 99.45,12 v2(99.45,11.79)
  IN3 w0.091: 101.98,12.78 102.54,12.78 103.79,14.03 106.51,14.03 107.87,15.39 107.87,16.17 108.32,16.62 108.32,18.24 105.97,20.59 104.91,20.59 v2(104.91,20.59)
  IN4 w0.091: v2(131.94,82.26) 131.94,80.99 129.89,78.93 129.89,66.56 129.72,66.4 129.72,65.03 131.7,63.05 131.7,55.24 117.87,41.41 113.71,41.41 113.26,40.96 113.26,40.07 109.16,35.96 109.16,34.54 106.76,32.14 106.76,28.08 105.23,26.55 105.23,23.3 105.54,22.99 105.54,21.21 v2(104.91,20.59)
  BOTTOM w0.076: 134.62,81.86 134.67,81.86 134.91,82.11 136.14,82.11 136.4,82.36 137.02,82.36 137.25,82.13 137.71,82.13 137.9,81.94 138.24,81.94 138.53,81.65 UH1.BP30
  BOTTOM w0.089: UH2.AM4 97.73,11.88 98.05,12.19 98.57,12.19 98.8,11.96 98.8,11.93 98.93,11.8 99.19,11.8 99.23,11.84 99.4,11.84 v2(99.45,11.79)
  BOTTOM w0.14: 134.62,81.86 132.51,81.86 132.11,82.26 v2(131.94,82.26) 131.58,82.26 131.41,82.42 RH497.2 130.54,81.9 129.56,81.9 129.02,81.36 RH543.2
CS_1.2V: length 3.7
  BOTTOM w0.14: v1(286.26,26.62) 287.71,26.62 PR601.2
  BOTTOM w0.203: PR601.2 288.08,27.31 288.27,27.5 PU600.13
CSIN_ISL88738: length 5.6
  TOP w0.203: 47.85,10.85 v1(48.22,11.21) 48.22,11.32 49.51,12.62 PU1900.14
  TOP w0.254: PC1910.2 47.12,10.21 47,10.1 PR1902.2 ; PC1910.2 47.7,9.34 PC1912.1 ; PC1910.2 47.85,10.36 47.85,10.85
CSIP_ISL88738: length 7.2
  TOP w0.14: PR1901.2 49.66,9.87 v1(50.86,8.66)
  TOP w0.203: PU1900.15 49.91,12.58 48.62,11.28 48.62,10.64
  TOP w0.254: PC1910.1 48.86,9.97 PR1901.2 ; PC1910.1 48.62,9.82 48.58,9.78 PC1911.1 ; PC1910.1 48.62,10.64
CSON_ISL88738: length 5.9
  TOP w0.203: PC1942.1 43.56,17.35 45.31,17.35 v1(45.67,16.99) 46.15,16.51 PU1900.1
  TOP w0.254: PC1943.1 PR1935.1 42.83,17.53 42.9,17.6 PC1942.1
CSOP_ISL88738: length 5.7
  TOP w0.203: PC1942.2 v1(44.4,16.69) 45.16,16.69 45.74,16.11 PU1900.2
  TOP w0.254: PC1938.1 PR1931.1 42.6,16.77 42.67,16.69 PC1942.2
DAT_TP_SIO: length 119.2
  TOP w0.076: UE3.C12 295.78,19.37 v2(296.17,18.99)
  TOP w0.14: v2(200.53,12.45) 200.53,12.69 v5(201.08,13.23)
  IN2 w0.099: v2(296.17,18.99) 296.11,19.04 296.11,19.4 295.7,19.81 294.26,19.81 294.01,20.07 290.82,20.07 289.47,18.72 288.6,18.72 288.2,18.31 284.89,18.31 283.08,16.51 282.72,16.51 281.82,15.61 279.77,15.61 278.64,14.48 266.2,14.48 263.6,11.88 261.82,11.88 260.65,10.7 254.93,10.7 254.17,9.94 240.33,9.94 239.79,9.4 216.66,9.4 213.39,12.67 204.32,12.67 203.55,11.91 201.07,11.91 v2(200.53,12.45)
  BOTTOM w0.14: v2(200.53,12.45) 200.53,12.96 200.99,13.41 DE4.3 200.22,14.26 200.22,15.05 199.9,15.37 192.92,15.37 192.6,15.05 192.6,14.64 RE26.2 192.28,14.33 CE78.1 192.34,13.4 192.34,12.18 192,11.84 JTP.2
DCI_CLK: length 1.2
  TOP w0.089: v2(91.94,6.81) 91.82,6.69 T5991.1
  BOTTOM w0.089: UH2.BB16 91.61,7.1 91.91,6.81 v2(91.94,6.81)
DCI_DATA: length 1.5
  TOP w0.089: T5992.1 91.64,11.47 v2(91.27,11.84)
  BOTTOM w0.089: v2(91.27,11.84) 91.11,11.84 90.77,11.51 UH2.AN18
DCIN1_EN: length 342.5
  TOP w0.254: v2(27.99,2.16) 27.99,4.39 31.12,7.51 31.12,12.44 31.91,13.24 31.91,14.28 v1(31.71,14.48) 28.62,14.48 27.35,13.21 PR256.1 ; v2(118.8,4.29) 118.8,5.73 118.31,6.21 118.31,6.48 117.77,7.02 v2(117.77,8.67) ; v2(301.76,12.57) UE3.K4
  IN5 w0.254: v2(117.77,8.67) 118.74,9.65 132.09,9.65 132.57,9.18 135.69,9.18 136.28,8.58 139.66,8.58 140.77,9.69 145.57,9.69 147.45,7.81 148.49,7.81 149.06,8.38 154.83,8.38 155.7,7.51 159.97,7.51 160.83,8.38 168.06,8.38 168.81,7.62 178.31,7.62 179.1,6.83 180.77,6.83 181.79,7.84 193.58,7.84 196.73,10.99 198.09,10.99 199.04,11.94 200.5,11.94 200.55,11.89 200.95,11.89 201,11.94 212.86,11.94 215.46,9.34 254.5,9.34 254.79,9.62 261.77,9.62 263.33,8.06 268.32,8.06 268.62,8.36 270.63,8.36 271.63,7.37 278.39,7.37 279.66,8.64 280.82,8.64 281.65,7.81 285.26,7.81 285.78,8.33 291.6,8.33 292.16,7.77 294.54,7.77 294.73,7.95 296.43,7.95 296.63,8.15 297.26,8.15 297.98,8.87 300.91,8.87 301.56,9.53 302.39,9.53 302.96,8.95 304.31,8.95 307.83,12.48 307.83,13.6 306.41,15.03 306.41,16.81 305.9,17.32 305.21,17.32 304.61,16.73 304.21,16.73 303.86,16.38 303.86,15.57 304.06,15.38 304.06,13.18 302.91,12.04 302.29,12.04 v2(301.76,12.57) ; v2(27.99,2.16) 28.91,1.25 41.99,1.25 42.95,2.21 44.89,2.21 45.93,1.17 53.14,1.17 53.54,1.58 53.54,2.01 54.51,2.97 57.62,2.97 58.48,3.84 58.48,4.56 58.76,4.84 59.78,4.84 60.4,5.46 60.89,5.46 61.22,5.79 62.74,5.79 63.13,6.19 68.17,6.19 68.72,5.64 68.72,5.33 69.39,4.66 73.7,4.66 75.03,3.33 75.78,3.33 76.82,4.37 78.91,4.37 80.05,5.51 85.54,5.51 86.16,4.88 89.47,4.88 89.84,5.26 93.27,5.26 93.63,4.9 95.94,4.9 97.9,2.94 99.49,2.94 100.24,3.68 102.45,3.68 102.48,3.66 107.15,3.66 107.53,4.04 117.04,4.04 117.8,3.28 118.59,3.28 118.82,3.51 118.82,4.26 v2(118.8,4.29)
DCIN2_EN: length 321
  TOP w0.076: UE3.L12 302.13,19.37 v2(301.75,19.75)
  TOP w0.14: PR221.1 19,30.59 v2(18.77,30.36)
  IN1 w0.076: 75.76,12.63 74.4,12.63 73.6,13.42 73.28,13.42
  IN1 w0.099: v2(136.81,11.81) 136.81,12.42 136.43,12.8 129.44,12.8 128.79,13.45 113,13.45 112.36,12.82 108.27,12.82 107.79,12.35 104.55,12.35 103.99,12.9 103.37,12.9 102.7,12.24 102.29,12.24 101.34,11.29 99.84,11.29 99.65,11.1 99.24,11.1 98.97,11.38 97.92,11.38 97.28,12.02 96.22,12.02 94.48,13.76 91.82,13.76 91.25,13.19 89.32,13.19 88.94,12.81 88.3,12.81 87.72,12.23 85.83,12.23 85.25,11.65 80.7,11.65 80.65,11.6 80.33,11.6 79.72,12.21 79.52,12.21 79.11,11.8 76.58,11.8 75.76,12.63 ; 73.28,13.42 71.95,13.42 71.04,12.51 69.98,12.51 69.01,11.53 66.74,11.53 65.52,10.31 63.36,10.31 62.49,11.19 62.49,13.54 61.82,14.21 61.82,14.56 58.96,17.42 58.96,19.2 58.72,19.44 57.78,19.44 54.55,22.68 52.86,22.68 51.8,21.62 51.8,20.97 51.24,20.41 47.2,20.41 46.68,20.93 44.75,20.93 44.01,20.19 44.01,18.99 43.51,18.49 36.21,18.49 35.57,17.86 32.4,17.86 30.44,19.81 23.95,19.81 22.99,20.77 22.99,21.85 23.64,22.49 23.64,28.08 23.32,28.4 21.76,28.4 21.31,28.85 21.31,29.57 21.05,29.82 19.31,29.82 v2(18.77,30.36)
  IN5 w0.099: v2(301.75,19.75) 300.75,19.75 300.33,20.17 299.99,20.17 299.81,19.99 294.16,19.99 294.03,19.87 291.23,19.87 289.46,18.1 288.08,18.1 287.3,17.32 276.42,17.32 275.05,15.95 267.87,15.95 265.55,13.64 262.83,13.64 262.53,13.94 257.28,13.94 256.7,13.36 249.68,13.36 246.72,16.32 215.25,16.32 214.84,16.73 202.88,16.73 202.51,17.1 180.7,17.1 177.35,13.75 164.38,13.75 163.97,14.17 145.3,14.17 144.23,13.1 140.5,13.1 139.73,12.33 137.33,12.33 v2(136.81,11.81)
DDC_CLK_HDMI: length 28.8
  TOP w0.14: UM1.E1 25.45,74.1 25.98,74.1 v2(26.16,73.92) 26.35,74.1 26.61,74.1 RM1.1
  IN1 w0.099: JHDMI1.15 12.72,87.88 12.72,88.81 12.19,89.35 12.19,89.46 12.36,89.63 15.38,89.63 22.73,82.28 22.73,79.77 24.41,78.08 24.41,76.76 25.51,75.66 25.51,74.46 25.77,74.2 25.89,74.2 26.16,73.92 v2(26.16,73.92)
DDC_DAT_HDMI: length 28.8
  TOP w0.14: RM2.1 26.61,74.37 26.35,74.37 v2(26.16,74.55) 25.98,74.37 25.39,74.37 UM1.F1
  IN1 w0.099: v2(26.16,74.55) 26.04,74.43 25.86,74.43 25.73,74.55 25.73,75.76 24.64,76.85 24.64,78.17 22.95,79.86 22.95,82.38 15.47,89.86 12.26,89.86 11.93,89.53 11.5,89.53 11.15,89.18 11.15,88.01 JHDMI1.16
DDI1_DDPB_CTRLCLK: length 104.9
  TOP w0.089: RP1.3 101.63,11.75 101.44,11.56 100.51,11.56 100.37,11.42 99.3,11.42 99,11.72 97.23,11.72 97.02,11.93 95.56,11.93 95.32,11.7 93.69,11.7 v3(93.33,12.05) 93.14,12.25 93.14,13.02 v2(93.24,13.12)
  IN3 w0.089: 32.75,33.53 32.75,33.53 32.75,33.54 32.66,33.63 32.46,33.82 31.74,33.82 31.38,34.18 31.38,34.91 32.66,36.2 32.66,40.65 31.26,42.05 29.54,42.05 28.87,42.72 28.02,42.72 27.59,43.14 27.59,44.26 27.8,44.46 30.13,44.46 30.6,44 v2(30.6,43.46) ; v2(93.24,13.12) 93.06,12.95 93.06,12.77 92.83,12.54 92.48,12.54 92.34,12.68 91.88,12.68 91.47,13.08 91.47,14.45 91.17,14.76 89.59,14.76 89.11,15.24 87.4,15.24 86.55,14.4 83.56,14.4 82.76,13.59 79.76,13.59 79.3,13.14 77.29,13.14 75.74,14.69 75.74,15.16 73.51,17.39 73.5,17.39 73.33,17.55
  IN3 w0.099: 73.33,17.55 73.04,17.85 72.22,17.85 69.02,21.05 65.84,21.05 64.59,22.3 64.59,23.13 63.8,23.91 52.57,23.91 51.99,24.5 48.64,24.5 48.29,24.85 45.84,24.85 44.8,25.89 42.49,25.89 39.32,29.06 38.59,29.06 37.12,30.53 34.76,30.53 33.99,31.3 33.99,32.7 33.43,33.27 33.02,33.27 32.75,33.53
  BOTTOM w0.089: v2(93.24,13.12) 93.13,13.12 93.1,13.1 93.1,12.84 UH2.AL13
  BOTTOM w0.102: v2(30.6,43.46) 30.6,43.44 30.89,43.15 UT1.Y5
DDI1_DDPB_CTRLDAT: length 105.3
  TOP w0.089: RP1.4 101.63,11.25 101.59,11.29 100.62,11.29 100.48,11.15 99.19,11.15 98.89,11.46 v3(97.5,11.46) 97.12,11.46 96.91,11.67 95.67,11.67 95.43,11.43 93.58,11.43 92.87,12.14 92.87,12.97 v2(92.69,13.15)
  IN3 w0.089: 32.9,33.65 32.88,33.67 32.88,33.67 32.54,34 31.81,34 31.56,34.26 31.56,34.83 32.84,36.12 32.84,40.72 31.34,42.23 29.61,42.23 28.94,42.9 28.09,42.9 27.77,43.22 27.77,43.35 27.9,43.47 v2(28.01,43.47) ; 73.62,17.54 73.63,17.52 73.63,17.52 75.92,15.23 75.92,14.76 77.37,13.32 79.23,13.32 79.69,13.78 82.69,13.78 83.49,14.58 86.47,14.58 87.32,15.43 89.18,15.43 89.67,14.94 91.24,14.94 91.65,14.53 91.65,13.15 91.95,12.86 92.42,12.86 92.56,12.72 92.75,12.72 92.88,12.85 92.88,12.96 v2(92.69,13.15)
  IN3 w0.099: 73.62,17.54 73.12,18.04 72.3,18.04 69.1,21.24 65.92,21.24 64.78,22.38 64.78,23.21 63.88,24.1 52.65,24.1 52.07,24.69 48.72,24.69 48.37,25.05 45.91,25.05 44.88,26.08 42.57,26.08 39.4,29.25 38.67,29.25 37.2,30.72 34.84,30.72 34.18,31.38 34.18,32.78 33.5,33.46 33.1,33.46 32.9,33.65
  BOTTOM w0.089: UH2.AR8 95.63,10.56 95.63,11.12 95.45,11.3 95.45,12.52 95.2,12.78 94.86,12.78 94.11,13.53 92.96,13.53 92.69,13.25 v2(92.69,13.15)
  BOTTOM w0.102: v2(28.01,43.47) UT1.R4
DDI2_DDPC_CTRLCLK: length 96.7
  TOP w0.089: v2(93.9,12.08) 94.1,12.28 94.1,12.43 94.38,12.71 95.39,12.71 96.06,13.38 v3(96.38,13.38) 97.73,13.38 98.57,12.55 100.69,12.55 100.78,12.64 101.42,12.64 101.54,12.75 RP1.1
  IN3 w0.089: 75.93,13.51 76.14,13.3 76.14,12.36 76.73,11.77 77.65,11.77 77.86,11.98 79.11,11.98 79.36,12.23 79.99,12.23 80.41,12.65 85.88,12.65 87.01,11.53 89.33,11.53 90.21,12.41 91.49,12.41 92.18,11.72 94.05,11.72 94.13,11.8 94.13,11.89 94.04,11.98 93.99,11.98 93.9,12.07 v2(93.9,12.08)
  IN3 w0.099: v4(31.24,41.52) 31.34,41.42 31.34,40.06 32.26,39.14 32.26,36.43 31.02,35.2 31.02,33.75 31.43,33.34 32.21,33.34 33.4,32.15 33.4,30.68 33.99,30.09 36.97,30.09 38.34,28.71 38.34,27.8 38.84,27.31 40.15,27.31 41.63,25.83 41.63,24.99 43.22,23.41 45.64,23.41 45.88,23.64 52.07,23.64 52.23,23.49 63.1,23.49 63.46,23.13 63.46,22.44 65.36,20.54 68.62,20.54 75.22,13.93 75.5,13.93 75.93,13.51
  BOTTOM w0.089: v2(93.9,12.08) 93.67,11.85 93.33,11.85 93.03,11.55 UH2.AN13
  BOTTOM w0.102: v4(31.24,41.52) 31.24,41.54 30.93,41.85 UT1.Y8
DDI2_DDPC_CTRLDAT: length 101
  TOP w0.089: v2(94.54,12.07) 94.36,12.24 94.36,12.32 94.49,12.45 95.5,12.45 96.17,13.11 97.62,13.11 98.45,12.28 v3(100.24,12.28) 100.8,12.28 100.89,12.37 101.42,12.37 101.54,12.25 RP1.2
  IN3 w0.076: 29.82,41.26 29.1,41.97 29.1,42.25 28.81,42.53 27.97,42.53 27.66,42.84 v2(27.36,42.84)
  IN3 w0.089: v2(94.54,12.07) 94.45,11.98 94.4,11.98 94.31,11.89 94.31,11.72 94.12,11.54 92.11,11.54 91.41,12.23 90.29,12.23 89.4,11.35 86.93,11.35 85.81,12.47 80.48,12.47 80.06,12.05 79.44,12.05 79.18,11.8 77.93,11.8 77.73,11.59 76.66,11.59 75.96,12.29 75.96,13.21 75.79,13.37
  IN3 w0.099: 75.79,13.37 75.42,13.74 75.15,13.74 68.54,20.35 65.28,20.35 63.27,22.36 63.27,23.05 63.02,23.3 52.15,23.3 51.99,23.45 45.96,23.45 45.72,23.22 43.14,23.22 41.44,24.92 41.44,25.75 40.08,27.12 38.76,27.12 38.15,27.72 38.15,28.63 36.89,29.9 33.91,29.9 33.21,30.6 33.21,32.07 32.13,33.15 31.35,33.15 30.83,33.67 30.83,35.27 32.07,36.51 32.07,39.06 31.15,39.98 31.15,40.93 31.14,40.93 30.81,41.26 29.82,41.26
  BOTTOM w0.089: v2(94.54,12.07) 94.43,12.17 UH2.AL10
  BOTTOM w0.102: UT1.N4 27.36,43.47 27.36,42.84 v2(27.36,42.84)
DDI3_DDPD_CTRLCLK: length 13
  TOP w0.089: RH1145.1 87.56,11.89 88.29,11.16 88.8,11.16 89.59,10.37 90.13,10.37 91.22,9.27 v1(91.94,9.27) 92.15,9.27 92.78,8.64 95.14,8.64 v2(95.39,8.9)
  BOTTOM w0.089: v2(95.39,8.9) 95.45,8.96 95.45,11.05 95.16,11.34 UH2.AL9
DDI3_DDPD_CTRLDAT: length 5.2
  BOTTOM w0.089: 101.98,10.39 101.42,10.39 101.11,10.7 101.11,10.88 100.87,11.12 99.9,11.12 99.42,10.64 98.35,10.64 98.02,10.31 UH2.AR3
  BOTTOM w0.14: 101.98,10.39 102.35,10.39 RH1146.1
DDR4_DRAMRST#: length 85.1
  TOP w0.14: v2(134.4,18.37) 134.33,18.3 RD102.1 CD3326.1 CD3327.1
  IN4 w0.091: v2(134.4,18.37) 134.4,19.02 134.68,19.31 147.96,19.31 149.35,17.91 151.01,17.91 152.95,19.85 174.34,19.85 174.97,19.22 176.85,19.22 177.25,19.62 184.02,19.62 184.34,19.31 201.36,19.31 201.89,18.77 210.47,18.77 v2(210.9,18.35)
  BOTTOM w0.102: v2(134.4,18.37) 134.12,18.64 JDIMM1.108 ; JDIMM2.108 210.43,18.82 v2(210.9,18.35)
DDR_A_ACT#: length 50.4
  IN6 w0.117: v2(150.06,58.49) 150.2,58.35 150.2,56.52 150.31,56.41 150.79,56.41 150.91,56.29 150.91,56.06 150.79,55.94 150.31,55.94 150.2,55.82 150.2,54.72 149.86,54.39 149.86,49.16 148.52,47.82 148.52,46.14 135.94,33.55 135.94,30.93 135.36,30.35 135.36,23.37 v2(135.78,22.95)
  BOTTOM w0.076: UH1.AU3 150.83,61.46 150.83,61.28 150.76,61.21 150.55,61.21 150.47,61.13 150.47,60.11 150.59,60 150.59,59.02 v2(150.06,58.49)
  BOTTOM w0.221: v2(135.78,22.95) 135.26,22.42 135.26,21.2 135.62,20.83 JDIMM1.114
DDR_A_ALERT#: length 50.5
  IN6 w0.117: v2(135.77,21.51) 134.94,22.34 134.94,30.53 135.52,31.11 135.52,33.87 148.1,46.45 148.1,47.99 149.44,49.34 149.44,54.49 149.91,54.96 149.91,58.02 149.65,58.28 149.65,59.33 v2(149.62,59.37)
  BOTTOM w0.076: v2(149.62,59.37) 149.62,59.6 150.14,60.12 150.14,62.23 UH1.AU5
  BOTTOM w0.221: v2(135.77,21.51) 135.77,21.43 136.12,21.08 JDIMM1.116
DDR_A_BG0: length 53.5
  IN6 w0.117: v2(146.98,54.52) 146.98,51.39 145.72,50.14 145.72,47.44 132.24,33.95 132.24,23.68 v2(133.93,21.98)
  BOTTOM w0.076: UH1.AU1 150.75,59.67 150.75,59.67 150.75,58.68 149.39,57.32 149.11,57.32 146.98,55.19 v2(146.98,54.52)
  BOTTOM w0.221: JDIMM1.115 135.88,26.56 135.27,25.96 135.27,23.6 134.44,22.76 134.44,22.48 v2(133.93,21.98)
DDR_A_BG1: length 51.1
  IN6 w0.117: v2(133.93,23.27) 132.66,24.55 132.66,33.76 146.15,47.25 146.15,49.97 147.42,51.25 147.42,53.89 147.74,54.2 147.74,55.4 v2(147.73,55.41)
  BOTTOM w0.076: UH1.AU2 150.75,60.63 151.03,60.35 151.03,58.72 148.56,56.25 148.56,56.24 v2(147.73,55.41)
  BOTTOM w0.221: v2(133.93,23.27) 134.06,23.27 134.75,23.95 134.75,26.28 135.37,26.91 JDIMM1.113
DDR_A_BS0: length 53.6
  IN6 w0.089: 159.17,50.5 159.17,50.94 158.61,51.5 158.61,58.99 158.49,59.12 v2(157.41,59.12)
  IN6 w0.117: 159.17,50.5 159.17,46.06 157.91,44.8 157.91,43.09 149.37,34.55 149.37,33.3 148.06,31.99 147.89,31.99 147.63,32.25 147.45,32.25 147.29,32.09 147.29,31.93 147.56,31.66 147.56,31.49 147.4,31.34 147.4,26.76 145.7,25.05 145.7,23.6 145.82,23.48 v2(146.47,23.48)
  BOTTOM w0.076: UH1.AH5 158,62.84 157.8,62.64 157.8,59.51 v2(157.41,59.12)
  BOTTOM w0.221: JDIMM1.150 146.64,20.86 147.32,21.54 147.32,22.65 147.47,22.8 147.47,23.35 147.35,23.48 v2(146.47,23.48)
DDR_A_BS1: length 50.3
  IN6 w0.089: v2(157.41,57.15) 158.15,56.4 158.15,51 158.32,50.83 158.32,50.5
  IN6 w0.117: v2(144.8,24.75) 144.8,25.35 146.13,26.68 146.13,27.04 146.25,27.16 146.43,27.16 146.55,27.28 146.55,27.51 146.43,27.63 146.25,27.63 146.13,27.74 146.13,27.98 146.25,28.09 146.43,28.09 146.55,28.21 146.55,28.44 146.43,28.56 146.26,28.56 146.14,28.68 146.14,30.7 146.03,30.82 145.91,30.82 145.78,30.95 145.78,31.17 145.9,31.29 146.03,31.29 146.14,31.4 146.14,31.58 146.03,31.7 145.89,31.7 145.78,31.82 145.78,32.05 145.89,32.17 146.03,32.17 146.14,32.28 146.14,32.65 147.82,34.33 147.99,34.33 148.13,34.19 148.13,33.97 147.57,33.41 147.57,33.24 147.72,33.09 147.91,33.09 148.53,33.71 148.53,35.03 157.07,43.57 157.07,45.15 158.32,46.4 158.32,50.5
  BOTTOM w0.076: UH1.AH1 158.3,58.04 v2(157.41,57.15)
  BOTTOM w0.221: JDIMM1.145 145.37,27.01 144.8,26.44 v2(144.8,24.75)
DDR_A_CAS#: length 53.5
  IN6 w0.117: v2(160.58,54.3) 160.58,53.8 161.01,53.36 161.18,53.36 161.51,53.7 161.68,53.7 161.84,53.53 161.84,53.37 161.51,53.03 161.51,52.87 161.67,52.7 161.84,52.7 162.18,53.04 162.34,53.04 162.51,52.87 162.51,52.71 162.17,52.37 162.17,52.2 162.33,52.04 162.5,52.04 162.84,52.38 163,52.38 163.19,52.19 163.19,52.01 163.01,51.83 163.01,51.65 164.17,50.5 164.17,43.3 155.13,34.27 155.13,32.74 152.59,30.2 152.59,28.83 152.9,28.53 152.9,26.65 151.99,25.75 151.99,24.15 151.29,23.44 v2(150.74,23.44)
  BOTTOM w0.076: v2(160.58,54.3) 160.58,55.42 161.7,56.54 161.7,60.08 UH1.AD1
  BOTTOM w0.221: JDIMM1.156 148.14,20.74 148.14,20.8 148.9,21.56 149.38,21.56 150.03,22.21 150.03,22.88 150.59,23.44 v2(150.74,23.44)
DDR_A_D0: length 60.5
  IN6 w0.079: v2(107.82,22.76) 107.82,22.87 107.65,23.04 107.65,24.95 107.98,25.28 107.98,29.89 108.57,30.48 108.57,32.95 120.09,44.48 120.09,46.21 130.03,56.15 130.03,56.26 129.78,56.51 129.78,56.62 129.9,56.73 130.01,56.73 130.25,56.49 130.36,56.49 130.53,56.65 130.53,57.1 130.45,57.18 130.29,57.18 130.22,57.25 130.22,57.41 130.29,57.49 130.45,57.49 130.53,57.57 130.53,57.89 131.94,59.3 131.94,59.78 134.59,62.42 135.52,62.42 v2(135.54,62.4)
  BOTTOM w0.076: UH1.BR6 138.02,63.53 137.19,63.53 137.14,63.47 136.79,63.47 136.71,63.55 136.05,63.55 135.54,63.04 v2(135.54,62.4)
  BOTTOM w0.14: v2(107.82,22.76) 108.09,22.76 109.13,21.72 JDIMM1.8
DDR_A_D1: length 59.7
  IN6 w0.079: v2(107.37,25.44) 106.94,25.87 106.94,27.04 107.42,27.51 107.42,30.13 108,30.71 108,33.19 119.53,44.71 119.53,46.53 126.29,53.3 126.29,53.41 126.18,53.52 126.07,53.52 124.83,52.27 124.69,52.27 124.59,52.37 124.59,52.49 129.48,57.37 129.48,57.63 129.61,57.76 129.61,57.76 131.38,59.53 131.38,60.01 134.48,63.11 135.54,63.11 136.27,63.83 v2(136.93,63.83)
  BOTTOM w0.076: UH1.BT6 v2(136.93,63.83)
  BOTTOM w0.14: v2(107.37,25.44) 107.62,25.44 108.08,25.9 108.08,26.04 108.88,26.83 JDIMM1.7
DDR_A_D2: length 59.5
  IN6 w0.079: v2(110.18,23.09) 110.36,22.92 110.77,22.92 111,23.15 111,31.95 122.52,43.47 122.52,44.3 127.32,49.1 127.32,50.01 132.44,55.13 132.59,55.13 132.68,55.04 132.68,54.92 132.16,54.41 132.16,54.29 132.28,54.18 132.39,54.18 132.96,54.76 132.96,56.79 135.1,58.93 135.4,58.93 136.58,60.11 136.58,60.71 v2(136.39,60.9)
  BOTTOM w0.076: UH1.BP3 138.53,61.94 137.97,61.94 137.95,61.92 137.2,61.92 137.01,61.73 136.69,61.73 136.39,61.44 v2(136.39,60.9)
  BOTTOM w0.14: JDIMM1.20 112.12,20.79 111.37,21.55 111.37,21.91 v2(110.18,23.09)
DDR_A_D3: length 59.7
  IN6 w0.079: v2(110.18,24.36) 110.55,24.36 110.72,24.53 110.72,32.07 122.24,43.59 122.24,44.42 127.04,49.21 127.04,49.32 126.94,49.43 126.8,49.43 125.44,48.06 125.32,48.06 125.24,48.14 125.24,48.32 132.68,55.76 132.68,56.9 v2(135.27,59.49)
  BOTTOM w0.076: v2(135.27,59.49) 135.67,59.49 136.21,60.03 137.22,60.03 137.8,60.61 137.8,60.71 137.8,61.06 137.82,61.09 138.01,61.28 138.23,61.28 138.34,61.4 139.24,61.4 UH1.BN3
  BOTTOM w0.14: JDIMM1.21 112.37,27 110.71,25.34 110.71,24.89 v2(110.18,24.36)
DDR_A_D4: length 60.7
  IN6 w0.079: v2(135.12,62.04) 134.61,62.04 132.23,59.66 132.23,59.09 130.81,57.68 130.81,56.54 120.37,46.09 120.37,44.36 108.85,32.84 108.85,30.36 108.26,29.78 108.26,25.16 107.94,24.84 107.94,23.45 108.22,23.17 108.22,21.96 v2(107.82,21.56)
  BOTTOM w0.076: UH1.BN5 139.09,63.19 139.09,63.65 138.71,64.03 137.94,64.03 137.78,64.19 136.79,64.19 136.32,63.72 135.98,63.72 135.12,62.85 v2(135.12,62.04)
  BOTTOM w0.14: v2(107.82,21.56) 108.13,21.26 JDIMM1.4
DDR_A_D5: length 60.5
  IN6 w0.079: v2(135.93,62.8) 134.57,62.8 131.66,59.89 131.66,59.42 129.76,57.52 129.76,57.18 126.59,54 126.59,53.89 126.7,53.78 126.82,53.78 128.97,55.94 129.09,55.94 129.19,55.84 129.19,55.71 119.81,46.33 119.81,44.59 108.28,33.07 108.28,30.6 107.7,30.01 107.7,26.95 107.41,26.66 v2(107.41,26.62)
  BOTTOM w0.076: UH1.BP6 138.79,63.53 138.4,63.14 138,63.14 137.92,63.22 137.88,63.22 137.73,63.36 137.31,63.36 137.26,63.31 136.72,63.31 136.64,63.39 136.12,63.39 135.93,63.2 v2(135.93,62.8)
  BOTTOM w0.14: JDIMM1.3 107.88,27.08 v2(107.41,26.62)
DDR_A_D6: length 59.2
  IN6 w0.079: v2(135.2,58.26) 134.89,58.26 133.47,56.84 133.24,56.61 133.24,54.64 131.39,52.79 131.25,52.79 131.15,52.89 131.15,53 132.05,53.89 132.05,54.01 131.95,54.1 131.82,54.1 127.6,49.89 127.6,48.98 122.81,44.19 122.81,43.36 111.28,31.83 111.28,22.3 110.8,21.82 v2(110.18,21.82)
  BOTTOM w0.076: UH1.BP2 139.07,60.79 139.07,60.1 138.88,59.91 138.79,59.91 138.14,59.25 137.87,59.25 136.87,58.26 v2(135.2,58.26)
  BOTTOM w0.14: JDIMM1.16 111.12,20.81 110.18,21.75 v2(110.18,21.82)
