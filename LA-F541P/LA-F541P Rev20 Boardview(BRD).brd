# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AC_PRESENT: length 259.5
  TOP w0.089: v1(78.08,3.29) 78.33,3.04 v2(78.33,2.8) 78.75,2.38 RH533.1
  TOP w0.14: UE3.K8 v6(300.96,16.57)
  IN1 w0.076: v2(78.33,2.8) 80.99,2.8 81.06,2.87 83.63,2.87 83.92,3.16 83.92,4.21 84.83,5.12 87.66,5.12 87.87,4.92 88.85,4.92 90.06,6.12 98.29,6.12 98.74,6.57 99.12,6.57 99.78,7.23 101.18,7.23 101.86,6.54 101.98,6.54 ; 303.99,11.3 303.99,13.27 302.88,14.38 301.71,14.38 301.53,14.56 300.79,14.56 300.57,14.79 300.57,16.17 v6(300.96,16.57)
  IN1 w0.099: 303.99,11.3 303.99,10.76 304.5,10.25 304.5,9.6 302.46,7.57 299.82,7.57 298.2,5.94 297.11,5.94 295.76,4.6 292.27,4.6 292.24,4.62 275.03,4.62 274.38,5.27 272.74,5.27 272.35,4.89 267.7,4.89 266.74,5.86 263.92,5.86 262.9,4.84 253.3,4.84 252.86,4.4 251.93,4.4 250.01,6.31 246.77,6.31 242.43,1.97 206.44,1.97 204.14,4.27 188.84,4.27 188.19,3.62 184.72,3.62 183.51,4.83 178.38,4.83 177.48,3.93 168.51,3.93 167.8,4.64 160.46,4.64 159.95,4.12 157.19,4.12 156.7,4.61 151.3,4.61 150.47,5.44 147.48,5.44 144.98,7.94 142.02,7.94 138.97,4.89 137.66,4.89 136.15,3.37 126.73,3.37 126.57,3.53 122.12,3.53 121.34,4.32 120.42,4.32 119.76,4.98 119.76,6.1 119.05,6.81 118.71,6.81 118.09,6.19 118.09,5.29 117.33,4.53 110.26,4.53 109.63,5.16 106.15,5.16 104.77,6.54 101.98,6.54
  BOTTOM w0.089: UH2.BG42 78.96,4.48 78.44,3.97 78.44,2.91 v2(78.33,2.8)
ACAV_IN: length 251.9
  TOP w0.14: v2(147.14,12.3) 147.14,12.61 v1(147.5,12.97) ; v2(295.36,14.97) UE3.C7 ; v2(65.4,16.2) 65.22,16.38 PR1940.2 64.58,16.37 PR1942.1
  IN1 w0.076: 101.98,14.75 98.82,14.75 98.19,15.38 95.08,15.38 93.75,16.7 89.07,16.7 89.04,16.68 87.5,16.68 86.78,15.96 86.78,15.32 86.2,14.74 85.71,14.74 85.26,14.29 85.26,13.65 84.98,13.37 84.35,13.37 82.59,15.13 77.07,15.13 76.09,16.1 72.31,16.1
  IN1 w0.099: 101.98,14.75 109.73,14.75 112.13,17.15 128.39,17.15 130.81,14.73 136.98,14.73 139.11,12.6 140.46,12.6 141.09,11.98 146.82,11.98 v2(147.14,12.3) ; v2(65.4,16.2) 65.99,16.2 66.51,15.69 66.51,14.85 67.47,13.89 67.47,13.13 67.76,12.83 68.33,12.83 71.6,16.1 72.31,16.1
  IN5 w0.099: v2(147.14,12.3) 147.57,11.86 148.02,11.86 148.9,12.74 163.33,12.74 164.07,12.01 183.48,12.01 186.74,15.27 201.97,15.27 201.98,15.26 214.26,15.26 215.24,14.27 225.74,14.27 226.07,13.94 231.61,13.94 232.16,14.48 246.43,14.48 249.2,11.71 262.63,11.71 263.16,12.23 265.49,12.23 266.3,11.42 268.85,11.42 268.91,11.35 272.21,11.35 272.61,11.75 272.61,12.13 273.99,13.51 276.93,13.51 278.35,14.93 285.1,14.93 285.68,15.51 287.17,15.51 287.49,15.83 289.9,15.83 290.77,16.71 293.62,16.71 v2(295.36,14.97)
ACAV_IN1: length 21.8
  TOP w0.254: v2(60.63,21.57) 60.3,21.9 v1(60.22,21.9) 58.76,21.9 58.61,22.05 57.61,22.05 PQ1906.1 ; PQ1906.1 56.02,21.96 PR1918.1 ; PQ1906.1 56.32,20.77 PR1911.1 55.77,19.86 54.88,18.97 PR1921.1 ; PR1941.1 64.54,12.29 65.53,13.29 v2(65.53,13.55)
  IN2 w0.254: v2(65.53,13.55) 65.53,13.79 63.71,15.62 63.71,18.48 62.99,19.19 62.99,19.36 61.96,20.39 61.77,20.39 60.91,21.24 60.91,21.28 v2(60.63,21.57)
ACIN_ISL88738: length 5.4
  TOP w0.203: PU1900.19 51.58,14.51 52.1,15.03 v2(52.25,15.03)
  BOTTOM w0.254: PR1904.2 PR1906.1 PC1925.1 53.26,13.54 52.76,14.05 v1(52.76,14.81) 52.54,15.03 v2(52.25,15.03)
ACOK_ISL88738: length 4.3
  TOP w0.203: PR1921.2 53.08,18.8 v1(53.02,18.74) 52.23,17.95 52.23,17.4 51.34,16.51 PU1900.24
ADP_ISL88738: length 3.3
  TOP w0.203: PU1900.16 50.31,12.53 50.38,12.46 v1(50.38,11.67) 50.38,10.48 50.74,10.12 PR1903.2
ALL_GPWRGD: length 10.3
  TOP w0.14: RV590.2 196.24,47.68 195.63,47.07 v1(195.63,46.34) 195.63,46.2 196.11,45.72 197.94,45.72 198.55,46.33 UV20.4 199.08,45.81 199.58,45.3 199.58,43.77 RV1132.2
ALW_PWRGD_3V_5V: length 312.8
  TOP w0.14: v2(73.77,21.18) 73.68,21.18 PR271.1 72.16,22.71 PR295.2 ; v1(345.49,26.07) 345.44,26.02 v2(345.44,25.53)
  TOP w0.254: PR407.1 345.12,25.21 v2(345.44,25.53)
  IN3 w0.091: v2(345.44,25.53) 344.25,25.53 340.76,22.04 330.67,22.04 328.54,24.17 v2(319.93,24.17)
  IN6 w0.089: 101.98,10.08 98.43,10.08 96.88,11.63 95.71,11.63 94.79,12.55 93.77,12.55 93.62,12.4 92.02,12.4 91.62,12.81 87.08,12.81 85.28,14.6 84.53,14.6 84,15.14 83.46,15.14 83.11,15.49 83.11,16.16 82.74,16.52 81.34,16.52 80.89,16.07 80.89,15.25 81.31,14.82 81.31,14.39 81.09,14.17 79.46,14.17 79.26,14.37 78.08,14.37 77.71,14.73 77.71,16.14 74.76,19.1 74.76,19.26
  IN6 w0.099: 101.98,10.08 103.09,10.08 103.36,9.8 103.68,9.8 104.41,9.07 104.95,9.07 105.52,9.64 105.52,10.44 106,10.92 107.77,10.92 108.29,10.4 110.39,10.4 110.97,9.82 111.61,9.82 112.53,10.73 113.29,10.73 113.97,11.42 117.64,11.42 118.24,12.03 121.18,12.03 123.05,13.89 137.89,13.89 138.32,13.47 141.18,13.47 143.2,11.45 147.92,11.45 148.88,10.49 150.63,10.49 150.94,10.8 152.01,10.8 152.19,10.98 163.23,10.98 164.21,11.96 185.23,11.96 185.45,11.74 192.41,11.74 194.35,13.68 224.86,13.68 229.14,9.4 239.52,9.4 239.78,9.65 256.67,9.65 257.49,8.83 264.24,8.83 265.62,10.21 271.76,10.21 273.77,8.2 278.62,8.2 280.04,6.79 280.63,6.79 280.82,6.98 287.5,6.98 288.24,6.24 290.89,6.24 292.07,7.42 297.39,7.42 298.55,8.57 303.14,8.57 303.59,9.03 303.59,10.04 303.9,10.34 306.42,10.34 307.91,8.85 308.95,8.85 311.18,11.08 313.37,11.08 314.31,12.02 314.31,16.13 315.03,16.84 315.03,18.72 318.82,22.51 319.05,22.51 319.93,23.39 v2(319.93,24.17) ; 74.76,19.26 74.46,19.55 74.46,20.49 v2(73.77,21.18)
ALWON: length 137
  TOP w0.076: UE3.A5 293.63,13.77 v2(293.63,13.77)
  TOP w0.14: v2(325.97,30.12) 327.13,31.28 328.88,31.28 330.16,32.56 330.16,34.89 330.65,35.38 332.26,35.38 333.5,36.62 335.96,36.62 336.76,35.81 339.3,35.81 342.07,33.05 344.72,33.05 346.97,30.8 v1(346.97,29.97) PR326.1 ; DI15.1 247.91,9.21 247.59,9.53 247.59,10.99 247.24,11.33 RZ1951.1 245.63,11.74 v2(245.87,11.98) ; v2(293.63,13.77) 293.19,13.77 292.62,13.2 291.81,13.2 RH5884.2
  IN1 w0.099: v2(312.71,26.31) 312.16,26.31 311,25.15 310.9,25.15 310.11,24.36 310.11,23.59 309.45,22.94 307.83,22.94 305.08,20.18 304.34,20.18 303.79,19.63 302.56,19.63 301.9,20.29 299.67,20.29 298.41,19.04 298.41,16.47 297.7,15.76 295.45,15.76 293.63,13.93 v2(293.63,13.77)
  IN3 w0.091: v2(325.97,30.12) 325.97,28.79 323.72,26.54 317.37,26.54 316.87,26.04 312.99,26.04 v2(312.71,26.31)
  IN6 w0.099: v2(293.63,13.77) 294.12,14.26 294.12,14.88 293.78,15.21 292.59,15.21 290.25,12.87 289.56,12.87 289.27,13.17 289.27,13.85 288.43,14.69 287.64,14.69 287.21,14.26 282.97,14.26 281.65,15.58 277.03,15.58 276.25,16.36 268.45,16.36 266.46,14.36 258.62,14.36 256.95,12.69 246.58,12.69 v2(245.87,11.98)
AUD_AZA_CPU_SCLK: length 153.9
  IN6 w0.099: v2(108.32,15.89) 107.84,16.37 107.84,16.51 110.83,19.5 170.57,19.5 171.32,20.26 176.01,20.26 177.04,21.29 177.04,26.52 180.72,30.2 180.72,31.29 188.13,38.7 188.13,51.13 189.56,52.57 189.56,57.87 185.1,62.34 185.1,64.39 184.06,65.43 183.71,65.43 180.16,68.99 180.16,74.93 177.96,77.13 173.69,77.13 173.5,77.32 173.5,77.39 173.5,77.4 173.5,77.7 174.12,78.32 174.12,79.3 174.52,79.7 v2(174.52,80.67)
  BOTTOM w0.076: UH1.G27 174.52,79.86 v2(174.52,80.67)
  BOTTOM w0.14: RH147.1 105.72,11.1 106.35,11.73 106.35,13.27 107.02,13.94 107.02,13.99 108.32,15.29 v2(108.32,15.89)
AUD_AZA_CPU_SCLK_R: length 8.8
  BOTTOM w0.089: UH2.AM3 98.25,11.8 98.31,11.74 98.31,11.74 98.61,11.43 98.93,11.43 99.26,11.1 99.63,11.1 99.82,11.3 100.95,11.3 101.32,10.93 101.32,10.87 101.44,10.75 101.98,10.75
  BOTTOM w0.14: v1(105.58,12.07) 104.74,11.23 RH147.2 104.28,11.1 104.06,10.88 102.72,10.88 102.59,10.75 101.98,10.75
AUD_AZA_CPU_SDI: length 8.7
  BOTTOM w0.14: v1(180,79.2) 180,79.39 180.65,80.04 RH145.1 180.14,80.72 179.51,81.35 179.44,81.35 179.39,81.4 174.49,81.4 174.18,81.09 UH1.G29
AUD_AZA_CPU_SDI_R: length 159.7
  IN5 w0.099: v2(98.81,11.01) 98.93,11.13 101.93,11.13 102.57,11.77 104.69,11.77 105.18,11.28 108.46,11.28 108.99,10.75 109.52,10.75 109.76,10.99 109.76,11.84 110.56,12.64 115.26,12.64 115.89,13.27 117.98,13.27 118.71,12.55 120.8,12.55 122.25,14 131.27,14 132.39,15.11 141.05,15.11 141.9,15.96 164.52,15.96 165.07,15.41 176.3,15.41 180.06,19.17 180.06,21.42 v2(179.91,21.57)
  IN6 w0.099: v2(179.91,21.57) 179.91,25.36 182.81,28.26 182.81,31.18 193.4,41.76 193.4,54.49 191.71,56.18 191.71,60.39 181.52,70.58 v2(181.52,79.22)
  BOTTOM w0.089: UH2.AN3 98.37,11.34 98.69,11.01 v2(98.81,11.01)
  BOTTOM w0.14: v2(181.52,79.22) 181.53,79.24 181.53,79.83 RH145.2
AUD_AZA_CPU_SDO: length 161.7
  IN5 w0.099: v2(103.85,11.31) 103.87,11.3 104.14,11.3 104.4,11.04 108.38,11.04 108.9,10.52 109.61,10.52 109.98,10.89 109.98,11.71 110.69,12.41 115.35,12.41 115.98,13.05 117.89,13.05 118.62,12.32 120.89,12.32 122.34,13.77 131.58,13.77 132.54,14.74 141,14.74 141.99,15.74 164.42,15.74 164.98,15.18 176.39,15.18 180.26,19.05 180.35,19.13 180.35,21.42 v2(180.5,21.57)
  IN6 w0.089: 181.1,69.53 180.98,69.66 180.98,76.81 179.83,77.96 174.86,77.96 174.51,77.61 v2(174.51,77.55)
  IN6 w0.099: v2(180.5,21.57) 180.06,21.13 179.54,21.13 179.13,21.54 179.13,24.9 182.59,28.35 182.59,31.56 192.38,41.35 192.38,54.61 190.81,56.18 190.81,58.3 189.02,60.09 189.02,61.62 181.1,69.53
  BOTTOM w0.076: UH1.G25 174.18,77.87 v2(174.51,77.55)
  BOTTOM w0.14: RH146.1 102.46,11.28 103.06,11.28 103.65,11.86 v1(103.77,11.86) 103.85,11.78 v2(103.85,11.31)
AUD_AZA_CPU_SDO_R: length 3.7
  BOTTOM w0.089: RH146.2 101.37,11.13 101.02,11.47 99.75,11.47 99.56,11.28 99.35,11.28 99.02,11.62 98.69,11.62 98.57,11.75 UH2.AM2
AUD_PWR_EN: length 132.2
  TOP w0.089: v2(98.96,6.94) 98.96,7.01 RH568.1 98.27,7.77 RH569.1
  TOP w0.14: 10.39,4.56 10.35,4.52 9.86,4.52 9.55,4.83 9.08,4.83 8.89,5.02 8.89,5.46 9.09,5.66 UA4.3 ; 10.39,4.56 v2(10.42,4.52) ; 10.39,4.56 10.48,4.65 10.48,5.18 9.89,5.77 UA4.5 ; v2(4.52,10.65) 4,11.17 JAUDIO.2
  IN1 w0.099: v2(10.42,4.52) 10.47,4.57 12.55,4.57 13.42,5.44 16.08,5.44 16.38,5.14 19.63,5.14 23.54,1.22 41.64,1.22 47.33,6.91 49.87,6.91 51.52,8.56 57.49,8.56 60.8,5.24 63.59,5.24 64.24,5.9 64.83,5.9 65.14,5.59 65.14,5.12 v2(65.22,5.04)
  IN3 w0.089: v2(98.96,6.94) 98.96,6.8 98.35,6.19 95.42,6.19 95.11,5.88 94.79,5.88 94.24,6.43 93.5,6.43 92.89,7.05 92.54,7.05 92.34,6.85 92.34,6.54 92.15,6.35 91.84,6.35 91.5,6.69 90.66,6.69 89.61,7.73 89.61,8.01 89.17,8.45 88.33,8.45 87.87,8 87.87,6.85 87.48,6.45 86.78,6.45 86.34,6.88 86.34,7.61 86.07,7.88 85.43,7.88 84.97,7.42 84.97,6.93 84.43,6.38 83.4,6.38 82.98,6.8 82.98,7.5 83.8,8.32 83.8,9.07 83.58,9.29 83.33,9.29 83.23,9.19 81.17,9.19 81.05,9.31 80.64,9.31 79.89,8.56 79.05,8.56 78.61,8.99 78.21,8.99 77.85,8.64 77.14,8.64 76.4,7.9 73.46,7.9 73.28,7.72
  IN3 w0.091: 73.28,7.72 72.8,7.24 71.89,7.24 69.61,4.96 69.27,4.96 69.02,5.21 69.02,5.45 68.29,6.19 65.41,6.19 65.22,6 v2(65.22,5.04)
  IN6 w0.099: v2(4.52,10.65) 5.18,9.98 5.97,9.98 6.43,9.53 6.43,9.22 10.42,5.23 v2(10.42,4.52)
  BOTTOM w0.089: v2(98.96,6.94) 98.87,7.03 97.97,7.03 97.85,6.91 97.82,6.84 97.82,6.5 97.65,6.34 96.08,6.34 95.83,6.09 UH2.BD8
  BOTTOM w0.14: UA3.3 4.84,10.98 v2(4.52,10.65)
AUDIO_AMP_SMBCLK: length 20.8
  TOP w0.076: UE3.D7 296.53,15.37 v2(296.12,14.96)
  TOP w0.14: QE18.3 286.75,8.02 286.64,8.13 286.64,8.88 RE95.1 v1(286.97,10.22) 286.97,10.54 v2(286.75,10.76)
  IN2 w0.089: v2(296.12,14.96) 295.72,14.56 295.06,14.56 294.95,14.45 294.95,14.17
  IN2 w0.099: v2(286.75,10.76) 286.75,11.99 287.72,12.96 289.94,12.96 290.34,13.35 294,13.35 294.11,13.46 294.11,15.23 294.22,15.33 294.41,15.33 294.51,15.23 294.51,13.05 294.63,12.93 294.85,12.93 294.95,13.04 294.95,14.17
AUDIO_AMP_SMBDAT: length 24.3
  TOP w0.076: v2(296.93,14.99) 297.31,15.37 UE3.E7
  TOP w0.14: QE18.6 284.56,6.72 284.49,6.78 RE94.1 283.43,7.33 283.43,9.49 283.38,9.54 283.38,9.89 v1(283.04,10.22) v2(283.04,11.62)
  IN2 w0.099: v2(296.93,14.99) 296.34,15.57 294.98,15.57 294.77,15.79 293.54,15.79 292.47,16.85 290.46,16.85 289.7,16.09 287.45,16.09 287,15.63 286.13,15.63 283.04,12.54 v2(283.04,11.62)
AUX_EN_WOWL: length 67.8
  TOP w0.14: v2(296.16,11.77) UE3.D3
  IN2 w0.099: v2(336.57,44.36) 335.9,43.7 335,43.7 329.79,38.49 329.79,36.72 329.06,35.98 v2(329.06,35.94)
  IN6 w0.099: v2(296.16,11.77) 296.16,11.75 296.61,11.3 298.86,11.3 299.15,11.59 299.65,11.59 299.74,11.49 300.01,11.23 300.01,10.92 300.4,10.53 301.95,10.53 302.27,10.84 306.73,10.84 307.56,10.02 309.55,10.02 311.02,11.49 311.58,11.49 312.18,12.09 312.18,13.6 313.62,15.04 313.62,16.03 314.63,17.04 314.63,18.97 319.15,23.49 319.15,24.64 319.79,25.27 319.79,30.74 322.58,33.53 326.65,33.53 v2(329.06,35.94)
  BOTTOM w0.14: v1(337.63,43.46) 337.47,43.46 v2(336.57,44.36) DN3.3 336.57,46.29 RZ1142.1
B+: length 208.3
  TOP w0.254: PR1922.2 44.26,15.43 43.56,14.73 v2(43.18,14.73) ; PD1902.2 59.79,12.86 60.07,12.57 60.07,10.58 59.81,10.31 59.68,10.31 v2(59.58,10.22)
  IN1 w0.254: v2(59.58,10.22) 59.31,10.22 58.62,9.53 46.23,9.53 43.52,12.23 43.52,14.67 43.46,14.73 v2(43.18,14.73)
  IN3 w0.762: 11.51,13.56 18.42,13.56 24.03,19.18 30.95,19.18 33.61,21.85 34.09,21.85
  IN4 w0.254: v2(34.04,22.66) 31.42,22.66 30.42,21.65 30.42,19.62 33.12,16.92 41.42,16.92 43.12,15.23 43.12,14.8 v2(43.18,14.73)
  IN6 w1.016: 254.15,22.91 254.19,22.95 254.19,24.58 257.88,28.26 269.91,28.26 271.12,27.05 272.46,27.05 274.07,25.45 276.63,25.45 276.78,25.6 277.95,25.6
  BOTTOM w1.016: 252.86,20.45 252.22,19.81 252.22,18.23 251.18,17.18 186.79,17.18 186.23,16.62 181.09,16.62 177.89,13.42 149.72,13.42 149.56,13.26
  vias: v2(10.44,13.82) v2(10.44,13.23) v2(33.86,26.49) v2(34.34,23.17) v2(34.45,26.49) v2(34.63,22.59) v2(34.93,23.14) v2(35.03,26.49) v2(35.26,22.58) v2(35.54,23.12) v2(35.62,26.48) v2(35.84,22.58) v2(36.11,25.62) v2(36.11,25.03) v2(36.1,24.44) v2(36.12,23.84) v2(36.12,23.24) v2(36.22,26.47) v2(36.42,22.61) v2(36.77,25.83) v2(36.81,25.2) v2(36.81,24.61) v2(36.81,24.03) v2(36.82,23.37) v2(37.02,22.61) v2(37.36,25.46) v2(37.4,24.85) v2(37.4,24.25) v2(37.42,23.67) v2(37.42,23.06) v2(43.52,33.57) v2(43.96,33.14) v2(98.49,47.96) v2(98.91,48.44) v2(99.19,47.85) v2(99.69,48.48) v2(100.12,47.93) v2(100.54,48.56) v2(101.07,49.02) v2(101.57,49.52) v2(102,49.95) v2(104.01,56.57) v2(104.22,69.19) v2(104.22,68.56) v2(104.22,67.92) v2(104.22,67.29) v2(104.51,56.92) v2(104.51,56.26) v2(104.84,69.19) v2(104.84,68.56) v2(104.84,67.92) v2(104.84,67.29) v2(105.37,68.26) v2(105.39,67.58) v2(107.04,100.22) v2(107.83,100.22) v2(108.47,100.22) v2(109.1,100.22) v2(109.74,100.22) v2(116.29,92.54) v2(116.93,92.54) v2(117.54,92.58) v2(118.17,92.58) v2(126.93,106.79) v2(126.92,104.95) v2(127.52,106.76) v2(127.51,104.95) v2(128.1,106.76) v2(128.09,104.95) v2(128.76,106.76) v2(128.75,104.95) v2(129.37,106.76) v2(129.36,104.95) v2(129.95,104.95) v2(129.96,106.76) v2(130.54,106.82) v2(130.52,106.19) v2(130.56,105.56) v2(130.56,104.96) v2(131.14,106.19) v2(131.16,106.83) v2(131.18,105.57) v2(131.19,104.97) v2(162.18,109.45) v2(162.19,108.85) v2(162.27,108.19) v2(162.73,109.76) v2(162.82,109.12) v2(162.82,108.48) v2(162.8,107.86) v2(162.75,107.26) v2(162.75,106.63) v2(163.01,110.3) v2(163.32,108.13) v2(163.34,107.41) v2(163.33,106.75) v2(163.36,109.51) v2(163.36,108.8) v2(163.57,110.12) v2(197.87,111.7) v2(197.88,111.13) v2(198.44,111.7) v2(198.45,111.13) v2(199.01,111.7) v2(199.02,111.13) v2(199.58,111.7) v2(199.59,111.13) v2(200.15,111.7) v2(200.17,111.13) v2(248.98,114.15) v2(248.98,113.48) v2(248.99,112.82) v2(249.01,112.12) v2(249.47,114.48) v2(249.47,113.81) v2(249.47,113.15) v2(249.46,112.47) v2(253.49,22.17) v2(253.49,21.56) v2(279.08,26.67) v2(279.72,26.67) v2(279.92,33.13) v2(279.98,32.53) v2(280.6,33.14) v2(280.58,32.5) v2(281.19,33.09) v2(281.18,32.46) v2(281.8,33.12) v2(281.79,32.41) v2(282.42,33.06) v2(283.06,33.03) v2(315.7,15.75) v2(316.08,16.28) v2(316.08,15.16) v2(316.18,17.48) v2(316.41,16.84) v2(316.43,15.7) v2(316.74,15.16) v2(316.79,17.45) v2(316.76,16.28) v2(317.12,18.04) v2(317.12,16.89) v2(317.09,15.7) v2(317.37,17.5) v2(317.37,16.28) v2(317.37,15.16) v2(318.24,17.86) v5(34.44,24.84)
B++: length 13.5
  TOP w0.508: PR415.2 339.66,22.83 339.96,23.13 v2(341.15,23.13)
  BOTTOM w0.508: v2(330.84,20.19) 331.79,20.19 333.43,21.83 339.86,21.83 339.98,21.96 v2(341.15,23.13)
  vias: v5(320.31,18.8)
B+_0.95V:
  vias: v1(107.18,57.74) v2(107.54,58.98) v2(107.54,58.19) v2(108.15,58.98)
B+_1.8VSP:
  vias: v1(243.45,109.13) v2(247.13,109) v2(247.12,108.41) v2(247.73,109.03) v2(247.72,108.44)
B+_1V:
  vias: v1(136.34,10.26) v2(136.67,9.81) v2(137.25,9.81) v2(137.83,9.81)
B+_1VSP:
  vias: v1(244.6,118.17)
B_DE0: length 1.6
  TOP w0.14: RI21.1 319.47,36.32 320,35.79 UI3.3
B_DE1: length 2.4
  TOP w0.14: v1(319.28,33.15) RI22.1 319.53,34.29 UI3.6
B_EQ0: length 1.7
  TOP w0.14: UI3.2 320.2,36.29 319.4,37.09 RI17.1
B_EQ1: length 1.5
  TOP w0.14: UI3.4 319.55,35.29 RI18.1
BAT1_LED#: length 151.7
  TOP w0.14: v2(296.16,18.17) UE3.D10 ; v2(169.11,10.57) v5(169.11,11.13)
  IN1 w0.076: v2(296.16,18.17) 295.74,18.58 295.15,18.58
  IN1 w0.099: v2(169.11,10.57) 169.63,10.05 176.15,10.05 176.54,9.65 183.36,9.65 183.8,10.08 188.01,10.08 188.2,9.89 204.78,9.89 205.77,10.89 211.25,10.89 213.76,8.38 218.76,8.38 221.55,11.18 227.27,11.18 227.78,10.67 239.71,10.67 239.82,10.78 251.88,10.78 252.76,9.89 260.19,9.89 262.8,12.51 267.12,12.51 268.93,14.32 279.45,14.32 280.26,15.14 286.08,15.14 286.44,15.5 290.09,15.5 290.78,16.18 293.32,16.18 294.33,17.19 294.33,17.76 295.15,18.58
  BOTTOM w0.14: v2(169.11,10.57) 169.11,10.35 166.87,8.11 166.87,7.24 165.71,6.09 162.32,6.09 158.8,9.6 JKB.10
BAT2_LED#: length 152.8
  TOP w0.14: v2(168.02,10.16) 168.02,9.84 v5(168.28,9.59) ; v2(296.96,18.98) 296.56,18.58 UE3.D11
  IN1 w0.076: 296.71,18.73 296.56,18.59 296.56,17.92 296.41,17.77 294.97,17.77 294.81,17.61
  IN1 w0.099: 296.71,18.73 v2(296.96,18.98) ; 294.81,17.61 294.64,17.44 294.64,17.07 292.1,14.53 286.35,14.53 285.94,14.94 280.64,14.94 279.82,14.12 269.01,14.12 267.15,12.26 266.4,12.26 266.24,12.1 262.69,12.1 260.28,9.69 252.68,9.69 251.82,10.55 239.97,10.55 239.78,10.35 227.78,10.35 227.2,10.92 221.68,10.92 218.88,8.13 213.71,8.13 211.15,10.69 205.95,10.69 204.9,9.64 188.1,9.64 187.86,9.88 183.94,9.88 183.51,9.45 176.46,9.45 176.06,9.85 168.33,9.85 v2(168.02,10.16)
  BOTTOM w0.14: v2(168.02,10.16) 168.02,9.6 166.63,8.21 166.63,7.34 165.61,6.33 162.42,6.33 159.3,9.44 JKB.9
BAT_LED#_LV1: length 5.8
  TOP w0.14: LED1.1 347.92,108.59 v1(347.28,107.95) 347.28,106.55 346.52,105.79 RL5.2
BAT_LED#_LV1_D: length 3.9
  TOP w0.14: RL5.1 343.32,105.79 v1(343.03,105.5) 342.54,105.5 341.5,104.46 Q4.1
BAT_LED#_LV2: length 3.9
  TOP w0.14: RL4.2 v1(347.22,104.9) 348.91,104.9 LED2.1
BAT_LED#_LV2_D: length 22.5
  TOP w0.14: v2(343.68,96.65) 343.58,96.75 v1(343.58,98.39) 343.58,101.01 343.29,101.29 343.29,103.87 344.22,104.8 RL4.1 ; QH5.3 345.27,86.77 343.28,86.77 342.47,87.59 342.47,88.24 342.05,88.66 342.05,89.26 342.49,89.7 v2(342.56,89.7)
  IN6 w0.099: v2(342.56,89.7) 342.61,89.74 342.61,95.58 v2(343.68,96.65)
BAT_LED#_LV3: length 4.9
  TOP w0.14: RL3.2 346.5,103.89 v1(347.15,103.24) LED3.1
BAT_LED#_LV3_D: length 36.8
  TOP w0.14: RL3.1 343.53,103.19 343.53,101.39 344.26,100.66 v1(344.26,99.9) v2(344.26,96.69) ; v6(336.65,87.49) 337.25,86.89 337.25,85.57 338.96,83.86 345.85,83.86 346.06,84.08 346.86,84.08 347.01,84.22 QH5.6
  IN6 w0.099: v6(336.65,87.49) 337.57,88.42 339.66,88.42 339.84,88.24 340.81,88.24 340.9,88.15 341.2,88.15 341.69,88.63 342.61,88.63 342.97,89 342.97,90.12 342.85,90.24 342.85,95.4 343.19,95.73 343.63,95.73 344.26,96.37 v2(344.26,96.69)
BAT_LED#_LV4: length 7.5
  TOP w0.14: LED4.1 347.73,99.06 v1(347.73,100.59) 347.73,101.6 346.46,102.87 RL2.2
BAT_LED#_LV4_D: length 46.2
  TOP w0.14: v2(332.7,86.03) 332.95,86.28 334.9,86.28 335.45,85.73 335.45,84.93 337.06,83.32 347.25,83.32 347.3,83.36 349.31,83.36 349.53,83.59 QH3.3 ; RL2.1 343.77,102.42 343.77,101.49 344.79,100.47 v1(344.79,97.51) 344.79,97.48 v2(345.61,96.66)
  IN2 w0.099: v2(345.61,96.66) 345.05,97.23 341.42,97.23 337.18,92.98 337.18,90.29 335.9,89.01 335.13,89.01 334.21,88.1 334.21,87.54 v2(332.7,86.03)
BAT_LED#_LV5: length 9.8
  TOP w0.14: LED5.1 347.04,96.15 v1(347.04,97.35) 347.04,100.84 346.03,101.86 RL1.2
BAT_LED#_LV5_D: length 35.1
  TOP w0.14: QH3.6 348.23,86.02 347.26,86.99 346.92,86.99 346.63,87.29 344.56,87.29 343.98,87.87 343.98,89.52 342.26,91.24 337.53,91.24 v2(336.64,90.36) ; v2(346.16,97.33) 345.77,97.72 345.77,100.31 v1(345.47,100.6) RL1.1
  IN2 w0.099: v2(336.64,90.36) 336.64,92.92 341.61,97.89 345.27,97.89 345.83,97.33 v2(346.16,97.33)
BATBTN#: length 177.9
  TOP w0.14: SW2.3 350.15,111.6 349.99,111.76 349.99,113.77 350.15,113.93 SW2.4 349.06,115.86 348.1,115.86 346.71,114.48 DL1.2 346.35,114.42 346.35,113.18 v2(346.33,113.16) ; RP19.4 285.96,12.82 v2(286.11,12.96) 287.08,11.98 v5(287.08,11.8) ; v2(292.96,12.92) 293.37,13.34 294.53,13.34 UE3.B5
  IN6 w0.076: 294.02,12.13 294.02,12.54 293.64,12.92 293.56,12.92
  IN6 w0.099: 293.56,12.92 v2(292.96,12.92) 292.57,12.53 292.57,11.41 290.54,9.38 290.54,8.58 290.24,8.27 287.78,8.27 286.89,9.16 286.89,10.04 287.36,10.51 287.36,11.01 287.12,11.25 287.12,11.95 v2(286.11,12.96) ; 294.02,12.13 294.02,11.67 294.59,11.1 298.95,11.1 299.23,11.39 299.57,11.39 299.8,11.15 299.8,10.84 300.32,10.33 302.03,10.33 302.35,10.64 306.65,10.64 307.49,9.8 309.62,9.8 311.1,11.28 313.29,11.28 314.1,12.09 314.1,16.23 314.83,16.96 314.83,18.81 319.41,23.38 319.41,24.51 320.1,25.21 320.1,30.67 322.76,33.33 327.21,33.33 329.84,35.97 329.84,41.91 332.47,44.54 332.47,47.75 332.3,47.92 332.3,55.39 336.76,59.85 336.76,63.28 333.97,66.08 333.97,80.39 335.47,81.9 335.47,85.55 338.08,88.16 339.47,88.16 339.65,87.97 340.24,87.97 340.35,87.86 341.24,87.86 341.8,88.42 343.5,88.42 344.01,88.93 344.01,89.73 344.93,90.65 344.93,104.85 344.1,105.68 344.1,112.45 344.81,113.16 v2(346.33,113.16)
BATT++: length 2.5
  TOP w0.14: 26.71,17.18 26.71,17.29 v5(27.18,17.76) v5(28.93,17.76)
  vias: v2(22.07,6.27) v2(22.66,6.27) v2(23.29,6.27) v2(24.44,7.93) v2(24.44,7.34) v2(24.44,6.76) v2(24.44,6.17) v2(24.91,16.62) v2(24.91,15.93) v2(25.5,16.5) v2(25.53,15.93) v2(26.11,15.93) v2(26.65,6.43) v2(26.65,5.82) v2(26.75,15.93) v2(27.23,6.43) v2(27.23,5.82) v2(27.86,6.43) v2(27.86,5.82) v5(25.54,17.11)
BATT_LED#_LV1: length 123.5
  TOP w0.14: v2(342.01,105.79) 341.25,105.79 v1(340.93,105.47) 340.62,105.16 340.62,103.46 Q4.3 ; v2(297.82,20.58) 297.82,19.71 UE3.F12
  IN6 w0.099: v2(297.82,20.58) 298.02,20.37 302.03,20.37 302.52,20.85 302.52,21.36 302.83,21.68 303.16,21.68 303.66,21.18 304.22,21.18 304.58,21.54 304.58,23.59 304.95,23.97 304.95,24.7 305.75,25.5 306.49,25.5 307.11,26.12 307.11,29.8 308.86,31.56 310.84,31.56 314.91,35.62 314.91,36.28 318.18,39.56 326.2,39.56 327.15,40.51 327.15,44.1 328.33,45.28 328.33,51.13 328.78,51.58 328.78,55.98 330.97,58.17 330.97,62.78 330.75,63 330.75,64.8 330,65.55 330,79.65 329.64,80.01 329.64,84.21 335.49,90.06 335.49,91.27 341.69,97.48 341.69,99.04 343.75,101.09 343.75,102.5 342.61,103.65 342.61,105.2 v2(342.01,105.79)
BATT_LED#_LV2: length 115.8
  TOP w0.14: v2(299.37,18.21) 299.37,18.18 UE3.G10 ; v2(340.34,89.14) 340.34,88.35 339.73,87.74 339.73,87.3 339.49,87.06 339.49,86.44 341.79,84.14 344.35,84.14 v1(344.55,84.34) 344.98,84.34 345.19,84.14 345.57,84.14 345.71,84.28 QH5.4
  IN6 w0.076: v2(299.37,18.21) 299.75,18.58 299.75,18.8 299.75,18.81 299.75,19.16 299.95,19.36 300.23,19.36 300.24,19.37 301.44,19.37 301.49,19.31 302.08,19.31 302.71,19.94 303.47,19.94
  IN6 w0.099: 303.47,19.94 304.7,19.94 304.98,19.66 306.69,19.66 307.06,19.29 309.36,19.29 311.53,21.46 313.69,21.46 318.52,26.29 318.52,29.08 317.76,29.85 317.76,33.91 321.18,37.34 326.16,37.34 328.68,39.86 328.68,42.76 329.76,43.84 329.76,48.21 330.86,49.31 330.86,55.93 333.15,58.23 334.41,58.23 336.36,60.18 336.36,63.12 333.55,65.92 333.55,80.83 334.99,82.27 334.99,86.48 335.7,87.19 335.7,88.48 336.36,89.14 v2(340.34,89.14)
BATT_LED#_LV3: length 122.8
  TOP w0.14: v2(295.36,14.17) UE3.C6 ; QH5.1 347.01,86.48 346.48,87.01 343.63,87.01 342.75,87.9 342.75,88.3 342.47,88.57 v2(342.47,89.08)
  IN6 w0.076: v2(295.36,14.17) 295.75,14.56 297.16,14.56 297.36,14.36 297.36,14 297.6,13.76 297.94,13.76 298.16,13.55 298.16,13.17 298.35,12.98 298.79,12.98 298.95,13.14 298.95,13.58 299.13,13.76 299.51,13.76 299.75,14 299.75,14.37 299.95,14.56 301.12,14.56 301.13,14.56 303.47,14.56
  IN6 w0.099: 303.47,14.56 303.61,14.42 305.56,14.42 306.03,14.88 309.68,14.88 314.58,19.79 314.58,21.59 319.03,26.04 319.03,31.35 319.66,31.98 319.66,35.07 320.65,36.07 327.53,36.07 328.23,36.77 328.23,38.29 329.18,39.24 329.18,42.1 331.83,44.74 331.83,46.21 331.11,46.93 331.11,55.9 332.17,56.96 332.17,56.96 333.24,58.03 334.49,58.03 336.56,60.1 336.56,63.2 333.76,66.01 333.76,80.75 335.19,82.18 335.19,86.39 335.93,87.13 335.93,88.31 336.36,88.74 340.56,88.74 341.13,89.3 342.25,89.3 v2(342.47,89.08)
BATT_LED#_LV4: length 113.7
  TOP w0.076: UE3.J12 300.56,19.38 300.97,19.79 300.97,20.83
  TOP w0.14: v2(332.4,87.96) 335.93,91.48 342.36,91.48 344.22,89.62 344.22,88.05 344.72,87.55 346.7,87.55 347.02,87.23 347.36,87.23 347.65,86.94 349.32,86.94 349.53,86.73 QH3.4 ; 300.97,20.83 300.97,21.04 300.86,21.15 v2(300.81,21.15)
  IN6 w0.099: v2(300.81,21.15) 300.86,21.15 301.75,22.04 303.09,22.04 303.74,21.39 304.13,21.39 304.38,21.63 304.38,23.67 304.75,24.05 304.75,24.79 305.67,25.7 306.4,25.7 306.91,26.2 306.91,29.89 308.77,31.76 310.76,31.76 314.7,35.7 314.7,36.37 318.15,39.82 325.3,39.82 325.93,40.45 325.93,43.24 328.13,45.44 328.13,51.27 328.58,51.72 328.58,57.02 329.77,58.21 329.77,59.19 330.77,60.2 330.77,62.69 330.55,62.92 330.55,64.72 329.8,65.46 329.8,79.24 329.39,79.66 329.39,84.24 332.4,87.25 v2(332.4,87.96)
BATT_LED#_LV5: length 104.9
  TOP w0.14: QH3.1 347.63,84.15 347.14,83.67 v1(346.7,83.67) 346.01,83.67 345.93,83.59 337.76,83.59 335.91,85.44 335.91,86.17 334.54,87.54 v2(333.64,87.54) ; UE3.M13 303.13,20.34 v2(303.13,20.67)
  IN6 w0.099: v2(333.64,87.54) 331.05,84.96 330.7,84.96 329.92,84.18 329.92,80.04 330.27,79.69 330.27,65.56 330.95,64.88 330.95,63.08 331.17,62.86 331.17,58.09 329.65,56.56 329.65,51.22 328.53,50.11 328.53,45.2 327.41,44.07 327.41,40.39 326.38,39.36 318.26,39.36 315.11,36.2 315.11,35.54 310.93,31.35 310.65,31.35 308.99,29.69 308.99,27.18 307.9,26.09 307.36,26.09 306.57,25.3 305.83,25.3 305.15,24.62 305.15,23.88 304.78,23.5 304.78,20.89 304.26,20.37 303.42,20.37 v2(303.13,20.67)
BBS_BIT6: length 1.9
  TOP w0.089: RH130.2 85.23,8.12 85.83,7.52 v2(85.84,7.52)
  BOTTOM w0.089: UH2.BA26 86.12,7.79 85.85,7.52 v2(85.84,7.52)
BC_CLK_ECE1117: length 157.8
  TOP w0.076: UE3.D13 296.38,20.17 295.85,20.7 v2(295.48,20.7)
  IN3 w0.091: v2(295.48,20.7) 295.36,20.82 295.07,20.82 294.07,19.83 290.95,19.83 287.53,16.4 287.53,16.23 287.01,15.71 286.35,15.71 285.69,15.05 285.69,12.69 285.98,12.4 286.26,12.4 286.54,12.11 286.54,11.13 286.32,10.91 286.21,10.91 285.68,10.38 282.77,10.38 281.27,8.88 272.91,8.88 271.78,7.75 235.33,7.75 234.95,7.37 214.12,7.37 212.12,9.37 205.97,9.37 204.46,7.86 202.56,7.86 201.95,7.25 193.07,7.25 191.79,5.97 188.69,5.97 188.18,6.48 181.9,6.48 181.72,6.3 179.44,6.3 178.34,7.4 171.04,7.4 170.43,6.79 164.71,6.79 v2(164.56,6.94)
  BOTTOM w0.14: v2(164.56,6.94) 165.57,6.94 165.67,7.04 165.67,7.46 165.57,7.56 164.85,7.56 164.71,7.7 164.71,8.05 164.78,8.13 165.56,8.13 165.73,8.29 165.73,8.57 CE81.1 164.9,9.4 164.65,9.4 163.68,8.43 160.8,8.43 159.84,9.39 159.84,10.33 159.8,10.37 JKB.8
BC_DAT_ECE1117: length 158.3
  TOP w0.076: UE3.D12 296.87,19.68 296.87,20.29 296.64,20.52 296.5,20.52 296.19,20.83
  TOP w0.14: 296.19,20.83 295.73,21.29 v2(295.48,21.29) ; v2(286.13,11.32) RP19.1
  IN3 w0.091: v2(295.48,21.29) 295.36,21.17 294.92,21.17 293.93,20.17 290.81,20.17 287.18,16.55 287.18,16.37 286.87,16.06 286.21,16.06 285.34,15.19 285.34,12.1 v2(286.13,11.32) 286.13,11.32 285.53,10.72 282.62,10.72 281.12,9.22 272.77,9.22 271.64,8.09 235.19,8.09 234.81,7.71 214.27,7.71 212.27,9.71 205.83,9.71 204.32,8.2 202.41,8.2 201.8,7.59 192.92,7.59 191.65,6.32 188.84,6.32 188.32,6.83 181.76,6.83 181.58,6.65 179.58,6.65 178.48,7.74 170.89,7.74 170.28,7.14 166.64,7.14 v2(166.16,7.62)
  BOTTOM w0.14: v2(166.16,7.62) 166.16,8.29 167.18,9.32 167.18,10.49 166.91,10.77 165.8,10.77 165.15,10.12 CE82.1 164.91,9.79 164.48,9.79 163.52,8.83 160.96,8.83 160.23,9.55 160.23,10.32 160.3,10.39 JKB.7
BC_INT#_ECE1117: length 149.5
  TOP w0.14: v2(161.64,9.59) v5(161.64,10.25) ; UE3.E2 297.69,11.04 297.69,10.32 297.86,10.15 297.86,9.59 297.55,9.28 v2(297.42,9.28)
  IN1 w0.099: v2(161.64,9.59) 162.06,10.01 163.5,10.01 163.86,9.65 175.98,9.65 176.38,9.25 183.81,9.25 184.21,9.65 187.71,9.65 187.97,9.39 205.03,9.39 206.02,10.38 211.16,10.38 213.61,7.93 219.06,7.93 221.81,10.67 227.02,10.67 228.29,9.4 239.14,9.4 240.06,10.32 251.77,10.32 252.65,9.44 260.87,9.44 262.85,11.42 267.7,11.42 268.03,11.75 268.03,12.47 268.64,13.08 273.09,13.08 273.76,13.74 286.97,13.74 287.86,12.86 290.17,12.86 290.24,12.79 291.34,12.79 292.63,11.5 294.18,11.5 296.62,9.06 297.2,9.06 297.42,9.28 v2(297.42,9.28)
  BOTTOM w0.14: v2(161.64,9.59) 160.8,10.43 JKB.6
BEEP: length 347
  TOP w0.14: v2(300.16,18.94) 299.78,18.57 UE3.H11 ; v2(3.51,29.01) 3.34,29.01 2.9,28.56 RA4.1
  IN1 w0.076: 73.28,13.69 73.6,13.69 74.2,13.09 74.56,13.09 75.02,13.55 75.39,13.55 76.79,12.15 78.85,12.15 79.29,12.59 80.07,12.59 80.14,12.65 83.77,12.65 83.92,12.5 85.36,12.5 85.64,12.78 86.6,12.78 87.43,13.6 87.9,13.6 88.06,13.77 88.06,14.16 88.27,14.36 90.19,14.36 90.64,14.81 94.08,14.81 95.83,13.06 98.02,13.06 98.48,12.6 101.22,12.6 101.73,13.11 101.98,13.11
  IN1 w0.099: v2(273.31,10.83) 273.31,9.11 272.06,7.86 271.39,7.86 270.81,8.45 268.66,8.45 268.62,8.4 262.41,8.4 261.81,7.8 257.88,7.8 257.19,7.11 253.24,7.11 253.06,7.29 252.64,7.29 251.17,8.76 240.79,8.76 239.08,7.05 231.9,7.05 230.25,5.4 214.31,5.4 210.59,9.12 206.42,9.12 204.8,7.5 187.18,7.5 186.81,7.87 185.51,7.87 184.9,7.27 183.67,7.27 182.96,7.97 176.44,7.97 175.61,7.14 166.03,7.14 165.36,7.8 159.36,7.8 158.8,7.24 157.1,7.24 156.06,8.28 155.07,8.28 154.48,8.87 152.06,8.87 150.7,10.23 148.85,10.23 148.2,10.89 139.28,10.89 136.83,13.34 129.92,13.34 128.26,15 120.16,15 120.07,15.09 113.62,15.09 111.81,13.27 108.01,13.27 107.57,12.83 104.65,12.83 104.14,13.34 102.62,13.34 102.4,13.11 101.98,13.11 ; v2(65.16,11.3) 65.26,11.3 65.33,11.23 65.96,11.23 66.46,11.74 68.92,11.74 70.99,13.81 71.61,13.81 71.72,13.69 73.28,13.69
  IN2 w0.099: v2(300.16,18.94) 299.66,19.44 299.15,19.44 298.91,19.2 298.91,18.49 298.65,18.23 298.65,16.33 298.34,16.03 295.23,16.03 294.81,16.45 293.89,16.45 292.9,17.44 290.73,17.44 290.51,17.66 289.06,17.66 288.42,17.02 285.66,17.02 284.51,15.87 284.51,15.16 283.55,14.21 281.88,14.21 281.06,13.39 279.32,13.39 279.15,13.21 274.19,13.21 273.31,12.32 v2(273.31,10.83)
  IN3 w0.091: v2(6.01,16.04) 6.1,16.13 6.1,18.09 7.86,19.85 7.86,22.78 3.01,27.63 3.01,28.73 3.28,29.01 v2(3.51,29.01)
  IN6 w0.099: v2(6.01,16.04) 6.1,15.96 6.1,15.07 7.77,13.4 7.77,12.69 8.42,12.03 28.7,12.03 30.96,14.3 30.96,15.01 31.22,15.27 32.89,15.27 33.35,15.72 33.35,16.21 33.61,16.46 46.33,16.46 47.19,15.6 54.74,15.6 56.49,13.84 59.69,13.84 59.9,14.05 61.77,14.05 62.54,13.28 62.54,11.59 63.06,11.08 64.94,11.08 v2(65.16,11.3)
  BOTTOM w0.14: v1(2.95,29.25) 3.19,29.01 v2(3.51,29.01)
BIA_PWM_EC: length 3.3
  TOP w0.14: UE3.N1 303.89,10.57 304.59,9.87 v1(305.49,9.87) 306.21,9.15 RE122.2
BIA_PWM_EC_R: length 297
  TOP w0.14: RE122.1 307.81,9.15 308.03,8.93 v1(308.41,8.93) 308.61,9.13 v2(308.61,9.4)
  IN2 w0.089: 101.6,6.76 101.35,6.5 101.35,6.4 101.09,6.15 101.09,6.12 100.58,5.61 96.27,5.61 96.08,5.42 93.82,5.42 93.33,5.91 91.44,5.91 91.16,6.2 89.66,6.2 88.95,5.49 88.09,5.49 87.9,5.67 85.58,5.67 85.27,5.97 80.04,5.97 79.94,5.88 79.28,5.88 78.82,5.42 75.61,5.42 74.89,6.14 74.89,6.81 74.5,7.2 73.7,7.2
  IN2 w0.099: v2(140.15,7.67) 140.15,7.76 138.81,9.09 136.42,9.09 135.74,9.78 135.31,9.78 134.02,11.06 132.37,11.06 131.74,11.7 125.1,11.7 124.65,11.25 119.4,11.25 117.87,12.78 115.32,12.78 113.59,11.05 113.59,8.85 113.24,8.49 112.47,8.49 111.8,7.83 110.68,7.83 110.13,8.38 105.18,8.38 103.56,6.76 101.6,6.76 ; 73.7,7.2 73.47,7.2 73.43,7.16 71.88,7.16 71.01,8.04 71.01,9.79 70.66,10.14 70.32,10.14 70.08,9.89 69.74,9.89 66.93,12.7 66.93,13.37 64.39,15.91 64.39,18.86 63.74,19.52 63.74,20.98 62.93,21.78 62.04,21.78 61.22,22.61 61.22,23.05 60.78,23.48 53.36,23.48 52.35,24.49 49.57,24.49 49.11,24.03 45.37,24.03 v2(44.94,24.46)
  IN5 w0.099: v2(308.61,9.4) 308.38,9.17 307.49,9.17 306.26,7.94 299.36,7.94 298.71,7.28 296.97,7.28 296.85,7.17 295.05,7.17 294.87,6.98 291.59,6.98 291.06,7.52 290.67,7.52 290.06,6.91 281.09,6.91 280.61,6.43 269.51,6.43 268.66,7.28 262.6,7.28 261.62,8.26 235.59,8.26 235.08,7.75 214.12,7.75 210.94,10.93 202.96,10.93 202.31,10.29 198.8,10.29 196.89,8.38 195.74,8.38 193.8,6.44 188.43,6.44 187.87,7 182.17,7 181.17,6 178.77,6 178.03,6.73 171.06,6.73 170.43,6.11 159.06,6.11 158.51,6.66 152.43,6.66 151.82,6.05 148.11,6.05 145.34,8.81 141.53,8.81 140.39,7.67 v2(140.15,7.67)
  BOTTOM w0.14: DV2.3 44.82,24.58 v2(44.94,24.46)
BIA_PWM_PCH: length 221.9
  TOP w0.127: 83.15,33.87 82.79,33.52 82.79,31.68 81.06,29.95 80.88,29.95 79.79,28.86 78.97,28.86 78.61,28.5 78.61,27.73 78.61,27.55 78.12,27.06 77.39,27.06 76.93,26.6 75.17,26.6 74.26,25.7 74.26,24.27 73.51,23.52 v2(72.97,23.52)
  TOP w0.14: 83.15,33.87 83.81,33.87 84.51,33.17 84.51,32.77 85.95,31.34 103.69,31.34 105.21,32.85 v2(105.21,33.07) ; v5(180.15,88.58) v2(180.8,88.58)
  IN2 w0.089: v2(74.74,10.68) 74.05,11.37 74.05,12.41
  IN2 w0.099: 74.05,12.41 72.75,13.71
  IN2 w0.127: 72.75,13.71 71.68,14.78 71.68,16.48 72.24,17.04 72.24,22.79 v2(72.97,23.52)
  IN4 w0.127: v2(131.94,90.65) 131.94,89.21 131.38,88.65 131.38,87.87 130.28,86.77 130.28,82.41 129.59,81.71 129.33,81.71 127.81,80.2 127.81,66.82 123.14,62.14 123.14,59.43 121.48,57.78 121.48,54.04 122.43,53.09 122.43,51.64 121.73,50.94 121.73,49.77 122.23,49.28 122.23,47.78 118.5,44.06 115.01,44.06 113.79,42.83 112.94,42.83 111.19,41.08 111.19,40.06 107.41,36.28 107.41,35.28 v2(105.21,33.07)
  IN6 w0.089: v2(74.74,10.68) 74.37,11.04 74.37,12.36 73.28,13.45
  IN6 w0.099: v2(131.94,90.65) 131.94,90.73 134.13,92.92 164.86,92.92 165.65,92.13 174.45,92.13 175.8,90.78 177.44,90.78 178.03,90.2 179.84,90.2 180.7,89.34 180.7,88.69 v2(180.8,88.58) ; v2(47.25,22.96) 47.63,22.58 49.39,22.58 49.74,22.23 51.91,22.23 52.19,22.51 55.64,22.51 57.88,20.27 61.58,20.27 61.81,20.04 63.34,20.04 63.56,20.26 68.89,20.26 71.11,18.05 71.11,15.85 72.17,14.79
  IN6 w0.127: 72.17,14.79 72.96,14 72.96,13.77 73.28,13.45
  BOTTOM w0.089: UH2.AU48 75.93,9.77 75.52,10.19 75.27,10.19 74.78,10.68 v2(74.74,10.68)
  BOTTOM w0.127: DV2.2 46.12,24.09 v2(47.25,22.96)
  BOTTOM w0.14: RH456.2 181.24,88.14 v2(180.8,88.58)
BID_BC: length 23.3
  TOP w0.14: RH567.1 RH566.2 107.66,9.53 v1(108.79,10.66) 109.23,11.1 v2(109.23,11.16)
  IN5 w0.089: 101.98,11.5 101.87,11.38 97.31,11.38 97.03,11.66 95.86,11.66 95.63,11.43 94.76,11.43 94.53,11.66 93.72,11.66 93.69,11.7 91.84,11.7 91.42,11.28 v2(91.17,11.28)
  IN5 w0.099: v2(109.23,11.16) 109.23,11.21 108.94,11.51 106.2,11.51 106.2,11.51 105.27,11.51 104.79,11.99 102.48,11.99 101.98,11.5
  BOTTOM w0.089: UH2.AR18 90.63,10.74 v2(91.17,11.28)
BID_DIS: length 276.8
  TOP w0.089: RH565.1 77.33,11.88 RH564.2 77.34,12.18 v2(77.01,12.51)
  TOP w0.14: v2(305.82,5.46) 306.58,6.22 308.86,6.22 309.79,5.3 311.27,5.3 311.75,5.78 312.17,5.78 312.8,6.42 312.8,9.16 314.61,10.97 v1(314.61,12.02) 314.61,15.89 315,16.28 315,18.29 314.49,18.8 RE112.2
  IN2 w0.099: v2(123.4,10.19) 118.7,10.19 117.88,11.01 v2(117.35,10.99)
  IN3 w0.089: 101.98,10.51 100.27,8.8 99.63,8.8 99.26,8.42 98.49,8.42 97.82,9.09 96.25,9.09 95.38,9.97 94.9,9.97 94.45,10.42 93.4,10.42 93.1,10.72 93.1,11.17 93.27,11.35 94.45,11.35 95.07,11.96 95.07,12.41 94.82,12.66 93.78,12.66 93.26,12.14 92.11,12.14 91.52,12.72 89.91,12.72 89,11.81 87.15,11.81 86.13,12.83 80.33,12.83 80.01,12.51 79.24,12.51 79.02,12.29 77.92,12.29 77.85,12.22 77.54,12.22 77.25,12.51 v2(77.01,12.51)
  IN3 w0.091: v2(117.35,10.99) 116.9,11.43 115.84,11.43 114.64,12.63 109.31,12.63 108.99,12.31 103.79,12.31 101.98,10.51 ; v2(123.4,10.19) 123.93,9.67 125.63,9.67 126.78,10.82 128.57,10.82 130.34,9.05 132.84,9.05 134.02,7.88 138.24,7.88 138.63,8.27 140.95,8.27 141.78,9.1 145.34,9.1 146.61,7.83 147.68,7.83 147.97,8.12 149.41,8.12 150.1,7.44 150.63,7.44 150.7,7.37 151.44,6.63 156.14,6.63 156.49,6.28 170.96,6.28 171.59,6.91 176.95,6.91 177.13,6.73 178.32,6.73 179.33,5.72 182.11,5.72 182.39,5.99 187.74,5.99 188.25,5.48 196.98,5.48 198,6.51 201.91,6.51 202.76,7.36 204.65,7.36 205.98,8.69 211.66,8.69 214.5,5.84 238.51,5.84 239.52,6.86 251.61,6.86 252.81,5.66 259.61,5.66 259.99,5.29 262.11,5.29 262.99,6.17 267.23,6.17 267.56,5.84 273.43,5.84 274.09,6.5 284.43,6.5 285.62,5.31 286.78,5.31 287.1,5.63 291.16,5.63 292.25,6.72 294.64,6.72 294.99,6.36 294.99,5.36 295.24,5.12 296.49,5.12 297.31,5.94 299.38,5.94 300.1,5.22 302.25,5.22 302.43,5.04 305.39,5.04 v2(305.82,5.46)
  BOTTOM w0.089: UH2.AL47 v2(77.01,12.51)
BID_GPU: length 5.8
  BOTTOM w0.089: 92.24,1.91 RH5858.1 92.24,2.76 92.74,3.26 92.74,3.69 92.58,3.85 92.58,4.96 UH2.BF14
  BOTTOM w0.14: 92.24,1.91 RH5857.2 93.78,1.4 v1(93.84,1.46)
BIOS_REC: length 2.5
  TOP w0.089: RH5840.1 78.85,10.99 v2(78.41,11.43) 78.38,11.46 v1(78.38,11.94)
  BOTTOM w0.089: UH2.AR42 78.74,11.14 78.45,11.43 v2(78.41,11.43)
BOARD_ID: length 3.4
  TOP w0.14: RE67.1 300.96,22.48 CE51.1 300.38,21.9 300.38,20.35 UE3.J13
BOOT1_ISL88738: length 5.6
  TOP w0.203: PR1905.2 45.34,10.68 45.81,11.15 v1(46.43,11.15) 46.69,10.9 47.32,10.9 48.71,12.29 PU1900.12
BOOT2_ISL88738:
  vias: v1(44.64,14.54)
BOOT_1.2V:
  vias: v1(285.59,30.13)
BREATH_LED#: length 144.1
  TOP w0.14: v2(333.58,119.19) 334.19,119.19 335.21,120.21 LED6.1 336.38,120.25 v1(336.51,120.12) ; UE3.C11 295.76,18.59 295.36,18.99 v2(295.36,18.99)
  IN6 w0.099: v2(295.36,18.99) 295.36,18.99 296.53,20.17 298.07,20.17 298.07,20.17 302.97,20.17 302.97,20.17 304.7,20.17 305.22,20.69 306.81,20.69 309.51,23.39 309.51,26.23 309.88,26.6 309.88,27.88 311.65,29.64 312.01,29.64 312.88,30.51 312.88,32.17 314.45,33.73 315.8,33.73 319.82,37.75 326,37.75 328.28,40.03 328.28,42.93 329.34,43.99 329.34,49.71 330.45,50.82 330.45,56.23 332.51,58.28 332.51,62.67 331.75,63.42 331.75,65.22 331.08,65.89 331.08,69.52 332.35,70.8 332.35,84.49 335.28,87.42 335.28,89.05 335.98,89.75 335.98,91.06 339.82,94.89 341.02,94.89 343.95,97.82 343.95,102.59 342.81,103.73 342.81,105.73 343.7,106.62 343.7,113.33 337.83,119.19 v2(333.58,119.19)
BST1_3V: length 1.4
  TOP w0.14: 341,24.58 341,25.41 v5(340.58,25.83)
BST1_5V: length 3
  TOP w0.14: PC411.1 344.23,17.69 345.16,16.77 346.36,16.77 v1(346.67,16.45)
BST1_NVVDD:
  vias: v1(165.47,113.82)
BST1_NVVDDS: length 1.3
  BOTTOM w0.14: PR1510.1 190.44,112.52 190.12,112.52 v1(189.68,112.08)
BST2_NVVDD: length 0.5
  TOP w0.14: v2(170.57,113.92) v1(170.57,113.4)
  vias: v2(170.17,114.36)
BST_0.95V:
  vias: v1(109.55,58.89)
BST_0.95V_R: length 1
  BOTTOM w0.14: PR800.2 v1(111.58,57.84)
BST_1.8VSP: length 1.6
  BOTTOM w0.14: PR1600.1 242.98,104.24 242.11,105.11 v1(242.11,105.36)
BST_1V: length 1
  BOTTOM w0.14: v1(133.26,9.78) 133.19,9.7 PR501.1
BST_1V_R: length 1.7
  BOTTOM w0.14: PC502.1 130.68,9.82 130.32,10.19 v1(129.25,10.19)
BST_1VSP: length 0.6
  TOP w0.14: v2(240.41,117.25) v1(241.03,117.25)
  vias: v2(239.83,117.25)
BST_1VSP_R: length 1
  TOP w0.14: PC902.1 237.91,116.97 v1(237.91,117.29)
BST_3V: length 1.4
  TOP w0.14: v1(344.13,25.78) 343.66,25.31 PR411.2
BST_5V: length 1.4
  TOP w0.14: PR412.1 341.89,16.61 v1(341.64,16.37)
BT_RADIO_DIS#: length 111.2
  TOP w0.14: RE72.2 296.05,7.96 295.55,8.45 v2(295.37,8.45) 295.94,9.03 295.94,10.11 296.1,10.28 296.1,11.02 UE3.C2 ; v2(326.8,72.22) v1(326.8,71.64)
  IN6 w0.099: v2(326.8,72.22) 326.81,64.84 327.98,63.67 327.98,52.01 326.77,50.8 326.77,45.98 325.38,44.58 325.38,40.77 324.93,40.32 316.42,40.32 312.6,36.51 312.6,34.17 310.59,32.16 308.61,32.16 306.5,30.05 306.5,26.37 306.24,26.1 305.5,26.1 304.35,24.95 304.35,24.22 303.53,23.39 302.59,23.39 302.03,23.95 302.03,24.94 301.83,25.15 300.33,25.15 297.98,22.79 291.25,22.79 v2(290.96,23.09)
  BOTTOM w0.127: v2(295.37,8.45) 295.37,9.36 295.06,9.67 295.06,13.04 293.9,14.2 293.04,14.2 292.48,14.76 292.48,16.41 291.99,16.9 291.99,19.25 290.61,20.63 290.61,22.52 290.97,22.88 290.97,23.08 v2(290.96,23.09)
  BOTTOM w0.14: v2(326.8,72.22) 327.25,72.67 328.07,72.67 331.85,76.46 DN2.1
BT_RADIO_DIS#_R: length 19.8
  IN2 w0.099: v2(332.79,79.12) 332.79,82.59 338.72,88.52 340.35,88.52 341.26,89.43 v2(341.26,90.12)
  BOTTOM w0.14: JNGFF1.46 341.8,90.66 v2(341.26,90.12) ; v2(332.79,79.12) 331.88,79.12 DN2.2 v1(330.54,79.15)
CAM_CBL_DET#: length 67.7
  IN1 w0.099: v2(63.97,22.71) 63.97,22.35 66.04,20.28 69.66,20.28 69.96,19.98 71.19,19.98 72.14,20.93 v2(72.76,20.93)
  IN2 w0.089: 73.52,17.74 73.52,16.39 73.56,16.36 73.56,15.3 ; 74.59,13.12 74.59,11.89 76.09,10.39 79.19,10.39 79.54,10.75 79.73,10.75 80.53,11.55 83.67,11.55 84.29,12.17 86.39,12.17 86.94,11.62 88.88,11.62 89.75,12.49 91.45,12.49 91.73,12.21 92.03,12.21 93.09,11.15 93.09,9.71 v2(93.31,9.5)
  IN2 w0.099: 73.56,15.3 72.91,14.66 72.91,14.3 73.18,14.03 74.58,14.03 74.87,13.73 74.87,13.4 74.59,13.12 ; 73.52,17.74 73.52,18.06 73.39,18.19 73.39,19.55 73.19,19.76 73.18,20.5 v2(72.76,20.93)
  BOTTOM w0.089: UH2.AW13 93.31,8.46 v2(93.31,9.5)
  BOTTOM w0.14: v2(72.76,20.93) 71.89,20.93 RH511.1 ; v2(63.97,22.71) 63.97,23.59 62.27,25.3 61.06,25.3 60.26,26.09 60.26,28 60.63,28.37 60.63,30.23 59.79,31.08 59.79,31.89 57.88,33.8 54.72,33.8 53.6,34.92 53.6,35.6 53.73,35.72 JEDP1.29
CD_WAKE#: length 5.2
  BOTTOM w0.14: v1(345.4,34.16) RR1.2 344.77,35.43 344.51,35.18 RR10.2 342.4,36.19 UR1.32
CEMSM#: length 1.4
  TOP w0.089: T4970.1 149.06,68.73 v2(149.35,68.44)
  BOTTOM w0.076: UH1.AW13 149.75,68.05 v2(149.35,68.44)
CERSVD1: length 1.2
  TOP w0.089: v2(150.29,68.36) 149.92,67.98 T4967.1
  BOTTOM w0.076: UH1.AU13 150.6,68.05 v2(150.29,68.36)
CERSVD2: length 1.1
  TOP w0.089: v2(148.45,68.36) 148.43,68.34 T4968.1
  BOTTOM w0.076: UH1.AY13 148.76,68.05 v2(148.45,68.36)
CEZVM#: length 1.2
  TOP w0.089: v2(151.2,68.43) 151.57,68.06 T4969.1
  BOTTOM w0.076: UH1.AT13 151.58,68.05 v2(151.2,68.43)
CFG0: length 49.4
  TOP w0.14: RH488.2 130.86,96.01 131.15,96.3 v2(131.15,96.65) ; JXDP.9 126.81,88.01 125.55,89.27 v2(125.55,89.46) ; RH183.1 132.45,77.24 132.51,77.31 139.04,77.31 v5(139.38,77.65) 139.73,77.99 v2(139.73,78.1)
  IN2 w0.099: v2(139.73,78.1) 139.31,77.69 138.52,77.69 138.34,77.86 135.34,77.86 135.01,77.54 132.49,77.54 131.34,78.69 130.18,78.69 127.57,81.3 127.57,83.05 126.9,83.72 126.9,85.43 126.34,85.99 126.34,87.49 126.02,87.81 126.02,88.99 v2(125.55,89.46) 125.71,89.61 125.71,90.83 125.91,91.03 126.09,91.03 126.65,91.59 128.04,91.59 129.45,93 130.71,93 130.87,92.84 131.39,92.84 132.6,94.05 132.6,94.55 131.15,96.01 v2(131.15,96.65)
  BOTTOM w0.076: UH1.BN25 139.4,77.78 v2(139.73,78.1)
CFG1: length 19
  TOP w0.089: v5(140.45,79.06) 139.83,79.68 v2(139.73,79.68)
  TOP w0.14: JXDP.11 130.11,88.51 v2(130.49,88.13)
  IN2 w0.099: v2(130.49,88.13) 130.49,87.24 130.89,86.84
  IN2 w0.102: 130.89,86.84 131.13,86.6 132.28,86.6 132.67,86.21 132.67,83.23 134.78,81.11 135.63,81.11 136.1,80.64 138.73,80.64 139.7,79.68 v2(139.73,79.68)
  BOTTOM w0.076: UH1.BN27 139.4,79.35 v2(139.73,79.68)
CFG2: length 26.5
  TOP w0.14: RH184.1 133.01,77.57 137.47,77.57 v5(137.61,77.71) 138.69,77.71 v2(139.08,78.1) ; JXDP.15 129.87,89.51 v2(129.92,89.46)
  IN2 w0.102: v2(139.08,78.1) 136.92,80.26 135.95,80.26 135.5,80.71 133.97,80.71 133.52,81.16 132.31,81.16 131.29,82.19 131.29,85.27 129.59,86.96 129.59,89.13 v2(129.92,89.46)
  BOTTOM w0.076: v2(139.08,78.1) 139.4,78.43 UH1.BN26
CFG3: length 21.2
  TOP w0.089: v2(139.08,79.68) 138.61,79.68 v5(138.48,79.81)
  TOP w0.14: v2(130.81,86.32) 131.28,86.32 131.64,86.68 131.64,87.31 131.07,87.89 131.07,89.16 130.21,90.01 JXDP.17
  IN2 w0.089: 134.62,80.99 134.7,80.91
  IN2 w0.099: v2(130.81,86.32) 131.13,86.32 132.28,85.17 132.28,83.33 134.62,80.99
  IN2 w0.102: v2(139.08,79.68) 137.77,79.68 137,80.45 136.02,80.45 135.57,80.91 134.7,80.91
  BOTTOM w0.076: v2(139.08,79.68) 139.4,80 UH1.BN28
  BOTTOM w0.14: v2(130.81,86.32) 131.09,86.04 RH474.2
CFG4: length 35.8
  TOP w0.089: v1(135.13,75.05) 135.13,74.89 v2(134.77,74.54) 134.62,74.69
  TOP w0.14: JXDP.27 126.69,92.51 v2(126.63,92.57) ; 134.62,74.69 134,75.31 RH185.1
  IN2 w0.099: v2(126.63,92.57) 126.63,92.51 125.9,91.77 125.64,91.77
  IN2 w0.102: 125.64,91.77 125.29,91.43 123.79,91.43 122.61,90.24 122.61,84.49 123.89,83.21 123.89,81.42 131.27,74.04 134.28,74.04 v2(134.77,74.54)
  BOTTOM w0.076: UH1.BR20 137.81,74.07 137.33,74.07 137.19,73.93 135.38,73.93 v2(134.77,74.54)
CFG5: length 48.9
  TOP w0.089: v2(140.38,73.38) 140.64,73.38 v5(141.21,72.81)
  TOP w0.14: RH186.1 131.81,72.25 132.23,71.83 133.07,71.83 v2(133.41,72.18) ; v2(125.78,92.57) 126.22,93.01 JXDP.29
  IN2 w0.099: v2(125.78,92.57) 125.04,91.83 124.18,91.83
  IN2 w0.102: v2(140.38,73.38) 139.99,73.76 135.89,73.76 135.74,73.61 130.78,73.61 121.64,82.75 121.64,83.65 122.2,84.2 122.2,90.41 123.62,91.83 124.18,91.83
  IN6 w0.089: 134.62,72.67 139.67,72.67 v2(140.38,73.38)
  IN6 w0.099: v2(133.41,72.18) 133.91,72.67 134.62,72.67
  BOTTOM w0.076: v2(140.38,73.38) 140.05,73.7 UH1.BM20
CFG6: length 37.4
  TOP w0.14: v5(130.84,73.88) 131.36,74.4 RH187.1 132.4,74.05 133.04,74.05 v2(133.5,74.52) ; JXDP.33 127.15,94.01 v2(126.59,93.45)
  IN2 w0.102: v2(133.5,74.52) 132.77,75.26 130.34,75.26 124.47,81.12 124.47,82.91 122.81,84.58 122.81,90.16 123.88,91.22 125.38,91.22 125.72,91.56 126.33,91.56 127.06,92.29 127.06,92.98 v2(126.59,93.45)
  BOTTOM w0.14: UH1.BT20 137.28,73.6 134.43,73.6 v2(133.5,74.52)
CFG7: length 40.6
  TOP w0.14: v2(125.95,93.45) 126.42,93.92 126.56,93.92 127.15,94.51 JXDP.35 ; v2(136.01,74.55) 136.01,73.78 v5(135.97,73.74) 135.61,73.74 135.21,73.34 RH188.1
  IN2 w0.102: v2(136.01,74.55) 135.28,73.83 130.85,73.83 121.85,82.83 121.85,83.56 122.4,84.12 122.4,90.33 123.71,91.63 125.21,91.63 125.55,91.97 125.8,91.97 126.23,92.41 126.23,93.17 v2(125.95,93.45)
  BOTTOM w0.076: UH1.BP20 138.43,74.09 138.2,74.09 138.03,74.27 137.2,74.27 137.07,74.14 136.42,74.14 v2(136.01,74.55)
CFG8: length 24.8
  TOP w0.089: v2(135.41,76.14) 135.41,76.44 v1(135.23,76.62)
  TOP w0.14: JXDP.10 123.68,88.01 v2(124.03,88.35)
  IN2 w0.102: v2(124.03,88.35) 124.03,87.01 124.99,86.05 124.99,83.86 125.49,83.36 125.49,81.63 130.39,76.73 134.81,76.73 v2(135.41,76.14)
  BOTTOM w0.076: UH1.BR23 137.71,76.53 135.8,76.53 v2(135.41,76.14)
CFG9: length 27.3
  TOP w0.14: v2(134.14,76.14) 134.14,76.21 v1(133.81,76.54) ; JXDP.12 123.44,88.51 124.32,89.39 v2(124.32,89.47)
  IN2 w0.099: v2(134.14,76.14) 133.75,76.53 130.31,76.53 127.97,78.86
  IN2 w0.102: 127.97,78.86 127.92,78.86 125.29,81.5 125.29,83.27 124.79,83.78 124.79,85.96 123.62,87.13 123.62,88.69 124.32,89.39 v2(124.32,89.47)
  BOTTOM w0.076: UH1.BR22 137.81,75.64 137.33,75.64 137.19,75.5 134.77,75.5 134.62,75.65
  BOTTOM w0.14: 134.62,75.65 v2(134.14,76.14)
CFG10: length 26.7
  TOP w0.089: v2(136.04,76.14) 136.65,75.53 v5(136.78,75.53)
  TOP w0.14: JXDP.16 123.53,89.51 123.92,89.9 124.54,89.9 v2(124.96,89.49)
  IN2 w0.102: v2(124.96,89.49) 124.96,89.38 124.44,88.86 124.44,87.82 125.19,87.06 125.19,83.94 125.7,83.44 125.7,81.71 130.48,76.93 135.25,76.93 v2(136.04,76.14)
  BOTTOM w0.076: UH1.BT23 137.06,75.74 136.44,75.74 v2(136.04,76.14)
CFG11: length 29.2
  TOP w0.14: v2(124.7,90.58) 124.3,90.17 123.75,90.17 123.59,90.01 JXDP.18 ; v1(132.39,76.29) 132.55,76.12 v2(133.5,76.12)
  IN2 w0.099: v2(133.5,76.12) 130.38,76.12 125.09,81.41 125.09,83.19 124.56,83.72 124.56,85.83
  IN2 w0.102: 124.56,85.83 123.42,86.97 123.42,89.61 123.8,89.99 124.12,89.99 v2(124.7,90.58)
  BOTTOM w0.076: 134.62,75.28 137.39,75.28 UH1.BT22
  BOTTOM w0.127: 134.35,75.28 v2(133.5,76.12)
  BOTTOM w0.14: 134.62,75.28 134.35,75.28
CFG12: length 38.8
  TOP w0.089: v2(139.73,73.38) 139.73,72.91 v5(139.42,72.61)
  TOP w0.14: v2(125.2,92.58) 125.2,92.51 124.83,92.14 123.84,92.14 123.47,92.51 JXDP.28
  IN2 w0.102: v2(125.2,92.58) 125.2,92.51 124.77,92.08 123.58,92.08 122,90.49 122,84.29 121.44,83.73 121.44,82.66 130.71,73.39 139.71,73.39 v2(139.73,73.38)
  BOTTOM w0.076: UH1.BM19 140.05,73.05 v2(139.73,73.38)
CFG13: length 36.7
  TOP w0.089: v5(137.63,72.23) 137.33,72.53 136.43,72.53 v2(136.06,72.16)
  TOP w0.14: v2(124.03,92.57) 124.03,92.78 123.8,93.01 JXDP.30
  IN2 w0.102: v2(124.03,92.57) 123.79,92.57 121.79,90.58 121.79,84.37 121.24,83.82 121.24,82.58 130.62,73.19 135.03,73.19 v2(136.06,72.16)
  BOTTOM w0.076: v2(136.06,72.16) 136.45,72.55 137.13,72.55 137.2,72.49 137.82,72.49 138.1,72.77 UH1.BR19
CFG14: length 38.8
  TOP w0.14: v2(124.61,92.58) 124.61,92.89 123.49,94.01 JXDP.34
  IN2 w0.102: v2(135.42,72.16) 134.66,72.92 130.6,72.92 121.04,82.49 121.04,83.9 121.59,84.46 121.59,90.7 123.31,92.42 123.31,92.71 123.84,93.24 124.19,93.24 124.59,92.85 124.59,92.83 124.61,92.8 v2(124.61,92.58)
  BOTTOM w0.076: UH1.BP19 138.43,73.31 137.98,73.31 137.75,73.08 137.75,72.82 137.63,72.69 137.33,72.69 137.27,72.76 136.02,72.76 v2(135.42,72.16)
CFG15: length 37
  TOP w0.14: v2(124.66,93.47) 124.47,93.47 123.44,94.51 JXDP.36
  IN2 w0.099: v2(134.09,72.2) 133.63,72.66 132.43,72.66
  IN2 w0.102: v2(124.66,93.47) 123.78,93.47 123.1,92.8 123.1,92.5 121.39,90.79 121.39,84.54 120.83,83.98 120.83,82.41 130.58,72.66 132.43,72.66
  BOTTOM w0.14: v2(134.09,72.2) 134.88,72.99 UH1.BT19
CFG16: length 26.2
  TOP w0.089: v2(138.43,76.53) 138.43,76.03 v1(138.39,76)
  TOP w0.14: v2(124.99,88.56) 124.45,88.02 124.45,87.76 123.7,87.01 JXDP.6
  IN2 w0.102: v2(138.43,76.53) 137.82,77.14 130.56,77.14 126.28,81.42 126.28,83.44 125.43,84.29 125.43,87.12 124.99,87.55 v2(124.99,88.56)
  BOTTOM w0.076: v2(138.43,76.53) 138.75,76.2 UH1.BP23
CFG17: length 28
  TOP w0.089: v5(140.11,76.04) 139.57,76.04 v2(139.08,76.53)
  TOP w0.14: v2(125.59,88.56) 125.59,88.23 123.87,86.51 JXDP.4
  IN2 w0.102: v2(139.08,76.53) 138.27,77.34 132.4,77.34 131.26,78.49 129.5,78.49 126.91,81.07 126.91,83.22 126.28,83.86 126.28,85.69 125.65,86.31 125.65,88.49 v2(125.59,88.56)
  BOTTOM w0.076: UH1.BN23 139.4,76.2 v2(139.08,76.53)
CFG18: length 34.1
  TOP w0.089: v2(139.08,74.95) 139.08,74.79 v5(139.47,74.4)
  TOP w0.14: v2(125.29,90.6) 124.38,91.51 JXDP.24
  IN2 w0.102: v2(139.08,74.95) 138.7,74.58 138.09,74.58 137.2,75.46 130.46,75.46 124.68,81.24 124.68,83.02 123.01,84.69 123.01,90.07 123.96,91.02 124.87,91.02 v2(125.29,90.6)
  BOTTOM w0.076: v2(139.08,74.95) 139.4,75.28 UH1.BN22
