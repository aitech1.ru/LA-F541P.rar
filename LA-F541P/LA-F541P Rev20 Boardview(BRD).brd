# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDA_RST#: length 15
  BOTTOM w0.089: UH2.BE10 94.6,5.77 94.6,5.14 94.32,4.86 94.32,4.29 95.21,3.39 95.21,2.64 95.77,2.08 100.74,2.08 101.17,2.52 101.98,2.52
  BOTTOM w0.14: 101.98,2.52 103.06,2.52 v1(103.63,3.09) 104.23,3.69 104.23,4.61 104.08,4.76 RP15.4
HDA_SDIN0: length 5.6
  TOP w0.089: CD3324.1 92.76,3.66 v2(93.46,2.95) 93.28,2.77 RH96.2 92.56,2.44 v1(92.42,2.58)
  BOTTOM w0.089: v2(93.46,2.95) 93.94,3.43 93.94,5.71 UH2.BE11
HDA_SDIN0_AUDIO: length 124.3
  TOP w0.089: v2(94.01,2.96) 93.87,2.82 RH96.1
  IN1 w0.099: v2(8.69,15.04) 9.3,14.43 9.3,12.75 11.03,11.02 11.03,6.24 11.82,5.45 12.46,5.45 12.68,5.67 16.26,5.67 16.52,5.41 19.68,5.41 23.64,1.45 41.55,1.45 47.35,7.26 49.82,7.26 51.36,8.79 57.66,8.79 60.74,5.71 62.89,5.71 63.3,6.12 64.96,6.12 65.45,5.64 65.45,5.39 66.08,4.75 66.08,3.54 67.87,1.75 75.02,1.75 75.49,2.22 77.04,2.22 77.5,1.77 82,1.77 82.67,2.44 85.71,2.44 86.21,2.94 87.94,2.94 89.05,1.83 89.91,1.83 90.31,2.22 93.27,2.22 v2(94.01,2.96)
  BOTTOM w0.14: v2(8.69,15.04) 7.79,15.94 7.79,19.19 8.09,19.5 8.09,19.79 8.34,20.04 8.34,23 6.58,24.77 3.49,24.77 v1(2.92,25.34) 2.41,25.85 RA6.1
HDA_SDOUT: length 39.7
  TOP w0.14: v2(118.33,3.89) 118.37,3.93 v1(118.37,5.57) 117.99,5.95 117.99,6.35 117.48,6.86 115.57,6.86 115.16,6.45 RH454.2
  IN1 w0.099: v2(118.33,3.89) 118.19,3.75 106.66,3.75 v2(106.26,4.14)
  BOTTOM w0.089: 95.13,1.91 94.47,2.56 93.3,2.56 93.1,2.76 93.1,3.11 93.76,3.77 93.76,4.84 UH2.BF12
  BOTTOM w0.14: 95.13,1.91 95.51,1.53 106.3,1.53 106.99,2.21 CD3325.1 CH51.2 106.99,3.42 v2(106.26,4.14) 105.35,4.14 105.08,4.41 RP15.2
HDA_SDOUT_AUDIO: length 145.5
  TOP w0.14: CA38.1 4.03,31.79 v2(3.81,31.57) 4.41,31.57 v1(4.43,31.55)
  IN2 w0.099: v2(3.49,36.07) 3.86,36.07 4.16,35.77 4.16,34.36 3.81,34.01 v2(3.81,31.57)
  IN6 w0.089: 101.98,7.63 101.14,7.63 100.57,8.21 99.61,8.21 99.07,7.67 96.64,7.67 95.89,6.92 95.12,6.92 94.55,7.49 93.06,7.49 92.74,7.81 92.16,7.81 91.05,6.7 90.3,6.7 89.27,5.67 87.61,5.67 86.81,6.47 86.81,8.1 87,8.29 87,9.82 86.22,10.6 84.82,10.6 84.73,10.51 83.13,10.51 82.83,10.8 82.83,11.21 82.7,11.34 80.13,11.34 79.34,10.54 77.17,10.54 75.8,11.91 75.8,13.39 75.52,13.68 75.52,15.03 74.57,15.98 72.53,15.98 72.4,16.11 72.4,16.11 72.31,16.2
  IN6 w0.099: v2(107.52,7.12) 107.52,7.43 107.34,7.62 106.08,7.62 105.88,7.42 102.2,7.42 101.98,7.63 ; v2(3.81,31.57) 3.81,31.9 4.17,32.26 4.17,32.64 4.93,33.4 5.84,33.4 7.94,35.5 12.49,35.5 13.17,34.82 13.17,32.61 14.77,31.01 14.77,29.66 20.66,23.77 25.37,23.77 30.39,18.75 43.85,18.75 44.35,19.24 44.35,20.24 45.87,21.77 45.87,22.71 46.56,23.39 49.01,23.39 49.87,22.53 51.59,22.53 51.87,22.81 55.79,22.81 58.03,20.58 61.85,20.58 62.08,20.34 63.21,20.34 63.44,20.56 69.09,20.56 71.42,18.23 71.42,17.08 72.31,16.2
  BOTTOM w0.14: UA1.17 4.55,37.03 3.59,36.07 v2(3.49,36.07) ; v2(107.52,7.12) 107.06,6.66 106.02,6.66 105.87,6.81 105.42,6.81 105.08,6.46 RP15.7
HDA_SYNC: length 22.2
  BOTTOM w0.089: 94.69,1.91 94.25,2.35 93.25,2.35 93.12,2.49 93.12,2.49 92.92,2.69 92.92,3.22 93.55,3.85 93.55,4.48 93.44,4.59 UH2.BG13
  BOTTOM w0.14: 94.69,1.91 95.34,1.26 107.05,1.26 107.46,1.66 107.46,3.63 v1(106.95,4.14) 106.51,4.57 105.69,4.57 105.58,4.69 RP15.1
HDA_SYNC_AUDIO: length 136.6
  IN6 w0.089: 72.49,16.71 72.85,16.34 74.66,16.34 75.71,15.29 75.71,13.74 76.05,13.39 76.05,11.95 76.68,11.32 77.73,11.32 78.22,11.81 78.96,11.81 79.53,11.23 79.78,11.23 80.06,11.51 82.81,11.51 82.98,11.34 85.49,11.34 85.56,11.41 86.02,11.41 87.18,10.25 87.18,8.96 87.76,8.37 87.76,7.3 87.57,7.11 87.57,6.1 87.82,5.85 89.2,5.85 91.12,7.77 91.12,7.94 91.66,8.48 92.5,8.48 93.31,7.67 93.98,7.67 94.63,8.32 96.2,8.32 96.96,9.07 97.89,9.07 98.7,8.27 99.21,8.27 99.33,8.39 100.64,8.39 101.07,7.96 101.98,7.96
  IN6 w0.099: v2(5.51,34.68) 6.8,34.68 7.85,35.73 12.59,35.73 13.45,34.87 13.45,32.75 15,31.19 15,29.75 20.63,24.12 25.33,24.12 30.49,18.97 43.76,18.97 44.12,19.33 44.12,21.01 45.01,21.9 45.01,22.66 45.97,23.62 49.2,23.62 49.46,23.36 51.55,23.36 51.87,23.04 55.9,23.04 57.82,21.12 58.73,21.12 59.03,21.41 60.2,21.41 60.22,21.39 60.61,21 61.4,21 61.67,21.28 63.69,21.28 63.97,21 69.02,21 71.69,18.33 71.69,17.51 72.49,16.71 ; v2(108.12,7.14) 108.12,7.5 107.7,7.92 106.06,7.92 105.79,7.65 102.78,7.65 102.47,7.96 101.98,7.96
  BOTTOM w0.14: UA1.14 6.04,35.06 5.82,34.83 5.66,34.83 v2(5.51,34.68) 5.12,34.29 CA34.1 ; v2(108.12,7.14) 108.12,7.03 107.48,6.39 106.22,6.39 106.01,6.18 RP15.8
HDD_DET#: length 187.5
  TOP w0.14: v2(220.16,18.35) v1(220.16,16.94) 222.5,14.61 236.6,14.61 v2(237.17,14.03)
  IN4 w0.091: v2(220.16,18.35) 219.44,19.08 202.1,19.08 201.11,20.07 183.58,20.07 182.94,20.7 177.64,20.7 v2(176.63,19.69)
  IN5 w0.089: 101.98,20.99 101.75,20.99 101.63,21.11 98.74,21.11 97.31,22.54 89.79,22.54 89.18,21.93 89.18,21.76 88.46,21.04 84.56,21.04 83.99,20.47 83.99,19.95 82.82,18.78 82.82,18.28 81.98,17.44 81.98,16.78 81.69,16.49 81.13,16.49 80.19,15.55 78.6,15.55 78.36,15.31 76.94,15.31 76.64,15.01 76.64,13.9 77.38,13.15 77.38,12.5 77.61,12.27 77.89,12.27 v2(78.3,12.68)
  IN5 w0.099: 101.98,20.99 102.46,20.99 103.27,20.18 106.06,20.18 106.93,19.32 129.77,19.32 130.23,18.85 165.38,18.85 166.27,17.96 172.37,17.96 173.31,18.9 175.83,18.9 v2(176.63,19.69)
  BOTTOM w0.089: v2(78.3,12.68) 77.96,13.02 77.47,13.02 77.32,12.86 77.12,12.86 77.04,12.9 76.92,13.02 UH2.AK47 76.52,13.02 76.4,12.9 76.03,12.9 75.36,13.57 74.99,13.57 73.2,15.36
  BOTTOM w0.14: v2(237.17,14.03) 237.17,13.53 236.86,13.21 JHDD.12 ; 73.2,15.36 73.2,15.45 72.79,15.86 71.74,15.86 71.5,15.62 RH513.1
HDD_DEVSLP: length 175.5
  TOP w0.14: v2(237.87,9.84) 237.87,9.2 RD100.1 237.92,8.59 v1(238.89,7.62)
  IN6 w0.089: 101.98,10.29 98.81,10.29 97.22,11.87 95.72,11.87 93.88,13.71 91.68,13.71 91.07,13.1 90.28,13.1 89.82,13.56 86.63,13.56 85.4,14.78 84.63,14.78 84.02,15.39 83.46,15.39 83.28,15.56 83.28,16.23 82.82,16.7 80.81,16.7 80.11,15.99 80.11,14.81 v2(80.37,14.55)
  IN6 w0.099: 101.98,10.29 103.16,10.29 103.45,10 103.77,10 104.5,9.27 104.86,9.27 105.32,9.73 105.32,10.53 105.97,11.18 108.08,11.18 108.62,10.63 110.45,10.63 111.06,10.02 111.5,10.02 112.41,10.94 113.2,10.94 114.23,11.96 116.03,11.96 116.35,11.65 117.58,11.65 118.16,12.23 121.07,12.23 123.02,14.18 131.24,14.18 131.47,14.4 140.53,14.4 143.28,11.66 148,11.66 148.96,10.7 150.54,10.7 150.85,11 151.88,11 152.05,11.18 163.13,11.18 164.11,12.16 185.31,12.16 185.53,11.94 192.33,11.94 194.27,13.88 225.34,13.88 228.8,10.42 237.3,10.42 v2(237.87,9.84)
  BOTTOM w0.089: v2(80.37,14.55) 80.37,14.19 UH2.AH40
HDD_FALL_INT: length 250.2
  TOP w0.14: v2(241.43,41.94) 241.58,41.78 248.07,41.78 249.35,40.51 252.64,40.51 260.86,32.28 260.86,29.71 261.63,28.94 261.63,24.08 262.19,23.52 262.19,22.63 264.11,20.71 264.11,18.87 263.85,18.61 263.85,14.96 263.05,14.15 v1(263.05,13.83) 263.05,10.11 263.25,9.91 263.25,7.78 262.13,6.66 260.2,6.66 259.87,7 v2(259.87,7.24) ; v2(237.73,45.52) 237.43,45.82 RF4.2 236.81,46.84 UF1.12
  IN6 w0.089: v2(86.09,9.32) 86.42,8.99 86.42,8.58 86.26,8.42 86.26,6.25 87.38,5.13 89.5,5.13 90.4,6.02 91.33,6.02 91.51,6.21 94.12,6.21 94.23,6.1 100.21,6.1 101.98,6.1
  IN6 w0.099: 101.98,6.1 102.17,6.29 105.18,6.29 107,4.47 116.92,4.47 118.01,5.56 118.01,7.44 119.5,8.94 124.13,8.94 124.47,9.29 133.52,9.29 134.67,10.44 141.12,10.44 141.93,9.63 145.37,9.63 147.64,7.36 151.63,7.36 151.93,7.06 159.81,7.06 160.28,7.53 163.33,7.53 163.97,8.17 169.55,8.17 169.86,7.86 175.32,7.86 177.26,9.8 177.76,9.8 178.47,10.51 211.94,10.51 212.36,10.93 214.44,10.93 218,7.38 234.35,7.38 234.85,7.87 259.24,7.87 v2(259.87,7.24)
  BOTTOM w0.089: UH2.AW26 86.67,8.74 v2(86.09,9.32)
  BOTTOM w0.14: v2(241.43,41.94) 241.43,42.31 238.78,44.96 238.29,44.96 v2(237.73,45.52)
HDMI_CEC: length 34.8
  TOP w0.14: v2(28.45,75.76) 28.26,75.57 RM19.2
  IN1 w0.099: v2(16.16,78.13) 16.16,77.93 17.45,76.64 17.45,71.84 19.65,69.64 22.79,69.64 23.62,70.46 25.23,70.46 25.43,70.66 26.59,70.66 27.5,71.57 27.5,73.02 27.85,73.37 27.85,75.16 v2(28.45,75.76)
  BOTTOM w0.14: JHDMI1.13 12.6,85.93 12.73,85.8 12.73,81.37 15.25,78.85 15.25,78.02 CV182.2 15.94,77.92 v2(16.16,78.13)
HDMI_CLKN: length 16.1
  TOP w0.102: UM1.H1 24.89,76.48 24.89,79.41 23.42,80.87 23.42,81.15 21.34,83.23 21.34,86.15 v3(19.83,87.65) 19.17,88.31 17.85,88.31 RV532.1
HDMI_CLKP: length 16.2
  TOP w0.102: RV533.1 17.85,88.04 19.06,88.04 19.64,87.46 v3(20.72,86.39) 21.07,86.03 21.07,83.12 23.16,81.03 23.16,80.76 24.62,79.3 24.62,76.67 24.52,76.57 24.23,76.57 24.11,76.45 24.11,76.27 24.17,76.21 UM1.H2
HDMI_HPLUG: length 31.3
  TOP w0.14: CV180.2 14.52,92.71 v2(13.97,92.71) 13.97,92.74 13.65,93.05 v1(13.65,93.21) ; UM1.G1 25.63,75.88 26.23,75.88 26.47,76.13 26.47,76.86 26.93,77.32 RM27.1 26.24,77.34 v2(25.89,76.99)
  IN1 w0.099: v2(13.97,92.71) 14.76,92.71 14.99,92.48 14.99,91.57 15.88,90.68 15.88,90.15 23.75,82.28 23.75,79.88 25.89,77.74 v2(25.89,76.99)
  BOTTOM w0.14: JHDMI1.19 11.77,89.39 13.56,91.18 13.56,92.3 v2(13.97,92.71)
HDMI_ID: length 5.2
  TOP w0.127: RM24.1 17.56,72.29 17.01,72.29 16.58,71.86 15.81,71.86 v1(15.33,72.34)
  TOP w0.14: UM1.D8 19.39,72.85 19.28,72.85 18.31,71.88 RM24.1
HDMI_R_CLKN: length 12.6
  TOP w0.076: JHDMI1.12 10.57,85.35 10.74,85.17 10.96,85.17 11.12,85.33 11.12,85.61 11.07,85.66 11.07,86.19 11.09,86.21 11.09,86.65 10.98,86.76 10.98,87.1 11.1,87.22 11.1,87.64 11.05,87.69 11.05,88.17 11.12,88.24 11.12,88.62 11.01,88.73 11.01,88.87 10.96,88.91 10.96,88.93
  TOP w0.102: RV532.2 16.95,88.31 16.67,88.31 RV539.1 16.35,88.31 16.02,88.31 DT175.1 15.47,88.3 14.41,88.3 v3(14.2,88.51) 13.28,89.43 12.83,89.88 11.28,89.88 10.96,89.56 10.96,88.93
HDMI_R_CLKP: length 12.5
  TOP w0.076: JHDMI1.10 11.07,84.93 11.07,85.03 11.3,85.26 11.3,85.68 11.25,85.73 11.25,86.12 11.27,86.14 11.27,86.72 11.16,86.83 11.16,87.03 11.28,87.15 11.28,87.71 11.23,87.76 11.23,88.1 11.3,88.17 11.3,88.69 11.19,88.8 11.19,88.87 11.23,88.91 11.23,88.93
  TOP w0.089: 15.44,88.04 15.48,88.04
  TOP w0.102: 11.23,88.93 11.23,89.45 11.39,89.61 12.72,89.61 14.01,88.32 14.3,88.04 15.44,88.04 ; RV533.2 16.95,88.04 16.67,88.04 RV539.2 16.35,88.04 15.97,88.04 DT176.1 15.7,87.82 15.48,88.04
HDMI_R_TX_N0: length 7.6
  TOP w0.089: DT177.1 15.13,86.67
  TOP w0.102: DT177.1 14.62,86.69 13.04,86.69 12.63,86.28 12.63,83.91 12.3,83.58 12.12,83.58 JHDMI1.9 ; RV534.2 16.05,86.48 15.79,86.48 RV540.1 15.14,86.65 15.13,86.67
HDMI_R_TX_N1: length 12.1
  TOP w0.089: JHDMI1.6 10.57,82.15 10.69,82.03 11.03,82.03 11.23,81.83 11.32,81.57 11.32,81.29 11.22,80.95 11.22,80.87 11.3,80.65 11.3,80.31 11.16,79.92 11.16,79.64 11.21,79.59
  TOP w0.102: RV536.2 16.08,82.92 15.8,82.92 RV541.1 15.47,82.95 15.29,82.95 DT179.1 14.6,83.11 14.12,83.11 13.53,82.52 13.53,80.17 12.64,79.29 11.36,79.29 11.21,79.44 11.21,79.59
HDMI_R_TX_N2: length 8.9
  TOP w0.102: RV531.2 16.91,84.77 16.62,84.77 RV538.1 16.4,84.76 16.02,84.76 DT181.1 15.44,84.72 14.44,84.72 v3(14.12,84.41) 12.75,83.03 12.75,80.83 12.46,80.54 12.16,80.54 JHDMI1.3
HDMI_R_TX_P0: length 7.6
  TOP w0.102: RV535.2 16.07,86.22 15.77,86.22 RV540.2 15.41,86.28 14.97,86.28 DT178.1 14.61,86.42 13.15,86.42 12.89,86.17 12.89,83.8 12.41,83.31 12.15,83.31 JHDMI1.7
HDMI_R_TX_P1: length 12.1
  TOP w0.089: JHDMI1.4 10.57,81.69 10.71,81.83 10.92,81.83 11.06,81.73 11.13,81.54 11.13,81.31 11.02,80.98 11.02,80.84 11.11,80.61 11.11,80.35 10.97,79.95 10.97,79.62 10.94,79.59
  TOP w0.102: 10.94,79.59 10.94,79.33 11.25,79.02 12.75,79.02 13.79,80.06 13.79,82.41 14.23,82.85 14.63,82.85 DT180.1 15.01,82.76 15.1,82.76 15.18,82.68 15.45,82.68 RV541.2 15.76,82.66 15.99,82.66 RV537.2
HDMI_R_TX_P2: length 9
  TOP w0.102: RV530.2 16.93,84.5 16.72,84.5 RV538.2 16.31,84.49 15.98,84.49 DT182.1 15.56,84.46 14.55,84.46 13.02,82.92 13.02,80.72 12.57,80.28 12.06,80.28 11.77,79.99 JHDMI1.1
HDMI_RESERVED: length 13.7
  BOTTOM w0.14: v1(15.33,76.4) 14.42,76.4 14.11,76.71 CV181.2 14.04,77.84 14.04,78.36 13.48,78.92 11.68,78.92 11.15,79.46 11.15,86.1 10.82,86.43 JHDMI1.14
HDMI_TX_N0: length 18.4
  TOP w0.102: UM1.H3 23.43,76.33 23.43,77.22 24.04,77.83 24.04,78.88 21.93,80.99 19.77,80.99 19.53,81.23 19.53,81.89 19.75,82.11 20.1,82.11 20.39,82.39 20.39,83.25 19.6,84.03 19.6,84.59 19.73,84.72 20.03,84.72 20.39,85.07 20.39,85.86 19.74,86.5 v3(18.35,86.5) 16.96,86.5 RV534.1
HDMI_TX_N1: length 17.9
  TOP w0.102: UM1.H5 21.95,77.57 21.67,77.85 21.67,78.67 21.12,79.22 19.14,79.22 18.14,78.21 17.2,78.21 16.67,77.69 15.46,77.69 14.87,78.27 14.87,80.41 15.75,81.29 v3(16.51,81.29) 17.09,81.29 17.78,81.98 17.78,82.47 17.37,82.89 16.97,82.89 RV536.1
HDMI_TX_N2: length 17.8
  TOP w0.102: RV531.1 17.88,84.78 18.26,84.78 18.69,84.35 18.69,81.59 18.13,81.03 18.13,80.66 18.7,80.08 21.69,80.08 22.48,79.29 22.48,78.84 v2(22.74,78.59) ; v2(20.96,78.23) 20.84,78.12 20.84,77.71 20.09,76.96 20.09,76.47 UM1.H7
  IN1 w0.089: v2(22.74,78.59) 22.52,78.81 22.52,79.04 22.25,79.32 21.73,79.32 21.39,78.97 21.39,77.73 21.26,77.6 20.99,77.6 20.86,77.73 20.86,78.14 v2(20.96,78.23)
HDMI_TX_P0: length 18.4
  TOP w0.102: RV535.1 16.97,86.23 19.63,86.23 20.12,85.75 20.12,85.18 19.92,84.98 19.62,84.98 19.33,84.7 19.33,83.92 20.12,83.14 20.12,82.5 19.99,82.37 19.64,82.37 19.26,82 19.26,81.12 19.66,80.72 v3(20.96,80.72) 21.82,80.72 23.78,78.77 23.78,77.94 23.16,77.33 23.16,76.68 23.07,76.59 22.71,76.59 22.62,76.5 22.62,76.34 UM1.H4
HDMI_TX_P1: length 17.9
  TOP w0.102: UM1.H6 21.15,76.38 21.27,76.5 21.6,76.5 21.69,76.58 21.69,77.46 21.41,77.74 21.41,78.56 21.01,78.95 19.25,78.95 18.25,77.95 17.31,77.95 16.78,77.42 15.35,77.42 14.61,78.16 v3(14.61,79.25) 14.61,80.52 15.64,81.55 16.98,81.55 17.52,82.09 17.52,82.36 17.26,82.62 17,82.62 RV537.1
HDMI_TX_P2: length 17.8
  TOP w0.102: v2(20.19,78.23) 20.41,78.23 20.57,78.07 20.57,77.82 19.82,77.07 19.82,76.47 UM1.H8 ; v2(22.13,78.56) 22.22,78.66 22.22,79.18 21.58,79.81 18.59,79.81 17.86,80.55 17.86,81.14 18.42,81.7 18.42,84.24 18.15,84.51 17.88,84.51 RV530.1
  IN1 w0.089: v2(20.19,78.23) 20.4,78.23 20.61,78.02 20.61,77.62 20.89,77.34 21.37,77.34 21.64,77.62 21.64,78.87 21.84,79.07 22.14,79.07 22.27,78.94 22.27,78.71 v2(22.13,78.56)
HOST_DEBUG_TX: length 23.8
  TOP w0.14: RE297.1 306.43,26.06 RE64.2 306.94,26.57 v2(307.61,26.57) 307.97,26.57 v1(308.28,26.26) ; v2(299.36,18.97) UE3.G11
  IN3 w0.091: v2(309.6,30.92) 309.6,28.4 307.78,26.57 v2(307.61,26.57) 307.61,22.66 306.04,21.09 304.62,21.09 303.78,20.26 302.45,20.26 302.15,20.56 300.38,20.56 299.53,19.71 299.53,19.14 v2(299.36,18.97)
  BOTTOM w0.14: JDEG1.8 309.6,31.8 v2(309.6,30.92)
HOST_SD_WP#: length 305.1
  TOP w0.14: v2(103.8,4.19) 103.71,4.19 102.21,2.69 RH563.2 ; v2(348.89,31.6) v1(348.89,30.97)
  IN5 w0.099: v2(103.8,4.19) 104.18,4.58 117.14,4.58 117.47,4.9 118.76,4.9 120.48,3.19 125.88,3.19 126.73,2.34 130.9,2.34 131.52,2.97 135.4,2.97 135.89,3.45 139.96,3.45 140.8,4.3 140.8,6.06 142.52,7.78 144.81,7.78 148.25,4.33 151.08,4.33 151.42,4.67 154.49,4.67 154.97,4.19 162.23,4.19 163.24,5.2 170.08,5.2 171.27,4.02 177.72,4.02 178.16,4.45 181.85,4.45 182.87,5.47 187.26,5.47 188.22,4.51 195.68,4.51 198.32,7.15 204.05,7.15 205.71,8.82 210.27,8.82 214.78,4.3 242.73,4.3 244.89,6.46 257.15,6.46 258.16,5.45 263.31,5.45 263.83,5.97 267.79,5.97 268.99,4.77 270.21,4.77 270.87,5.43 274.1,5.43 274.98,4.54 280.18,4.54 280.33,4.39 283.2,4.39 283.63,3.97 284.29,3.97 284.77,4.44 284.77,4.51 285,4.74 288.71,4.74 289.24,4.2 296.69,4.2 297.47,4.99 298.24,4.99 299.94,6.7 301.43,6.7 302,6.12 302,5.47 302.46,5.01 306.5,5.01 306.83,5.34 308.01,5.34 308.41,4.94 308.41,4.71 308.95,4.17 311.2,4.17 311.66,4.62 313.07,4.62 314.13,5.68 314.13,6.93 312.28,8.78 312.28,19.56 316.09,23.37 324.87,23.37 325.63,24.13 327.66,24.13 329.31,25.78 329.31,31.01 330.32,32.02 340.5,32.02 341.52,33.03 346.73,33.03 348.16,31.6 v2(348.89,31.6)
  BOTTOM w0.089: 101.98,3.04 101.95,3.04 101.38,3.6 100.49,3.6 100.07,3.18 100.07,3.15 99.48,2.57 97.58,2.57 96.39,3.76 96.39,4.19 96.06,4.52 96.06,5.21 95.74,5.53 UH2.BE8
  BOTTOM w0.14: v2(103.8,4.19) 103.8,3.75 103.09,3.04 101.98,3.04 ; QR1.2 v2(348.89,31.6)
HP_JD#: length 53.5
  TOP w0.14: v2(5.51,15.73) 7.36,13.89 7.36,13.2 6.96,12.8 6.59,12.8 6.4,12.61 JAUDIO.8 6.4,11.02 5.94,10.57 v5(5.94,10.12)
  IN5 w0.254: v2(4.38,46.13) 4.38,43.95 5.41,42.93 5.41,36.07 6.22,35.26 6.22,33.47 6.05,33.3 6.05,32.28 6.17,32.16 v2(6.22,32.16)
  IN6 w0.099: v2(6.22,32.16) 6.18,32.11 5.64,32.11 4.88,31.35 4.88,26.94 6.85,24.98 8.28,24.98 9.45,23.8 9.45,20.73 6.28,17.56 5.21,17.56 4.36,16.71 4.36,15.98 4.64,15.7 5.48,15.7 v2(5.51,15.73)
  BOTTOM w0.108: RA14.1 6.12,32.92 6.12,32.26 v2(6.22,32.16)
  BOTTOM w0.254: v2(4.38,46.13) RA82.2 DA3.1 3.52,46.22 5.17,47.87 JHP1.6
HP_LINE1_JD: length 7.2
  BOTTOM w0.108: UA1.9 8.04,34.25 RA14.2 RA13.2
  BOTTOM w0.14: CA23.1 5.46,29.65 5.85,30.05 5.85,30.27 5.94,30.35 5.94,30.74 6.59,31.4 6.59,31.94 v1(6.78,32.13) 7.32,32.13 7.66,32.47 RA13.2
HPD_IFPA: length 1.2
  TOP w0.14: T4973.1 211.71,61.4 v2(211.69,61.42)
  BOTTOM w0.14: UV18.N4 212.09,61.02 211.69,61.42 v2(211.69,61.42)
HPD_IFPB: length 4.3
  BOTTOM w0.14: T4974.1 210.82,55.86 210.82,56.72 211.27,57.17 211.27,57.69 211.63,58.05 211.63,58.77 211.24,59.16 UV18.P2
HPD_IFPC: length 2.7
  TOP w0.14: T4980.1 207.53,58.99 v2(208.34,59.8)
  BOTTOM w0.14: UV18.U3 208.34,59.8 v2(208.34,59.8)
HPD_IFPD: length 1.2
  TOP w0.14: T4975.1 213.7,63.5 213.31,63.1 v2(213.31,63.07)
  BOTTOM w0.14: UV18.M6 212.94,62.7 v2(213.31,63.07)
HPD_IFPE: length 1.2
  TOP w0.14: v2(210.74,58.11) 210.42,58.11 T4976.1
  BOTTOM w0.14: UV18.R1 210.74,58.29 v2(210.74,58.11)
HPD_IFPF: length 2.3
  TOP w0.14: T4979.1 213.87,58.93 v2(214.38,58.42)
  BOTTOM w0.14: UV18.L2 214.38,58.76 v2(214.38,58.42)
HPOUT_D_L_C: length 10.6
  TOP w0.127: JHP1.1 10.8,56.91 11.52,57.63 v1(11.52,58.41)
  BOTTOM w0.508: LA6.2 13.43,52.26 CA42.2 13.42,53.16 DA2.1 13.51,54 13.72,54.2 13.72,56.41 12.69,57.44 11.37,57.44 JHP1.1
HPOUT_D_R_C: length 26.7
  TOP w0.508: v2(11.46,46.99) 12.24,46.99 12.6,46.62 v1(12.97,46.62) 13.07,46.62 13.77,47.32 CA43.1 14.16,47.32 DA9.1 14.96,46.52 LA7.2
  IN5 w0.508: JHP1.2 5.8,56.93 7.98,59.11 10.47,59.11 11.09,58.48 11.6,58.48 13.83,56.25 13.83,47.74 13.08,46.99 v2(11.46,46.99)
HPOUT_L: length 18
  TOP w0.508: RA28.2 12.93,45.33 11.78,45.33 RA75.2 11.67,46.31 v2(11.66,46.32) ; v2(10.74,43.33) 10.26,42.85 RA30.2
  IN6 w0.508: v2(11.66,46.32) 11.66,44 11,43.33 v2(10.74,43.33)
  BOTTOM w0.203: UA1.32 7.24,42.79 7.01,43.01 7.01,43.64 6.81,43.84 6.81,44.15
  BOTTOM w0.508: RA52.1 13.88,47.42 13.36,46.9 12.25,46.9 v2(11.66,46.32) v1(11.04,46.32) 8.57,46.32 6.81,44.55 6.81,44.15
HPOUT_L_R1: length 2.4
  BOTTOM w0.508: RA52.2 v1(13.88,50.31) 14.36,50.79 LA6.1
HPOUT_R: length 16.1
  TOP w0.508: RA31.2 RA27.2 11.04,42.46 RA29.2 12.03,42.85 v2(12.09,42.79) ; v2(12.83,47.63) 14.16,48.95 RA51.1
  IN3 w0.508: v2(12.09,42.79) 12.03,42.72 8.04,42.72 v2(7.54,43.23)
  IN6 w0.508: v2(12.83,47.63) 13.38,47.08 13.38,44.07 v2(12.09,42.79)
  BOTTOM w0.203: UA1.33 7.64,43.13 v2(7.54,43.23)
HPOUT_R_R2: length 2.1
  TOP w0.127: RA51.2 15.07,50.4 v1(15.03,50.45)
  TOP w0.508: RA51.2 15.07,48.51 LA7.1
HW_ACAVIN_NB: length 383.7
  TOP w0.14: v2(28.94,3.64) 30.64,1.94 PR208.2 31.28,1.6 PC207.1 31.62,1.94 31.62,2.75 31.24,3.13 PU200.1 30.18,3.13 29.34,3.97 29.34,5.31 30.46,6.43 33.96,6.43 34.85,5.54 PR207.2 ; PR1939.1 61.24,8.55 v2(61.46,8.33) ; DI14.1 307.75,14.27 307.45,13.97 v2(306.54,13.97)
  IN1 w0.099: v2(61.46,8.33) 61.48,8.35 61.48,10.28 61.66,10.45 61.66,11.73 61.04,12.35 61.04,12.6 59.81,13.84 58.08,13.84 57.72,14.2 57.72,16.38 57.52,16.58 57.52,17.84 56.37,18.99 56.37,19.6 54.94,21.03 52.74,21.03 v2(52.41,21.37)
  IN2 w0.089: 101.44,4.83 101.26,4.65 93.87,4.65 93.59,4.93
  IN2 w0.099: v2(123.99,10.24) 123.86,10.36 123.8,10.36 123.57,10.6 123.07,10.6 122.86,10.39 118.78,10.39 117.56,11.62 115.47,11.62 114.21,10.36 114.21,8.43 113.7,7.93 112.69,7.93 111.82,7.06 110.33,7.06 109.61,7.78 105.93,7.78 104.21,6.06 102.3,6.06 101.78,5.55 101.78,5.52 101.68,5.42 101.68,5.07 101.44,4.83 ; v2(61.46,8.33) 61.46,6.9 62.43,5.93 63.01,5.93 63.19,6.11 68.34,6.11 68.9,5.55 68.9,5.33 69.45,4.78 73.94,4.78 75.06,3.66 75.69,3.66 76.38,4.34 78.48,4.34 79.65,5.51 80.09,5.51 80.19,5.61 85.13,5.61 85.43,5.31 87.75,5.31 87.94,5.13 89.1,5.13 89.81,5.84 91.01,5.84 91.29,5.55 92.97,5.55 93.59,4.93
  IN5 w0.099: v2(28.94,3.64) 28.68,3.91 28.68,11.4 27.35,12.73 27.35,16.72 26.04,18.04 20.45,18.04 18.78,19.7 18.78,21.96 v2(17.43,23.32) ; v2(123.99,10.24) 125.78,10.24 126.19,10.64 130.78,10.64 130.97,10.45 131.96,10.45 132.76,9.65 135.89,9.65 136.48,9.06 139.46,9.06 141.01,10.61 146.39,10.61 147.33,9.67 148.41,9.67 149.23,8.85 168.25,8.85 168.98,8.13 193.38,8.13 196.53,11.27 197.98,11.27 198.88,12.18 198.88,12.83 199.39,13.34 212.98,13.34 215.77,10.54 247.38,10.54 248.03,9.9 261.88,9.9 263.45,8.34 268.21,8.34 268.51,8.64 270.84,8.64 271.73,7.75 278.21,7.75 279.51,9.05 284.87,9.05 285.32,8.61 291.71,8.61 292.27,8.04 294.36,8.04 295.37,9.06 297.07,9.06 297.25,8.87 297.59,8.87 297.87,9.15 299.47,9.15 300.45,10.13 302.37,10.13 304.14,11.9 305.18,11.9 305.47,12.18 305.47,13 305.86,13.4 305.97,13.4 v2(306.54,13.97)
  IN6 w0.099: v2(61.46,8.33) 59.38,6.25 59.38,4.97 59.69,4.67 59.69,3.56 59.04,2.91 54.47,2.91 53.61,2.05 53.61,1.47 53.23,1.09 45.01,1.09 44.18,1.92 42.61,1.92 41.78,1.09 31.83,1.09 29.28,3.64 v2(28.94,3.64)
  BOTTOM w0.14: PR284.1 PR285.1 53.09,19.31 52.41,19.99 v2(52.41,21.37) ; v2(17.43,23.32) 17.73,23.62 17.73,24.97 17.54,25.16 17.54,28.52 17.21,28.85 17.21,29.77 17.02,29.96 PR214.1
HW_ACAVIN_NB_P: length 3.8
  TOP w0.14: UE3.N6 303.8,14.53 304.91,14.53 305.25,14.86 DI14.2 306.05,14.96 306.76,15.67 RE142.1
I2C0_IRQ_TS_R: length 9.9
  BOTTOM w0.14: JTS1.4 343.55,48.91 342.93,49.53 340.51,49.53 339.78,48.8 339.78,47.89 340.17,47.5 341.03,47.5 342.08,46.45 342.08,45.81 RR41.2
I2C0_SCK_DSP: length 344.9
  TOP w0.14: JAUDIO.5 v2(5.6,16.46) ; v2(284.63,9.84) 284.89,9.59 RE136.2 284.89,8.18 QE18.4
  IN1 w0.076: 72.66,14.52 72.67,14.53 72.69,14.53 73.26,15.1 73.93,15.1 74.77,14.26 76.17,14.26 76.18,14.27 76.4,14.27 76.48,14.18 76.5,14.18 76.5,14.18
  IN1 w0.099: 72.66,14.52 72.55,14.41 70.72,14.41 68.62,12.32 67.54,12.32 66.96,12.9 66.96,13.58 63.83,16.72 60.83,16.72 59.97,17.58 v2(59.97,17.88) ; v2(284.63,9.84) 284.38,9.84 284.14,10.08 284.14,10.6 284.25,10.7 285.81,10.7 285.99,10.52 285.99,9.39 285.84,9.23 283.57,9.23 283.15,9.65 282.79,9.65 282.69,9.75 275.48,9.75 273.55,11.69 272.83,11.69 272.25,11.11 272.25,8.88 271.88,8.51 271.57,8.51 271.03,9.04 268.91,9.04 267.55,10.4 266.15,10.4 264.73,8.98 262.17,8.98 261.57,8.38 257.51,8.38 256.88,7.75 253.75,7.75 253.42,8.08 252.7,8.08 251.38,9.4 240.54,9.4 238.82,7.68 228.47,7.68 226.89,6.1 214.5,6.1 210.9,9.7 206.17,9.7 204.55,8.08 187.42,8.08 187.05,8.45 185.27,8.45 184.75,7.93 183.82,7.93 183.21,8.55 176.12,8.55 175.38,7.81 170.18,7.81 169.61,8.38 159.47,8.38 158.96,8.89 156.94,8.89 156.92,8.87 155.3,8.87 153.15,11.01 149.05,11.01 148.6,11.47 139.52,11.47 136.92,14.07 130.58,14.07 128.66,15.99 122.11,15.99 121.83,16.27 112.1,16.27 109.77,13.94 107.82,13.94 107.73,14.03 102.5,14.03 102.16,13.69 101.07,13.69 101.05,13.7 99.44,13.7 99,14.15 97.68,14.15 97.36,13.83 95.93,13.83 94.31,15.46 90.44,15.46 90.12,15.14 89.49,15.14 89.31,15.32 87.43,15.32 85.14,13.03 84.14,13.03 83.22,13.94 79.53,13.94 79.07,13.49 77.19,13.49 76.5,14.18 ; v2(5.57,31) 5.44,31 5,30.56 5,28.99 5.25,28.74 5.25,26.74 7.01,24.99 9.09,24.99 10.77,23.31 13.34,23.31 13.77,22.88 13.77,22.36 13.42,22.01 13.08,22.01 v2(12.95,21.88)
  IN6 w0.099: v2(59.97,17.88) 59.78,17.69 59.78,16.82 58.79,15.84 55.07,15.84 53.95,16.96 53.95,17.33 51.98,19.31 49.86,19.31 47.37,16.82 33.35,16.82 32.92,16.38 29.03,16.38 26.42,13.77 23.7,13.77 20.17,17.3 16.31,17.3 14.05,19.56 14.05,21.49 13.53,22 13.07,22 v2(12.95,21.88) 12.84,22 11.62,22 6.54,16.91 5.46,16.91 5.33,16.78 5.33,16.6 5.47,16.46 v2(5.6,16.46)
  BOTTOM w0.14: UA1.12 6.84,34.91 6.27,34.34 6.27,34.01 5.47,33.21 5.47,32.6 5.31,32.44 5.31,31.26 v2(5.57,31)
I2C0_SCK_TS: length 309.6
  IN1 w0.076: v6(88.93,2.92) 88.93,2.9 89.32,2.5 89.62,2.5 90.12,3 90.52,3 90.91,3.39 90.91,3.43 91.35,3.87 94.97,3.87 95.77,3.08 95.77,2.54 96.06,2.25 101.95,2.25 101.96,2.26 101.98,2.26
  IN1 w0.099: 101.98,2.26 102.36,2.26 103.47,3.37 106.16,3.37 107.18,2.34 110.28,2.34 111.17,3.22 115.33,3.22 116,2.55 116.59,2.55 116.99,2.95 121.36,2.95 121.72,2.59 125.66,2.59 126.42,1.83 146.21,1.83 147.64,3.26 148.88,3.26 149,3.14 177.76,3.14 178.64,4.01 181.67,4.01 182.64,3.05 188.55,3.05 189.18,3.68 191.39,3.68 191.77,3.3 204.28,3.3 206.2,1.38 242.7,1.38 247.02,5.71 249.76,5.71 252.08,3.39 256.16,3.39 256.97,4.2 263.13,4.2 264.18,5.25 266.39,5.25 267.3,4.35 272.8,4.35 273.08,4.07 280.29,4.07 280.98,3.38 288.88,3.38 289.56,4.06 292.39,4.06 292.43,4.1 296.2,4.1 296.91,4.81 298.61,4.81 299,4.42 300.06,4.42 300.64,5 306.31,5 307.01,5.7 308.09,5.7 308.61,5.18 308.84,5.18 v2(308.99,5.34)
  IN3 w0.091: v2(308.99,5.34) 309.14,5.19 309.53,5.19 309.65,5.07 310.3,5.07 310.92,5.69 311.57,5.69 313.44,7.56 313.44,11.59 314.87,13.02 314.87,18.31 316.32,19.76 316.32,23.32 319.16,26.16 323.92,26.16 330.12,32.36 339.77,32.36 340.59,33.18 343.44,33.18 345.1,34.84 345.1,38.25 344.93,38.42 344.93,40.16 345.22,40.46 345.22,44.56 344.86,44.92 342.2,44.92 341.83,44.55 341.83,44.17 v2(341.92,44.07)
  BOTTOM w0.089: UH2.BC22 88.85,6.43 88.84,6.41 88.84,5.59 88.68,5.43 88.68,5.06 88.43,4.81 88.43,4.48 88.32,4.37 88.32,3.85 88.33,3.84 88.33,3.62 88.46,3.49 88.46,3.37 88.9,2.92 v6(88.93,2.92)
  BOTTOM w0.14: RC184.2 341.8,43.66 341.8,43.95 v2(341.92,44.07) 341.92,44.29 341.63,44.58 341.08,44.58 340.87,44.79 RR45.1
I2C0_SCK_TS_R: length 15.2
  BOTTOM w0.14: RR45.2 340.82,45.81 340.82,46.15 v1(340.23,46.74) 340.22,46.75 339.71,46.75 339.03,47.43 339.03,48.5 338.21,49.32 338.21,51.11 338.7,51.6 341.98,51.6 344.55,49.03 344.55,48.93 344.35,48.73 JTS1.3
I2C0_SDA_DSP: length 346.8
  TOP w0.14: JAUDIO.3 v2(4.8,16.46) ; v2(289.42,7.41) 289.42,7.17 289.04,6.78 RE137.2 288.1,6.72 QE18.1
  IN1 w0.076: 72.91,14.27 72.92,14.28 72.92,14.3 73.4,14.77 73.79,14.77 74.64,13.93 76.25,13.93
  IN1 w0.099: v2(289.42,7.41) 289.42,7.37 289.03,6.97 288.44,6.97 286.54,8.88 283.42,8.88 283,9.3 282.65,9.3 282.55,9.4 275.34,9.4 273.4,11.33 272.97,11.33 272.6,10.96 272.6,8.73 272.03,8.15 271.42,8.15 270.89,8.69 268.76,8.69 267.41,10.05 266.3,10.05 264.88,8.63 262.31,8.63 261.71,8.03 257.66,8.03 257.03,7.39 253.6,7.39 253.27,7.73 252.55,7.73 251.26,9.02 240.67,9.02 238.95,7.3 228.6,7.3 227.01,5.72 214.39,5.72 210.75,9.35 206.32,9.35 204.69,7.72 187.27,7.72 186.9,8.1 185.41,8.1 184.9,7.58 183.67,7.58 183.06,8.2 176.27,8.2 175.46,7.39 170.09,7.39 169.98,7.51 169.98,7.52 169.47,8.03 159.32,8.03 158.81,8.54 157.09,8.54 157.07,8.51 155.15,8.51 153.01,10.66 148.91,10.66 148.45,11.11 139.38,11.11 136.77,13.72 130.43,13.72 128.51,15.64 121.97,15.64 121.68,15.92 112.25,15.92 109.92,13.59 107.82,13.59 107.32,13.08 104.9,13.08 104.4,13.59 102.56,13.59 102.31,13.34 100.92,13.34 100.91,13.35 99.3,13.35 98.85,13.8 97.82,13.8 97.5,13.48 95.79,13.48 94.16,15.1 90.59,15.1 90.27,14.78 89.35,14.78 89.16,14.97 88.37,14.97 87.84,14.44 87.53,14.44 87.24,14.15 87.24,13.84 86.98,13.58 86.19,13.58 85.28,12.67 83.99,12.67 83.08,13.59 79.67,13.59 79.22,13.14 77.04,13.14 76.25,13.93 ; v2(59.36,17.91) 59.36,17.69 60.68,16.37 63.68,16.37 66.61,13.44 66.61,12.75 67.4,11.96 68.77,11.96 70.87,14.06 72.7,14.06 72.91,14.27 ; v2(12.96,22.49) 13.09,22.37 13.28,22.37 13.42,22.51 13.42,22.73 13.19,22.96 10.62,22.96 8.95,24.63 6.86,24.63 4.9,26.6 4.9,28.59 4.65,28.84 4.65,30.71 5.5,31.56 v2(5.78,31.56)
  IN6 w0.099: v2(59.36,17.91) 59.42,17.85 59.42,16.97 58.64,16.19 55.22,16.19 54.3,17.1 54.3,17.48 52.12,19.66 49.72,19.66 47.23,17.17 33.2,17.17 32.77,16.74 28.89,16.74 26.27,14.12 23.85,14.12 20.31,17.65 16.45,17.65 14.4,19.7 14.4,21.63 13.68,22.36 13.1,22.36 v2(12.96,22.49) 12.82,22.35 11.48,22.35 6.4,17.27 5.32,17.27 4.97,16.92 4.97,16.58 4.85,16.46 v2(4.8,16.46)
  BOTTOM w0.14: UA1.11 7.23,35.27 7.23,34.74 6.67,34.18 6.67,33.85 v3(6.22,33.4) 5.87,33.05 5.87,32.44 5.7,32.27 5.7,31.64 v2(5.78,31.56)
I2C0_SDA_TS: length 310.2
  IN1 w0.076: 101.98,1.91 101.96,1.91 101.95,1.92 95.92,1.92 95.44,2.4 95.44,2.94 94.84,3.54 93.05,3.54 92.76,3.25 92.76,2.6 92.73,2.57 91.83,2.57 91.73,2.67 90.26,2.67 89.76,2.17 89.19,2.17 88.58,2.78 88.58,3.18 88.06,3.7 v6(87.98,3.7)
  IN1 w0.099: 101.98,1.91 102.51,1.91 103.61,3.01 106.01,3.01 107.04,1.98 110.43,1.98 111.31,2.87 115.18,2.87 115.85,2.2 116.74,2.2 117.13,2.59 121.22,2.59 121.57,2.24 125.51,2.24 126.27,1.47 146.36,1.47 147.79,2.91 148.73,2.91 148.86,2.78 177.91,2.78 178.79,3.66 181.53,3.66 182.52,2.67 204.03,2.67 205.61,1.08 242.9,1.08 247.17,5.35 249.62,5.35 251.93,3.04 256.3,3.04 257.11,3.85 263.28,3.85 264.33,4.9 266.25,4.9 267.15,3.99 272.65,3.99 272.93,3.71 280.14,3.71 280.83,3.02 289.03,3.02 289.71,3.7 292.53,3.7 292.57,3.74 296.34,3.74 297.06,4.46 298.46,4.46 298.85,4.07 300.2,4.07 300.79,4.65 306.45,4.65 307.15,5.35 307.94,5.35 308.46,4.83 308.87,4.83 v2(308.99,4.7)
  IN3 w0.091: v2(308.99,4.7) 309.14,4.84 309.38,4.84 309.5,4.73 310.44,4.73 311.06,5.35 311.71,5.35 313.78,7.41 313.78,11.44 315.22,12.88 315.22,18.16 316.67,19.62 316.67,23.18 319.31,25.82 324.06,25.82 330.26,32.02 339.92,32.02 340.73,32.83 343.58,32.83 345.44,34.7 345.44,38.4 345.27,38.57 345.27,40.02 345.57,40.31 345.57,44.71 345,45.27 342.06,45.27 341.48,44.69 341.48,44.21 v2(341.34,44.07)
  BOTTOM w0.089: UH2.BF23 88.44,5.19 88.2,4.94 88.2,4.57 87.98,4.35 87.98,3.71 87.98,3.7 v6(87.98,3.7)
  BOTTOM w0.14: RR42.1 340.23,44.83 341,44.07 v2(341.34,44.07) 341.4,44.01 341.4,43.41 RC183.2
I2C0_SDA_TS_R: length 16.4
  BOTTOM w0.14: RR42.2 340.23,46.15 340.02,46.36 339.55,46.36 338.64,47.27 338.64,48.33 337.81,49.16 v1(337.81,50.53) 337.81,51.28 338.53,51.99 342.15,51.99 344.95,49.2 344.95,48.93 345.15,48.73 JTS1.2
I2C1_SCK_TP: length 126.1
  TOP w0.14: QE2.3 197.52,12.16 v2(197.29,12.39) ; RH119.2 108.13,5.23 108.13,5.73 v2(108.31,5.91)
  IN2 w0.099: v2(108.31,5.91) 108.12,5.72 108.12,5.32 107.48,4.68 106.23,4.68 104.5,2.95 102.04,2.95 101.58,3.41 100.69,3.41 100.25,2.97 100.25,2.59 99.85,2.19 98,2.19 97.09,3.1 96.26,3.1 95.97,2.81 94.99,2.81 94.75,2.57 92.25,2.57 92.12,2.7 91.69,2.7 91.42,2.98 90.13,2.98 89.6,2.46 88.77,2.46 88.56,2.67 88.56,3.13 v2(88.92,3.49)
  IN3 w0.091: v2(108.31,5.91) 108.14,6.09 108.14,6.21 108.26,6.33 114.83,6.33 116.42,7.92 118.36,7.92 121.9,11.47 125.16,11.47 125.67,11.98 129.36,11.98 130.54,10.8 134.11,10.8 134.68,10.22 138.18,10.22 139.13,9.27 140.27,9.27 141.13,10.13 145.35,10.13 145.48,10.26 146.23,10.26 147,9.49 147.36,9.49 147.53,9.33 149.75,9.33 150.6,8.48 167.21,8.48 168.03,9.3 172.65,9.3 172.76,9.19 178.77,9.19 179.47,8.49 183.72,8.49 184.2,8 188.47,8 191.07,10.61 196.03,10.61 196.59,11.16 196.59,11.56 197.29,12.26 v2(197.29,12.39)
  BOTTOM w0.089: v2(88.92,3.49) 88.89,3.53 88.74,3.53 88.58,3.68 88.58,4.29 88.65,4.36 88.65,4.74 88.89,4.98 88.89,5.34 89.14,5.59 UH2.BE21
I2C1_SCK_TP_C: length 16.5
  TOP w0.14: v2(187.83,12.48) 187.83,12.47 188.01,12.47 188.14,12.6 188.14,13.18 188.72,13.77 188.72,14.43 189.49,15.19 DE5.3 190.68,14.02 194.23,14.02 v5(195.09,14.88) 195.4,15.19 197.14,15.19 197.41,14.91 RE9.1 197.52,14.44 QE2.4
  BOTTOM w0.14: CE79.1 187.76,13.32 187.76,12.54 v2(187.83,12.48) 187.83,12.01 188,11.84 JTP.6
I2C1_SDA_TP: length 126.3
  TOP w0.14: RH120.2 107.74,5.33 107.74,5.76 v2(107.6,5.9) ; v2(195.39,12.38) 195.39,12.83 195.79,13.23 QE2.6
  IN2 w0.099: v2(89.85,3.39) 89.58,3.39 89.29,3.68 89.29,4.05 89.6,4.36 90.53,4.36 90.65,4.48 91.15,4.48 91.74,3.89 92.56,3.89 92.83,3.62 94.69,3.62 95.14,3.17 95.83,3.17 96.11,3.46 97.23,3.46 98.15,2.54 99.7,2.54 99.9,2.74 99.9,3.12 100.55,3.76 101.73,3.76 102.19,3.3 104.35,3.3 106.08,5.03 107.34,5.03 107.77,5.47 107.77,5.73 v2(107.6,5.9)
  IN3 w0.091: v2(107.6,5.9) 107.79,6.09 107.79,6.35 108.11,6.67 108.65,6.67 114.69,6.67 116.28,8.27 118.21,8.27 121.76,11.82 125.02,11.82 125.52,12.32 129.51,12.32 130.68,11.14 134.46,11.14 135.04,10.57 138.32,10.57 139.27,9.62 140.13,9.62 140.99,10.48 145.21,10.48 145.34,10.61 146.37,10.61 147.14,9.83 147.51,9.83 147.67,9.67 149.9,9.67 150.74,8.83 167.06,8.83 167.89,9.65 172.79,9.65 172.91,9.54 178.91,9.54 179.61,8.83 183.86,8.83 184.35,8.35 188.32,8.35 190.93,10.95 195.89,10.95 196.24,11.31 196.24,11.77 196.05,11.96 195.73,11.96 195.42,11.65 195.19,11.65 194.99,11.85 194.99,11.98 v2(195.39,12.38)
  BOTTOM w0.089: v2(89.85,3.39) 89.44,3.39 89.3,3.53 89.3,4.3 89.18,4.42 89.18,4.68 89.12,4.74 UH2.BF21
I2C1_SDA_TP_C: length 17.5
  TOP w0.14: QE2.1 195.96,11.33 195.55,10.91 192.3,10.91 RE7.1 v5(193.23,13.13) 193.23,13.5 193.1,13.63 190.52,13.63 190.32,13.83 189.86,13.83 189.51,13.48 DE5.2 188.77,13.26 188.53,13.02 188.53,12.44 188.18,12.08 188.18,12.07 188.1,12 187.67,12 187.65,12.01 187.65,12.01 187.4,12.26 187.4,12.3 v2(187.24,12.46)
  BOTTOM w0.14: JTP.7 187,11.87 187.24,12.11 v2(187.24,12.46) 187.24,12.47 187.24,13.06 CE80.1
I2C2_IRQ_TS: length 353.2
  TOP w0.14: v2(64.72,19.73) 64.72,19.8 64.26,20.26 v1(63.56,20.26)
  IN3 w0.089: 73.28,12.64 74.4,11.52 75.71,11.52 77.04,10.19 78.9,10.19 79.4,10.69 80.13,10.69 80.32,10.5 85.31,10.5 v2(85.83,11.02)
  IN3 w0.091: 73.28,12.64 69.34,16.57 69.34,18.48 68.09,19.73 v2(64.72,19.73)
  IN5 w0.089: 75.06,20.64 77.01,20.64 77.98,21.61 78.67,21.61 79.35,22.28 79.96,22.28 80.35,21.89 87.35,21.89 89.07,23.61 89.07,24.38 90.41,25.72 95.17,25.72 96.18,24.71 96.86,24.71 97.08,24.49 97.82,24.49 98.6,25.27 101.55,25.27 101.98,24.85
  IN5 w0.099: v2(342.51,44.29) 341.71,45.09 338.53,45.09 336.9,43.46 334.45,43.46 332.86,41.88 332.86,41.19 331.5,39.82 331.5,37.22 328.04,33.77 328.04,27.43 326.9,26.29 315.28,26.29 313.32,28.25 309.82,28.25 309.35,27.78 306.12,27.78 304.13,29.77 297.67,29.77 295.14,27.25 291.02,27.25 290.51,26.74 287.92,26.74 287.6,26.42 286.84,26.42 286.19,25.77 278.58,25.77 277.59,24.78 270.58,24.78 268.5,22.71 263.16,22.71 261.32,24.55 261.32,26.73 253.15,34.89 181.64,34.89 178.12,31.37 177.68,31.37 175.25,28.94 175.25,25.7 176.89,24.06 176.89,21.49 176.1,20.71 175.62,20.71 174.57,19.66 130.56,19.66 130.1,20.13 107.26,20.13 106.06,21.33 105.68,21.33 105.21,21.8 103.72,21.8 102.53,23 102.53,24.3 101.98,24.85 ; 75.06,20.64 74.87,20.64 74.65,20.41 65.91,20.41 65.11,19.61 64.84,19.61 v2(64.72,19.73)
  BOTTOM w0.089: UH2.AP29 85.65,10.84 v2(85.83,11.02)
  BOTTOM w0.14: v2(342.51,44.29) 342.51,44.79 RR41.1 341.95,44.86 RH5891.1
I2C_EN8723: length 3.3
  TOP w0.14: v1(319.37,39.8) 319.93,39.24 RI25.1 320.3,39.12 321.48,37.93 UI3.24
I2CB_SCL: length 16.3
  TOP w0.14: v2(210.01,63.85) 209.6,63.44 209.6,62.82 209.03,62.24 209.03,61.81 208.09,60.87 207.76,60.87 206.58,59.69 v3(205.94,59.69) 205.23,59.69 203.7,58.15 203.7,57.82 201.1,55.23 201.1,53.09 RV570.1
  BOTTOM w0.102: UV18.R7 210.37,63.5 v2(210.01,63.85)
I2CB_SDA: length 15.3
  TOP w0.14: RV571.1 201.49,53.09 201.49,55.06 204.09,57.66 204.09,57.99 v3(204.39,58.29) 205.4,59.3 206.74,59.3 207.92,60.48 208.25,60.48 209.42,61.65 209.42,62.08 210,62.65 210,63.02 v2(210.03,63.06)
  BOTTOM w0.102: v2(210.03,63.06) 210.03,63.06 UV18.R6
I2S_BCLK: length 27
  TOP w0.14: JAUDIO.9 7.2,16.55 7.23,16.52 v2(7.23,16.49)
  IN2 w0.099: v2(7.23,16.49) 7.23,16.52 7.2,16.55 7.2,16.96 8.38,18.15 8.38,24.41 9.97,26 10.57,26 12.08,27.51 12.08,27.64 12.44,28 13.81,28 14.83,29.01 14.83,30.99 14.12,31.7 13.36,31.7 12.73,32.33 12.73,34.06 12.35,34.44 v2(12.35,35.03)
  BOTTOM w0.108: UA1.56 12.39,36.22 12.5,36.12 12.5,35.18 v2(12.35,35.03)
I2S_IN: length 29.7
  TOP w0.14: v2(9.6,16.41) 9.6,16.41 JAUDIO.15
  IN2 w0.099: v2(10.16,34.38) 10.32,34.38 11.75,35.81 12.83,35.81 13.69,34.95 13.69,32.79 13.86,32.62 14.5,32.62 15.78,31.34 15.78,28.35 13.24,25.8 12.82,25.8 11.75,24.74 11.4,24.74 9.83,23.17 9.83,17.75 9.6,17.53 v2(9.6,16.41)
  BOTTOM w0.108: v2(10.16,34.38) 10.1,34.38 9.64,34.84 UA1.5
I2S_LRCK: length 27.8
  TOP w0.14: v2(8.69,16.33) 8.8,16.44 JAUDIO.13
  IN2 w0.099: v2(8.69,16.33) 8.69,17.22 9.48,18.01 9.48,23.28 11.25,25.04 11.62,25.04 12.69,26.11 13.12,26.11 15.44,28.42 15.44,31.26 14.38,32.31 13.74,32.31 13.39,32.66 13.39,34.68 12.6,35.47 12.12,35.47 11.96,35.31 11.95,35.31 v2(11.7,35.05)
  BOTTOM w0.14: v2(8.69,16.33) v1(8.69,16.91) ; v2(11.7,35.05) 11.54,34.9 11.36,34.9 11.24,35.03 UA1.1
I2S_MCLK: length 28.9
  TOP w0.14: JAUDIO.11 8,16.29 8.58,15.71 v2(8.73,15.71)
  IN2 w0.099: v2(8.73,15.71) 8.03,16.41 8.03,17.12 9.14,18.23 9.14,23.37 11.12,25.34 11.5,25.34 12.56,26.41 12.99,26.41 15.13,28.55 15.13,31.12 14.25,32 13.57,32 13.04,32.53 13.04,34.34 v2(12.76,34.61)
  BOTTOM w0.108: UA1.55 12.6,36.63 12.86,36.36 12.86,34.7 v2(12.76,34.61)
I2S_OUT: length 32.8
  TOP w0.14: JAUDIO.17 10.4,16.53 v2(9.61,15.75)
  IN2 w0.099: v2(11.39,36.13) 11.96,36.7 14.5,36.7 15.01,36.19 15.01,32.58 16.28,31.31 16.28,27.64 15.26,26.62 15.26,26.44 14.33,25.51 14.33,25.25 14.03,24.96 12.77,24.96 12.25,24.44 11.53,24.44 10.13,23.03 10.13,16.26 v2(9.61,15.75)
  BOTTOM w0.108: v2(11.39,36.13) 10.8,36.13 10.44,35.77 UA1.3
I2S_RST_AUDIO#: length 145.3
  IN3 w0.089: 75.06,3.39 75.49,3.39 75.52,3.37 76.12,3.37 77.23,4.47 78.65,4.47 79.62,5.44 84.16,5.44 84.31,5.6 85.62,5.6 85.87,5.35 87.73,5.35 87.95,5.13 89.39,5.13 90.01,5.75 91.18,5.75 91.47,5.46 93.84,5.46 94.63,4.67 97.48,4.67 98.12,5.3 98.72,5.3 99.2,5.79 101.53,5.79 101.98,6.24
  IN3 w0.091: 101.98,6.24 102.44,6.7 106.68,6.7 106.93,6.96 v2(106.93,7.15) ; 75.06,3.39 74.65,3.39 73.41,4.64 70.57,4.64 70.3,4.36 68.55,4.36 68.54,4.34 66.87,4.34 66.46,3.94 64.24,3.94 63.52,4.66 63.52,4.98 63.02,5.48 63.02,5.81 65.81,8.61 65.81,9.27 66.93,10.39 66.93,13.24 65.33,14.83 63.24,14.83 v2(63.06,14.65)
  IN6 w0.099: v2(63.06,14.65) 62.14,15.56 62.14,17.31 61.04,18.42 59.29,18.42 58.88,18 58.88,17.26 58.28,16.66 56.34,16.66 56.16,16.84 56.16,18.1 55.47,18.79 53.39,18.79 52.18,19.99 49.73,19.99 47.13,17.39 32.94,17.39 32.54,16.99 28.82,16.99 26.18,14.35 23.94,14.35 20.41,17.88 16.55,17.88 14.63,19.8 14.63,21.97 13.51,23.09 10.74,23.09 8.58,25.26 6.98,25.26 5.13,27.11 5.13,30.1 v2(5.45,30.42)
  BOTTOM w0.14: RP15.5 104.08,6.73 104.9,7.56 106.53,7.56 v2(106.93,7.15) ; CA37.1 RA17.2 4.04,30.25 4.19,30.4 RA93.1 5.44,30.4 v2(5.45,30.42)
I2S_RST_AUDIO#_R: length 6.1
  BOTTOM w0.14: RA93.2 4.57,31.46 v1(3.7,32.34) 3.66,32.37 3.66,33.45 4,33.78 4,34.66 4.52,35.18 4.52,36.04 4.7,36.22 UA1.15
I2S_SDIN0_AUDIO_R: length 7.8
  BOTTOM w0.14: UA1.16 4.72,36.63 4.22,36.12 4.22,35.37 3.73,34.88 3.73,33.89 3.35,33.51 3.35,31.74 3.26,31.66 3.26,31.32 3.44,31.14 v1(3.44,31.07) 3.44,30.99 3.1,30.65 RA6.2
I_ADP: length 273.6
  TOP w0.14: v2(294.54,18.96) 294.94,18.57 UE3.B11 ; v2(47.17,22.02) 47.17,21.65 PR1933.2 ; v1(145.2,11.69) 145.32,11.8 v2(145.32,12.39)
  IN1 w0.076: 101.52,16.08 100.49,16.08 99.93,16.64 98.42,16.64 97.45,17.61 90.75,17.61 90.61,17.47 87.5,17.47 86.61,16.57 86.61,15.38 86.18,14.95 85.67,14.95 85.09,14.38 85.09,13.72 84.98,13.6 84.42,13.6 82.67,15.35 77.08,15.35 76.12,16.3 72.38,16.3 72.31,16.38
  IN1 w0.099: 72.31,16.38 71.6,16.38 68.24,13.03 67.88,13.03 67.67,13.25 67.67,13.97 66.71,14.94 66.71,16.15 65.07,17.79 62.4,17.79 60.14,20.05 58.03,20.05 54.8,23.28 52.04,23.28 50.79,22.03 49.19,22.03 48.79,21.64 47.33,21.64 47.17,21.81 v2(47.17,22.02) ; v2(145.32,12.39) 145.32,12.49 144.37,13.44 140.18,13.44 138.13,15.5 130.9,15.5 128.63,17.76 111.58,17.76 110.14,16.32 107.57,16.32 106.68,15.43 104.27,15.43 103.7,16 103.06,16 102.62,15.56 102.05,15.56 101.52,16.08
  IN5 w0.099: v2(145.32,12.39) 146.29,13.36 163.63,13.36 164.05,12.95 177.69,12.95 181.02,16.28 201.8,16.28 202.16,15.92 214.44,15.92 215.43,14.94 226.19,14.94 226.6,14.54 230.82,14.54 231.52,15.24 246.52,15.24 249.45,12.31 262.38,12.31 262.91,12.83 265.89,12.83 266.46,13.4 267.64,13.4 268.4,12.64 271.62,12.64 273.2,14.23 276.78,14.23 279.02,16.47 285.41,16.47 285.97,15.91 287,15.91 287.32,16.23 289.73,16.23 290.66,17.16 291.15,17.16 292.95,18.96 v2(294.54,18.96)
I_BATT: length 297.4
  TOP w0.14: RE55.2 309.13,7.75 v2(308.83,8.05) 308.78,8.05 v1(308.38,7.65) ; v2(59.66,24.58) 58.89,25.35 54.05,25.35 52.33,23.62 49.68,23.62 48.59,22.53 47.24,22.53 47.19,22.48 46.99,22.48 46.71,22.2 46.71,22.02 PR1932.2
  IN2 w0.089: 74.73,7.49 74.72,7.49 74.44,7.77 73.35,7.77 73.28,7.85 ; 101.93,7.71 101.24,7.71
  IN2 w0.099: v2(59.66,24.58) 62.02,24.58 63.55,23.06 63.55,22.56 65.34,20.77 65.34,18.19 64.97,17.82 64.97,16.06 67.47,13.56 67.47,13.03 69.58,10.92 70.77,10.92 71.57,10.12 71.57,9.07 72.32,8.31 72.82,8.31 73.28,7.85 ; 101.93,7.71 102.15,7.71 102.16,7.7 103.24,7.7 104.49,8.95 105.11,8.95 106.11,9.94 110.11,9.94 111.61,8.44 v2(111.61,8.23) ; 101.24,7.71 99.51,5.98 96.11,5.98 95.93,5.79 94.14,5.79 93.65,6.28 91.6,6.28 91.31,6.57 89.51,6.57 88.8,5.86 88.24,5.86 88.06,6.04 85.73,6.04 85.43,6.35 79.88,6.35 79.78,6.25 79.12,6.25 78.66,5.79 75.76,5.79 75.45,6.1 75.45,6.77 74.73,7.49
  IN5 w0.099: v2(308.83,8.05) 309.3,8.51 309.3,10.67 309.09,10.88 308.66,10.88 308.47,10.7 307.66,10.7 306.53,9.57 305.32,9.57 304.34,8.59 299.23,8.59 298.51,7.87 296.75,7.87 296.55,7.67 294.84,7.67 294.66,7.49 292.04,7.49 291.48,8.05 285.9,8.05 285.38,7.53 281.26,7.53 280.53,8.26 279.78,8.26 278.51,6.99 271.61,6.99 270.52,8.08 268.74,8.08 268.44,7.78 263.22,7.78 262.85,8.15 261.65,9.34 254.9,9.34 254.59,9.03 215,9.03 212.6,11.43 198.93,11.43 198.21,10.72 196.85,10.72 193.68,7.55 181.89,7.55 180.89,6.55 178.98,6.55 178.25,7.28 170.16,7.28 169.88,7 165.88,7 165.41,7.47 160.32,7.47 160.02,7.16 151.41,7.16 151.04,7.53 147.33,7.53 145.45,9.42 141.04,9.42 139.93,8.3 136.81,8.3 136.37,7.86 133.05,7.86 131.54,9.37 119.55,9.37 117.07,6.89 115.52,6.89 114.51,7.9 111.94,7.9 v2(111.61,8.23)
I_BATT_R: length 16.1
  TOP w0.14: v2(309.81,8.38) 310.39,7.8 RE55.1 ; RE55.1 C3320.1 ; RE55.1 v1(311.39,7.75) ; v2(300.96,12.57) UE3.J4
  IN5 w0.099: v2(308.56,11.7) 308.9,11.7 309.81,10.79 v2(309.81,8.38)
  IN6 w0.076: 303.47,12.38 303.22,12.13 302.01,12.13 301.96,12.17 301.35,12.17 v2(300.96,12.57)
  IN6 w0.099: v2(308.56,11.7) 308.56,12.04 308.28,12.32 305.81,12.32 305.28,12.85 303.93,12.85 303.47,12.38
I_SYS_R: length 14.5
  TOP w0.14: v1(312.6,10.35) 312.48,10.35 C3321.1 311.25,11.59 309.96,11.59 RE126.1 309,11.6 309,11.88 308.36,12.52 v2(308.36,12.8) ; v2(300.96,13.37) UE3.J5
  IN6 w0.076: v2(300.96,13.37) 301.35,12.97 303.03,12.97 303.39,13.34 303.47,13.34
  IN6 w0.099: v2(308.36,12.8) 307.82,13.34 303.47,13.34
IA_SW1:
  vias: v1(142.62,110.35) v2(142.57,111.99) v2(142.57,111.35) v2(143.21,111.99) v2(143.21,111.35)
IA_SW2:
  vias: v1(151.52,112.23) v2(149.72,113.72) v2(150.36,113.72) v2(150.99,113.72)
IA_SW3: length 1
  TOP w0.14: v2(159.12,113.15) 159.12,113.51 159.13,113.53 v1(158.71,113.95)
  vias: v2(159.75,113.15) v2(160.39,113.15)
ILIM_HI1: length 6.5
  BOTTOM w0.14: UI2.16 332.12,63.51 333.21,62.42 v1(335.95,62.42) 336.92,62.42 RI12.1
ILIM_HI3: length 3.1
  TOP w0.14: v1(26.55,98.52) RI7.1 28.66,98.52 v2(28.72,98.46)
  BOTTOM w0.14: UI1.16 28.19,98.57 28.29,98.46 v2(28.72,98.46)
ILIM_LO1: length 6.4
  BOTTOM w0.14: RI11.1 v1(333.95,62.93) 333.24,62.93 332.15,64.01 UI2.15
ILIM_LO3: length 3.3
  TOP w0.14: v2(28.7,99.07) 28.49,99.28 RI6.1 27.41,99.28 v1(26.65,100.04)
  BOTTOM w0.14: UI1.15 v2(28.7,99.07)
ILIM_SEL_L: length 447
  TOP w0.14: v2(62.16,22.71) v1(62.16,23.38)
  IN5 w0.089: 101.98,26.62 98.2,26.62 96.64,25.07 96.33,25.07 95.32,26.08 90.26,26.08 88.71,24.53 88.71,23.75 87.21,22.25 80.5,22.25 80.11,22.64 79.14,22.64 78.48,21.98 77.16,21.98 76.02,20.84 75.06,20.84
  IN5 w0.099: 101.98,26.62 103.02,26.62 104.51,25.13 104.51,23.28 107.37,20.43 130.37,20.43 130.89,19.91 173.77,19.91 174.87,21 174.87,21.97 176.33,23.44 176.33,24.33 175.05,25.61 175.05,29.03 177.6,31.57 178.04,31.57 181.83,35.37 253.26,35.37 261.35,27.28 265.36,27.28 268.48,24.16 269.08,24.16 270.12,25.2 277.44,25.2 278.41,26.17 285.79,26.17 286.44,26.82 287.43,26.82 287.75,27.14 290.35,27.14 290.85,27.65 293.94,27.65 294.45,28.16 294.45,28.68 296.6,30.82 303.61,30.82 305.53,32.74 309.03,32.74 309.41,33.12 323.57,33.12 325.88,35.43 325.88,38.61 327.28,40.01 328.8,40.01 329.69,40.9 329.69,43.18 330.71,44.2 330.71,45.21 330.96,45.47 v2(331.42,45.47) ; v2(62.16,22.71) 62.52,22.35 63.12,22.35 63.37,22.61 63.37,23.01 63.76,23.39 65.48,23.39 66.23,22.64 69.61,22.64 70.19,22.06 72.23,22.06 73.23,21.06 73.23,20.92 73.54,20.62 74.14,20.62 74.36,20.84 75.06,20.84
  IN6 w0.089: 20.58,40.14 20.68,40.03 20.68,34.99 20.58,34.88
  IN6 w0.099: v2(62.16,22.71) 62.16,23.07 61.22,24.01 57.42,24.01 57.06,24.38 55.78,24.38 54.84,25.31 49.44,25.31 49.27,25.48 44.7,25.48 43.91,24.69 42.64,24.69 39.66,21.71 33.76,21.71 32.23,23.24 27.92,23.24 24.36,26.8 24.36,27.71 23.72,28.35 19.25,28.35 18.57,29.02 18.57,29.47 17.66,30.38 17.66,31.71 18.89,32.94 18.89,33.37 20.15,34.63 20.32,34.63 20.58,34.88 ; 20.58,40.14 20.22,40.49 20.22,42.01 18.57,43.67 18.57,51.55 17.13,52.99 17.13,53.45 16.11,54.47 16.11,63.04 15.34,63.81 15.34,67.88 14.1,69.12 12.98,69.12 11.8,70.3 11.8,75.03 13.7,76.93 13.7,78.87 21.45,86.62 21.45,92.8 24.26,95.61 24.26,97.23 v2(24.51,97.49)
  BOTTOM w0.14: RI31.2 330.58,45.01 331.04,45.47 v2(331.42,45.47) 331.24,45.64 RI33.1 329.06,44.78 RI34.2 329.13,43.94 DI12.3 ; UI1.4 25.54,97.61 25.41,97.49 v2(24.51,97.49)
ILIM_SEL_R: length 27
  TOP w0.14: v2(328.41,62.98) v1(327.76,62.98)
  IN6 w0.099: v2(325.98,44.37) 327.73,46.12 327.73,51.44 328.18,51.89 328.18,62.74 v2(328.41,62.98)
  BOTTOM w0.14: UI2.4 329.07,62.44 328.96,62.33 328.59,62.33 328.41,62.51 v2(328.41,62.98) ; v2(325.98,44.37) 325.79,44.18 RI30.2 RI35.2 328.14,43.64 DI12.2 328.22,43.69 RI34.1 328.17,44.76 RI32.1
ILMT_0.95V: length 4.9
  BOTTOM w0.254: PU800.13 107.94,63.66 107.47,64.14 105.54,64.14 104.98,64.69 PR808.1 PR807.2
ILMT_1.8VSP: length 2.1
  BOTTOM w0.254: PR1607.1 PR1606.2 248.5,104.75 PU1600.13
ILMT_1V: length 4.1
  TOP w0.14: PR506.2 v1(134.35,5)
  TOP w0.254: PR508.1 134.37,4.4 v2(133.96,4.4) 133.66,4.4 133.35,4.71 PR506.2
  BOTTOM w0.14: v2(133.96,4.4) 133.54,4.81 PU500.13
ILMT_1VSP: length 2.4
  BOTTOM w0.203: PR910.1 242.06,112.27 241.56,112.78 PU900.13
  BOTTOM w0.508: PR909.2 PR910.1
IMVP_VR_ON: length 261.7
  TOP w0.14: v2(171.6,4.71) 171.6,5.24 172.11,5.75 172.11,6.2 172.72,6.81 172.72,7.24 172.09,7.88 170.43,7.88 169.88,8.43 169.88,9.17 170.26,9.55 170.26,15.29 168,17.55 v2(168,18.37) ; v2(107.52,40.51) 104.27,43.76 104.27,50.54 v1(104.65,50.92) 105.15,51.42 109.54,51.42 110.25,50.71 UZ21.1 ; UE3.N7 304.15,15.37 v2(304.57,14.96)
  IN1 w0.099: v2(107.52,40.51) 108.2,41.19 109.42,41.19 110.28,40.34 118.72,40.34 120.81,38.25 120.83,38.25 121.16,37.92 v2(121.16,37.72)
  IN2 w0.099: v2(168,18.37) 168,18.45 167.54,18.91 157.6,18.91 156.39,20.12 149.07,20.12 147.09,22.1 147.09,25.35 146.77,25.67 145.48,25.67 143.95,27.2 143.95,29.31 137.05,36.21 122.67,36.21 v2(121.16,37.72)
  IN3 w0.091: v2(305,8.36) 305,9.73 304.01,10.72 304.01,14.1 304.57,14.65 v2(304.57,14.96)
  IN6 w0.099: v2(171.6,4.71) 172.12,5.23 176.88,5.23 179.45,7.8 182.72,7.8 184.37,6.15 201.48,6.15 203.61,8.29 210.03,8.29 214.5,3.81 243.14,3.81 245.58,6.24 253.1,6.24 253.85,5.49 262.21,5.49 263.44,6.71 268.28,6.71 268.87,6.12 270.36,6.12 271.02,5.46 274.31,5.46 275.02,4.74 280.17,4.74 280.82,4.09 284.88,4.09 285.37,4.57 288.6,4.57 288.66,4.52 298.56,4.52 298.89,4.18 299.91,4.18 301.08,5.36 301.8,5.36 301.98,5.54 301.98,6.74 302.38,7.14 303.79,7.14 v2(305,8.36)
IMVP_VR_PG: length 197
  TOP w0.14: v2(105.64,48.84) 105.37,48.84 104.88,48.35 v1(104.88,45.34) 104.88,43.76 107.94,40.69 107.94,40.19 105.8,38.04 105.8,32.96 103.83,31 85.81,31 83.91,32.9 v2(83.91,33.17)
  TOP w0.254: PR1119.1 v2(112.97,113.22)
  IN2 w0.099: v2(59.42,22.81) 59.42,21.55 59.03,21.16 59.03,20.83 59.41,20.45 59.78,20.45 61.93,18.29 61.93,16.55 62.02,16.46 62.02,14.23 62.52,13.73 62.52,13.49 62.14,13.11 61.6,13.11 61.39,12.9 61.39,12.54 62.03,11.9 62.03,11.07 63.31,9.79 63.31,7.93 62.68,7.3 v2(62.68,6.49)
  IN4 w0.091: v2(59.42,22.81) 59.89,22.34 60.92,22.34 61.3,22.72 61.3,23.13 63.88,25.71 63.88,27.56 65.87,29.55 71.97,29.55 77.82,35.4 82.52,35.4 83.91,34.01 v2(83.91,33.17) ; v2(105.64,48.84) 105.76,48.96 112.61,48.96 113.39,49.75 116.06,49.75 117.07,50.76 117.07,63.65 121.4,67.98 121.4,69.82 123.69,72.1 123.69,84.82 121.72,86.79 121.72,91.52 121.23,92 115.72,92 115.14,92.58 115.14,97.51 116.05,98.43 116.05,100.15 116.82,100.92 119.58,100.92 120.04,101.37 120.04,104.01 120.53,104.5 120.53,106.94 121.06,107.47 121.46,107.47 122.38,108.38 122.38,109.39 120.16,111.61 114.35,111.61 112.97,112.99 v2(112.97,113.22)
  BOTTOM w0.14: v2(62.68,6.49) 62.68,6.04 62.05,5.41 61.44,5.41 61.05,5.02 61.05,4.83 60.58,4.36 60.58,3.75 60.27,3.44 UH14.1
INTRUDER#: length 5.5
  TOP w0.089: v2(78.26,8.44) 78.26,8.08 77.95,7.77 76.89,7.77 RH531.1 76.06,8.6 75.25,8.6 v1(75.15,8.5)
  BOTTOM w0.089: v2(78.26,8.44) 78.19,8.38 78.19,8.19 78.44,7.95 78.44,7.56 78.16,7.28 UH2.BB44
INV_PWM: length 18
  IN1 w0.254: v2(46.38,30.79) 46.38,31.01 50.15,34.79 52.8,34.79 53,34.58 54.85,34.58 v2(55.18,34.25)
  BOTTOM w0.254: v2(55.18,34.25) 55.18,34.61 55.73,35.16 JEDP1.25 ; DV2.1 45.47,28.63 RV109.1 44.88,29.74 v1(45.64,30.51) 45.92,30.79 v2(46.38,30.79)
IRQ_SERIRQ: length 1.5
  TOP w0.089: v6(82.84,8.74) 83.12,9.02 RH5882.1
  BOTTOM w0.089: UH2.AW35 82.55,8.45 v6(82.84,8.74)
ISEN1_GT: length 16.5
  TOP w0.14: v2(105.98,104.84) v1(105.98,106.95)
  TOP w0.203: PC1125.2 111.63,103.58 112.12,104.06 112.12,104.2 112.69,104.78 v2(112.69,104.79) 112.85,104.79 113.44,105.39 PU1100.9
  IN1 w0.254: v2(112.69,104.79) 113.16,104.79 113.39,105.02 113.39,105.73 113.2,105.92 112.22,105.92 111.82,106.31 109.81,106.31 108.74,105.24 106.38,105.24 v2(105.98,104.84)
  BOTTOM w0.254: PR1303.2 v2(105.98,104.84)
ISEN1_VCORE: length 22.9
  TOP w0.203: PU1100.21 118.07,102.73 118.49,102.31 118.49,101.63 v2(118.47,101.6) 118.49,101.58 PC1124.1
  IN2 w0.254: v2(118.47,101.6) 118.49,101.6 119.06,102.17 119.66,102.17 120.12,101.72 123.62,101.72 v2(124.08,102.17) 126.18,102.17 126.58,101.76 126.81,101.76 127.41,101.16 127.41,100.39 127.17,100.15 126.51,100.15 v2(126.34,99.99)
  BOTTOM w0.254: PR1201.2 126.9,100.27 126.8,100.17 126.52,100.17 v2(126.34,99.99) ; PR1216.2 124.61,97.41 123.83,97.41 123.08,98.15 v1(123.08,101.18) v2(124.08,102.17) PR1214.2
