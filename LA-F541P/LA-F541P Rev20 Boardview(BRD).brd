# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VCCGT on TOP: outline of 117 points within 116.47,68.14 153.44,89.5 ; 3 cut-outs
+VCCGT on BOTTOM: outline of 243 points within 115.6,67.83 152.96,92.87
+VCCGT on IN1: 138.25,78.39 138.25,86.29 139.13,87.17 139.13,88.5 139.39,88.76 152.27,88.76 152.71,88.32 152.71,85.52 152.73,85.5 152.73,81.77 153.34,81.16 153.34,69.45 152.4,68.52 151.98,68.68 151.79,68.27 151.77,68.18 151.69,68.14 150.69,68.14 150.6,68.18 150.59,68.27 150.27,68.7 149.96,68.27 149.95,68.18 149.86,68.14 139.33,68.14 138.6,68.87 138.03,68.87 138.01,68.86 134.34,68.86 133.91,69.29 133.91,74.04
+VCCGT on IN2: outline of 133 points within 116.51,68.13 153.33,89.54
+VCCGT on IN4: 153.19,68.75 149.75,68.75 149.05,68.75 148.48,68.19 145.55,68.19 145.28,68.46 134.46,68.46 134.13,68.78 134.13,70.83 134.66,71.36 137.19,71.36 137.19,72.29 137.93,73.03 143.1,73.03 143.1,79.71 143.28,80.01 143.1,80.3 143.1,80.39 142.49,80.99 142.49,81.54 142.54,81.63 142.64,81.63 142.98,81.65 143.13,81.96 142.93,82.29 142.56,82.21 142.51,82.25 142.49,82.31 142.49,84.5 142.34,84.66 142.33,84.67 142.14,84.89 141.84,84.87 141.82,84.85 141.42,84.85 141.23,84.92 141.03,84.85 140.78,84.85 140.69,84.9 140.69,85 140.4,85.48 140.11,85 140.1,84.9 140.02,84.85 138.79,84.85 138.66,84.99 138.66,88.75 139.11,89.21 151.28,89.21 153.34,87.14 153.34,68.9
+VCCGT on IN4: 123.81,84.21 123.81,72.07 122.38,70.64 121.26,70.64 120.59,69.97 117.48,69.97 116.89,70.56 116.89,71.22 115.9,72.21 115.9,81.97 116.26,82.32 117.76,82.32 118.03,82.6 118.03,83.26 117.12,84.18 117.12,84.66 117.48,85.01 123.01,85.01
+VCCGT on VCC: 134.32,53.6 131.32,56.6 131.32,62.57 129.24,64.64 121.16,64.64 118.68,64.62 117.39,64.63 117.08,64.95 117.07,70.5 117.07,72.68 116.33,73.48 116.33,81.83 116.8,82.3 118.45,82.3 120.02,83.86 120.02,98.09 125.18,103.25 131.91,103.25 132.29,103.63 133.12,103.63 143.79,92.96 143.79,90.8 145.93,88.66 148.54,88.66 149.71,87.49 151.05,87.49 153.04,85.51 153.04,80.24 151.89,79.1 151.89,69.24 153.67,67.46 153.67,54.21 153.06,53.6
+VCCGT on IN5: 116.98,70.33 116.56,70.75 116.56,82.22 117.74,83.4 117.74,84.53 117.95,84.74 121.3,84.74 122.67,86.11 130.53,86.11 130.81,85.97 131.09,86.11 131.74,86.11 131.82,86.07 131.84,85.98 132.18,85.52 132.52,85.98 132.54,86.07 132.62,86.11 137.08,86.11 139.5,88.52 152.76,88.52 153.35,87.93 153.4,87.93 153.42,87.91 153.42,76.85 152.78,76.21 152.78,74.22 149.84,74.22 149.83,74.23 141.34,74.23 141.33,74.25 141.25,74.4 141.11,74.48 140.92,74.49 140.76,74.38 140.68,74.35 140.61,74.38 140.29,74.49 140.04,74.27 140.03,74.23 136.96,74.23 136.87,74.28 136.87,74.39 136.89,74.42 136.9,74.45 136.88,74.72 136.67,74.88 136.66,74.88 136.5,74.88 136.36,74.8 136.29,74.77 136.22,74.8 135.99,74.88 135.76,74.77 135.69,74.74 135.62,74.77 135.38,74.87 135.08,74.74 134.78,74.87 134.54,74.77 134.47,74.75 134.4,74.78 134.14,74.89 133.89,74.79 133.82,74.76 133.75,74.78 133.5,74.88 133.26,74.78 133.19,74.76 133.12,74.79 132.66,74.83 132.55,74.38 132.54,74.28 132.45,74.23 128.84,74.23 124.94,70.33
+VCCIO on TOP: 171.21,71.52 171.34,71.39 173.35,71.39 173.55,71.19 173.55,70.32 173.66,70.21 174.05,70.21 174.24,70.4 174.24,73.82 174.24,73.83 174.24,74.47 174.01,74.69 173.08,74.69 172.53,74.13 172.2,74.13 172.08,74.01 172.08,73.22 171.21,72.34
+VCCIO on BOTTOM: 172.44,79.58 172.45,79.59 172.59,79.66 172.68,79.78 173.63,79.78 173.69,79.73 173.69,79.02 173.69,79.02 173.69,78.54 173.66,78.51 172.61,78.51 171.96,77.86 171.96,77.86 171.96,75.96 172.71,75.21 173.75,75.21 173.76,75.21 173.98,75.21 174.02,75.17 174.05,75.09 174.01,75.01 173.92,74.69 174.2,74.51 174.18,74.38 174.21,74.25 173.98,74.16 173.94,73.91 173.99,73.83 174.07,73.77 174.08,73.77 174.34,73.5 174.34,72.83 174.18,72.67 173.65,72.67 173.44,72.72 173.26,72.62 173.05,72.62 172.86,72.72 172.66,72.67 172.59,72.65 172.53,72.67 171.98,72.43 172.53,72.18 172.59,72.21 172.66,72.19 172.86,72.14 173.05,72.24 173.26,72.24 173.4,72.15 173.56,72.15 173.57,72.15 173.82,72.15 173.82,72.15 174.07,72.15 174.37,71.85 174.37,71.52 174.32,71.47 174.32,69.91 174.29,69.88 172.15,69.88 171.5,70.53 171.5,79.59 171.63,79.72 172.11,79.72 172.24,79.62 172.4,79.59
+VCCIO on BOTTOM: 120.57,63.25 119.41,63.25 119.19,63.02 119.11,62.91 119.08,62.78 119.07,62.76 118.75,62.43 117.65,62.43 117.6,62.49 117.6,62.94 117.63,62.97 118.09,62.97 118.14,63.02 118.14,63.7 118.11,63.73 117.6,63.73 117.58,63.76 117.58,64.14 117.6,64.16 118.11,64.16 118.14,64.19 118.14,64.9 118.11,64.92 117.6,64.92 117.58,64.95 117.58,66.37 117.45,66.49 117.45,67.84 117.69,68.07 119.03,68.07 119.33,67.77 119.33,66.73 119.51,66.55 120.56,66.55 120.71,66.39 120.71,63.39
+VCCIO on IN1: 176.45,85.98 176.33,85.85 174.73,85.85 173.2,84.33 173.2,82.63 173.19,82.61 173.19,82.28 172.78,81.88 172.78,81.17 174.14,79.81 174.14,70.99 173.97,70.82 172.54,70.82 172.29,71.07 172.29,72.52 170.56,74.25 170.56,84.28 170.82,84.53 170.82,85.8 171.95,86.93 173.52,86.93 174.76,88.17 176.2,88.17 176.45,87.92
+VCCIO on IN3: 171.58,70.13 171.44,70.27 171.44,79.39 171.62,79.56 172.49,79.56 173.15,78.91 173.15,78.12 173.57,77.71 173.55,77.67 173.68,77.27 174.11,77.33 174.18,77.36 174.26,77.33 174.3,77.29 174.3,77.02 174.27,77 174.25,76.96 174.17,76.93 174.09,76.96 173.51,76.73 174.1,76.54 174.18,76.58 174.26,76.54 174.3,76.5 174.3,76.23 174.28,76.21 174.25,76.19 174.18,76.15 174.1,76.19 173.52,75.97 174.11,75.75 174.18,75.79 174.26,75.75 174.3,75.71 174.3,75.45 174.17,75.19 174.3,74.92 174.3,74.65 174.18,74.4 174.3,74.14 174.3,73.87 174.17,73.61 174.3,73.35 174.3,73.08 174.18,72.82 174.3,72.57 174.3,72.3 174.17,72.04 174.3,71.77 174.3,71.47 174.18,71.21 174.3,70.95 174.3,70.72 174.18,70.54 174.2,70.33 174.22,70.29 174.06,70.13
+VCCIO on IN4: 171.8,79.38 171.96,79.54 172.9,79.54 173.45,78.99 173.45,75.31 174.12,74.63 174.12,70.28 174.08,70.23 172.46,70.23 171.8,70.9
+VCCIO on IN5: outline of 378 points within 116.9,63.82 174.55,74.64
+VCCSA on TOP (solid shape): 119.36,90.86 119.36,88.11 119.08,87.83 114.73,87.83 114.56,88.01 114.56,90.96 114.71,91.11 119.1,91.11
+VCCSA on BOTTOM (solid shape): 119.9,91.01 119.9,87.83 119.71,87.64 119.07,87.64 119.06,87.63 117.6,87.63 117.6,87.64 114.67,87.64 114.3,87.27 111.86,87.27 111.66,87.47 111.66,88.89 112.56,88.89 112.56,89.65 111.66,89.65 111.66,91.08 111.83,91.25 114.87,91.25 115.35,91.73 119.18,91.73
+VCCSA on BOTTOM (solid shape): outline of 372 points within 165.57,80.07 176.33,93.3
+VCCSA on TOP: 170.94,73.29 170.94,74.27 170.7,74.52 170.7,79.18 170.6,79.27 170.6,80.77 169.86,81.51 169.86,83.52 170.45,84.1 170.45,86.34 170.54,86.43 170.54,86.43 170.6,86.49 170.61,86.49 170.65,86.53 170.65,87.62 170.34,87.93 170.34,88.73 169.92,89.16 168.91,89.16 165.48,92.58 165.48,93.22 165.68,93.42 176.72,93.42 178.42,91.71 178.42,86.93 178.47,86.89 178.47,86.73 178.55,86.64 178.55,86.42 178.55,86.41 178.55,85.88 178.55,85.88 178.55,85.5 178.2,85.15 178.2,84.6 177.87,84.27 176.31,84.27 175.79,84.27 175.76,84.24 173.5,84.24 173.49,84.24 173.21,84 173.32,83.65 173.34,83.6 173.32,83.54 173.2,83.36 173.21,83.15 173.22,83.12 173.06,82.95 172.82,82.95 172.81,82.96 172.51,82.92 172.37,82.64 172.37,82.62 172.01,82.27 172.01,78.56 172.51,78.07 172.51,76.56 172.5,76.56 172.5,75.29 172.57,75.23 172.57,74.29 172.54,74.27 172.14,74.27 171.98,74.1 171.98,73.23 171.95,73.21 171.02,73.21
+VCCSA on IN5: outline of 100 points within 116.01,74.36 179.31,102.25
+VCCST on TOP (solid shape): 181.93,82.51 181.93,82.07 181.93,82.06 181.9,81.94 181.93,81.82 181.93,81.81 181.93,81.73 182.06,81.6 182.16,81.6 182.21,81.59 182.26,81.58 182.31,81.54 182.31,80.58 182.44,80.46 182.44,79.88 182.17,79.62 181.43,79.62 181.34,79.53 181.27,79.48 181.21,79.4 180.69,78.88 180.33,78.88 180.15,79.06 180.15,79.25 180.79,79.88 180.79,81.6 180.1,82.28 180.1,82.72 180.22,82.83 181.61,82.83
+VCCST on TOP: 172.79,76.65 172.67,76.77 172.67,78.63 172.71,78.67 172.71,79.21 172.06,79.86 172.06,81.34 172.33,81.61 173.31,81.61 173.52,81.81 174.02,81.81 174.15,81.81 174.29,81.67 174.29,81.52 173.78,81.01 173.74,80.99 173.71,80.98 173.36,80.98 172.79,80.83 173.24,80.45 173.33,80.44 173.38,80.35 173.38,78.79 173.49,78.68 173.49,76.71 173.43,76.65
+VCCST on IN2: 177.55,76.35 176.94,76.96 176.94,77.52 176.74,77.72 176.71,77.76 176.68,77.79 175.99,77.79 175.77,77.88 175.54,77.79 175.38,77.79 175.16,77.88 174.93,77.79 174.73,77.79 174.51,77.88 174.28,77.79 174.09,77.79 173.98,77.86 173.85,77.88 173.83,77.88 173.71,78 171.71,78 171.45,78.26 171.45,81.36 172.1,82 174.37,82 174.38,82 174.54,81.96 174.69,82 174.7,82 174.98,82 175.17,81.94 175.37,82 175.63,82 175.82,81.94 176.02,82 176.24,82 176.44,81.94 176.65,82 176.87,82 177.09,81.93 177.3,82 178.5,82 178.68,81.95 178.86,82 179.32,82 182.01,79.31 182.01,77.17 181.2,76.35
+VCCSTG on BOTTOM (solid shape): 186.52,84.41 186.52,83.8 185.64,82.92 185.57,82.92 183.55,80.9 181.26,80.9 180.82,81.34 180.82,82.92 180.91,83 181.49,83 181.71,82.79 182.64,82.79 183.32,82.11 183.91,82.11 183.91,82.11 183.96,82.11 184.75,82.9 184.75,82.95 184.75,84.4 184.93,84.58 186.34,84.58
+VCCSTG on IN3: 173.18,82.18 173.16,82.2 173.16,82.85 173.26,82.95 173.46,82.95 173.51,82.95 173.68,82.95 173.84,83.1 173.84,83.1 174.02,83.28 174.03,83.28 174.07,83.33 174.24,83.33 174.4,83.48 174.53,83.48 174.79,83.74 174.79,83.87 175.09,84.17 175.26,84.17 175.53,84.44 178.32,84.44 178.71,84.11 178.89,84.11 179,84.14 179.1,84.2 180,84.2 181.28,82.92 183,82.92 183.25,82.67 183.25,81.12 182.56,80.43 174.9,80.43 173.18,82.15
AGND on BOTTOM (solid shape): 15.52,43.03 15.52,42.17 15.4,42.05 13.77,42.05 13.61,41.89 13.23,41.89 13.21,41.9 13.21,42.3 13.34,42.42 13.65,42.42 14.01,42.77 14.17,42.77 14.4,43 14.4,43.37 14.42,43.37 14.67,43.63 14.92,43.63
AGND on GND1, GND2, VCC, GND3: 2.16,32.39 2.12,32.43 2.12,48.47 11.9,48.47 12.6,49.07 12.1,49.84 12.1,54.9 12.6,55.67 11.9,56.27 9.3,56.27 9.3,56.67 8.4,57.57 7.5,56.67 7.5,56.27 1.9,56.27 1.34,56.51 1.1,57.07 1.1,59.05 4.47,59.05 4.49,59.06 4.87,59.44 6.74,59.44 6.8,59.44 6.91,59.55 10.85,59.55 10.87,59.56 13.04,59.56 13.29,59.31 13.74,59.31 15.11,57.93 15.11,50.19 15.5,49.81 15.5,45.83 14.86,45.19 14.86,41.19 14.69,41.02 13.55,41.02 13.23,40.7 11.54,40.7 11.03,41.22 10.72,41.22 6.12,41.24 5.78,40.9 5.78,38.59 5.48,38.29 3.9,38.29 3.24,37.63 3.24,32.6 3.06,32.39
DV12S on BOTTOM (solid shape): 333.66,39.12 333.86,39.02 334.08,39.01 334.11,39.01 334.14,39 336.37,39 336.61,38.77 337.05,38.77 337.49,38.33 338.33,38.33 338.39,38.27 338.39,38.1 338.34,38.05 337.1,38.05 336.84,38.3 336.37,38.3 336.14,38.53 335.54,38.53 335.36,38.36 333.63,38.36 333.44,38.16 332.08,38.16 331.99,38.25 331.99,39.02 332.09,39.12
DV12S on BOTTOM: 337.5,36.68 336.74,35.93 336.74,35.73 336.87,35.6 337.1,35.6 337.35,35.85 337.35,36.28 337.55,36.49 338.33,36.49 338.38,36.54 338.38,36.65 338.35,36.68
DV33_18 on BOTTOM (solid shape): 338.29,41.6 338.41,41.6 339.12,40.9 339.12,39.24 339.05,39.18 338.89,39.18 338.82,39.24 338.82,40.08 338.14,40.77 337.33,40.77 337.24,40.86 337.24,41.56 337.29,41.61 338.29,41.61
GND on TOP (solid shape): 17.92,112.01 10.92,112.01 10.92,112.81 17.92,112.81
GND on TOP (solid shape): 17.92,94.69 10.92,94.69 10.92,95.49 17.92,95.49
GND on TOP (solid shape): 22.3,100.25 21.5,100.25 21.5,107.25 22.3,107.25
GND on TOP (solid shape): 330.45,69.94 329.65,69.94 329.65,76.94 330.45,76.94
GND on TOP (solid shape): 341.03,81.7 334.03,81.7 334.03,82.5 341.03,82.5
GND on TOP (solid shape): 341.03,64.38 334.03,64.38 334.03,65.18 341.03,65.18
GND on TOP (solid shape): 22.3,109.31 21.5,109.31 21.5,112.01 18.8,112.01 18.8,112.81 22.3,112.81
GND on TOP (solid shape): 22.3,94.69 18.8,94.69 18.8,95.49 21.5,95.49 21.5,98.19 22.3,98.19
GND on TOP (solid shape): 330.45,65.18 333.15,65.18 333.15,64.38 329.65,64.38 329.65,67.88 330.45,67.88
GND on TOP (solid shape): 118.34,87.2 118.34,85.35 118.09,85.09 114.56,85.09 114.43,85.22 114.43,87.12 114.68,87.38 118.16,87.38
GND on TOP (solid shape): 150.88,100.33 150.88,98.55 150.62,98.3 147.38,98.3 146.69,99 146.69,101.98 146.81,102.11 149.1,102.11
GND on TOP (solid shape): 213.17,72.78 213.17,71.5 213.11,71.44 212.61,71.44 211.96,72.08 211.96,72.6 212.15,72.79 213.17,72.79
GND on TOP (solid shape): 226.73,118.66 226.73,115.72 226.61,115.6 225.67,115.6 225.5,115.77 225.5,118.63 225.73,118.85 226.54,118.85
GND on TOP (solid shape): 36.87,29.62 36.87,28.39 36.77,28.3 32.31,28.3 32.17,28.45 32.17,29.64 32.34,29.82 36.67,29.82
GND on TOP (solid shape): 187.96,104.2 187.96,99.06 187.77,98.87 184.47,98.87 184.41,98.93 184.41,100.27 185.29,101.16 185.29,104.59 185.48,104.78 187.39,104.78
GND on TOP (solid shape): 333.15,81.7 330.45,81.7 330.45,81.45 330.3,81.31 330.3,80.08 330.45,79.93 330.45,79 329.65,79 329.65,82.5 333.15,82.5
GND on TOP (solid shape): 108.26,62.08 108.26,61.57 108.1,61.42 105.87,61.42 105.66,61.21 105.66,61.22 105.51,61.22 105.38,61.35 105.38,62 105.63,62.26 108.08,62.26
GND on TOP (solid shape): 191.14,7.49 193.04,7.49 193.17,7.37 193.17,6.61 193.04,6.48 190.25,6.48 190.12,6.61 190.12,7.75 190.25,7.88 190.76,7.88
GND on TOP (solid shape): 33.56,5.86 33.56,5.42 33.4,5.26 31.85,5.26 31.45,4.86 30.03,4.86 29.87,5.02 29.86,5.02 29.86,5.3 30.63,6.07 33.36,6.07
GND on TOP (solid shape): 51.94,31.37 51.94,31.12 51.82,30.99 51.56,30.99 51.31,30.74 51.31,28.07 51.06,27.81 50.42,27.81 50.29,27.94 50.29,30.86 50.93,31.5 51.82,31.5
GND on TOP (solid shape): 248.35,30.1 248.35,29.27 248.22,29.15 247.91,29.15 247.65,29.4 245.87,29.4 245.81,29.47 245.81,30.04 245.87,30.1 247.84,30.1 247.97,30.23 248.22,30.23
GND on TOP (solid shape): 20.99,111.42 20.99,109.89 20.96,109.86 19.64,109.86 19.51,109.98 19.51,110.24 19.37,110.38 18.67,110.38 18.47,110.58 18.47,111.3 18.6,111.44 20.98,111.44
GND on TOP (solid shape): 110.9,59.41 110.9,56.82 110.43,56.36 109.26,56.36 109.16,56.47 109.16,57.8 109.73,58.37 109.73,59.26 109.74,59.27 109.74,59.48 109.83,59.56 110.75,59.56
GND on TOP (solid shape): 229.55,120.33 231.19,120.33 231.51,120.02 231.51,118.85 231.5,118.85 231.12,118.47 227.17,118.47 227.03,118.61 227.03,119.79 227.74,120.5 229.38,120.5
GND on TOP (solid shape): 201.8,105.28 201.8,103.15 201.58,102.92 201.09,102.92 200.8,102.63 199.07,102.63 198.92,102.78 198.92,104.18 198.96,104.22 198.86,104.32 198.86,105.49 198.98,105.61 201.47,105.61
GND on TOP (solid shape): 233.36,10.73 233.36,9.53 233.49,9.4 234.25,9.4 234.7,8.95 237.43,8.95 237.49,8.89 237.49,7.94 237.43,7.88 232.92,7.88 232.35,8.45 232.35,10.73 232.47,10.86 233.24,10.86
GND on TOP (solid shape): 124.59,70.11 124.59,69.47 124.46,69.34 122.3,69.34 122.18,69.22 122.18,68.96 121.16,67.95 121.16,67.44 121.03,67.31 120.02,67.31 119.1,68.23 119.1,69.98 119.35,70.23 124.46,70.23
GND on TOP (solid shape): 326.37,11.56 326.37,6.68 326.04,6.35 319.58,6.35 317.91,8.03 317.91,8.92 318.14,9.15 321.54,9.15 321.99,9.6 321.99,11.37 322.34,11.71 326.21,11.71
GND on TOP (solid shape): 6.93,69.27 8.97,69.27 9.08,69.16 9.08,68.95 8.95,68.82 7.16,68.82 7.09,68.76 6.36,68.76 6.25,68.87 6.22,68.94 6.18,68.99 6.18,69.29 6.38,69.49 6.71,69.49
GND on TOP (solid shape): 7.55,23.31 7.55,20.67 7.48,20.6 7.48,19.43 6.67,18.62 2.77,18.62 1.83,19.56 1.83,22.77 3.02,23.96 6.9,23.96
GND on TOP (solid shape): 52.44,12.51 55.35,12.51 55.51,12.35 55.51,10.7 55.3,10.49 51.41,10.49 51.4,10.5 50.83,10.5 50.72,10.61 50.72,13.18 50.83,13.29 51.66,13.29
GND on TOP (solid shape): 31.45,43.59 31.45,43.1 31.52,43.03 31.85,43.03 31.93,42.95 31.93,42.01 31.78,41.86 30.53,41.86 30.46,41.94 30.46,42.37 30.56,42.47 30.81,42.47 30.99,42.65 30.99,43.59 31.04,43.64 31.4,43.64
GND on TOP (solid shape): 179.79,82.65 179.79,82.28 180.53,81.54 180.53,79.95 180.4,79.82 179.9,79.82 179.71,80.01 179.71,81.21 179.54,81.37 178.74,81.37 178.44,81.67 178.44,82.38 178.58,82.52 178.96,82.52 178.98,82.54 179.35,82.54 179.55,82.74 179.71,82.74
GND on TOP (solid shape): 329.5,24.08 329.5,21.76 329.18,21.44 326.13,21.44 325.96,21.27 321.61,21.27 321.48,21.4 321.48,22.07 321.88,22.48 323.39,22.48 324.26,23.34 324.99,23.34 326.01,24.36 329.23,24.36
GND on TOP (solid shape): 277.3,30.14 277.3,27.97 276.98,27.65 273.66,27.65 273.37,27.94 273.37,30.06 273.48,30.18 274.35,30.18 274.5,30.02 274.5,29.54 274.58,29.47 275.4,29.47 275.53,29.59 275.53,30.23 275.72,30.42 277.02,30.42
GND on TOP (solid shape): 212.28,114.68 215.77,114.68 216.16,114.3 216.16,112.65 215.9,112.4 215.16,112.4 214.7,111.94 212.29,111.94 211.96,112.27 211.96,113.92 211.84,114.05 204.34,114.05 204.22,114.17 204.22,115.07 204.35,115.2 206.48,115.2 206.79,115.52 211.45,115.52
GND on TOP (solid shape): 340.74,100.76 340.74,97.21 340.56,97.03 338.45,97.03 338.44,97.03 338.42,97.01 336.78,97.01 336.66,97.13 336.66,98.94 336.77,99.06 336.77,99.11 336.76,99.11 336.76,99.77 336.94,99.94 336.94,100.4 336.97,100.44 337.39,100.44 337.75,100.08 338.84,100.08 339.19,100.43 339.19,100.89 339.22,100.92 340.59,100.92
GND on TOP (solid shape): 7.53,41.14 7.62,41.12 7.72,41.14 7.73,41.14 10.81,41.14 11.31,40.64 11.31,39.11 11.56,38.86 12.25,38.86 12.28,38.83 12.28,38.41 12.04,38.17 12.04,37.53 11.69,37.17 11.44,37.17 10.78,36.51 6.47,36.51 6.44,36.54 5.87,36.54 5.74,36.67 5.74,37.8 6.35,38.42 6.35,40.64 6.35,40.64 6.35,41.05 6.45,41.14 7.52,41.14
GND on TOP (solid shape): 112.1,86.47 112.1,84.73 110.06,82.69 110.06,77.39 110.55,76.9 112.33,76.9 112.52,76.71 112.52,75.12 112.33,74.93 109.92,74.93 107.95,72.96 107,72.96 106.81,73.15 106.81,75.88 107.34,76.42 107.34,77.27 107.88,77.81 107.88,78.84 107.53,79.19 107.53,83.33 107.54,83.33 107.54,83.48 108.01,83.96 108.01,86.55 108.21,86.74 111.82,86.74
GND on TOP (solid shape): 203.58,72.52 203.58,72.33 203.01,71.76 203.01,70.99 203.52,70.49 203.52,70.3 203.43,70.21 203.4,70.21 203.4,70.18 203.33,70.11 203.26,70.11 203.14,69.98 203.14,69.47 202.88,69.22 202.88,67.12 202.76,66.99 202.38,66.99 202.31,67.06 202.31,67.67 202.32,67.68 202.35,67.83 202.32,67.98 202.31,67.99 202.31,70.94 202.47,71.09 202.47,72.25 202.88,72.67 203.43,72.67
GND on TOP (solid shape): 7.35,63.72 8.34,63.72 8.49,63.57 8.49,63.35 8.4,63.26 7.64,63.26 7.34,63.42 7,63.4 6.99,63.4 6.95,63.4 6.92,63.37 6.78,63.28 6.68,63.16 6.39,63.16 6.21,63.34 6.21,63.67 6.24,63.73 6.27,63.8 6.32,63.85 7.21,63.85
GND on TOP (solid shape): 54.61,7.37 54.61,6.35 54.87,6.1 56.52,6.1 56.52,5.21 55.37,5.21 55.12,4.95 55.12,4.07 55.09,4.07 54.84,3.81 54.84,3 54.64,2.8 54.51,2.8 54.43,2.71 54.42,2.71 54.26,2.55 54.05,2.47 53.98,2.26 53.65,1.93 53.65,1.6 53.42,1.37 52.41,1.37 51.93,1.85 51.93,6.85 52.58,7.49 54.48,7.49
GND on TOP (solid shape): 339.95,21.77 339.95,20.83 339.75,20.63 339.75,19.89 339.9,19.73 340.87,19.73 341.06,19.54 341.06,18.02 340.84,17.81 338.9,17.81 338.7,18.01 335.12,18.01 334.97,18.16 334.97,18.42 334.96,18.42 334.96,19.31 334.77,19.5 334.07,19.5 334.04,19.53 332.17,19.53 332.04,19.66 332.04,20.2 332.17,20.32 333.06,20.32 334.27,21.53 336.04,21.53 336.11,21.47 336.11,20.58 336.3,20.39 337.25,20.39 337.84,20.97 337.84,21.33 337.91,21.4 338.7,21.4 339.12,21.82 339.9,21.82
GND on TOP (solid shape): 10.31,79.6 10.31,79.05 11.18,78.18 12.57,78.18 13.01,77.75 13.01,76.84 12.48,76.31 11.62,76.31 10.36,75.06 6.05,75.06 3.89,72.9 3.89,61.34 3.58,61.04 2.85,61.04 2.52,60.71 2.52,59.97 2.14,59.59 1.56,59.59 1.11,59.59 1.11,75.58 1.34,76.14 1.9,76.37 8.88,76.37 10.05,76.08 9.76,77.26 9.76,79.69 10.22,79.69
GND on TOP (solid shape): 345.95,120.5 343.2,117.75 340.45,120.5 340.45,121.6 341.57,121.6 341.58,121.6 344.35,121.6 344.35,122.3 344.64,123.01 345.35,123.3 345.95,123.3
GND on TOP (solid shape): 251.2,121.97 251.5,121.25 251.45,119.9 249.52,117.28 246.44,118.33 246.1,119.04 245.95,119.81 245.95,119.9 245.95,122.25 246.95,122.25 247,122.25 250.47,122.25
GND on TOP (solid shape): outline of 250 points within 201.05,80.23 204.34,83.38
GND on TOP (solid shape): outline of 146 points within 0.21,0.21 352.49,48.39
GND on TOP (solid shape): outline of 660 points within 329.42,55.69 352.49,109.53
GND on TOP (solid shape): outline of 2015 points within 1.11,33.22 351.59,123.09
GND on BOTTOM (solid shape): 15.96,111.87 8.96,111.87 8.96,112.67 15.96,112.67
GND on BOTTOM (solid shape): 15.96,94.57 8.96,94.57 8.96,95.37 15.96,95.37
GND on BOTTOM (solid shape): 18.27,100.12 17.47,100.12 17.47,107.12 18.27,107.12
GND on BOTTOM (solid shape): 103.2,65.2 102.4,65.2 102.4,82.2 103.2,82.2
GND on BOTTOM (solid shape): 334.55,69.95 333.75,69.95 333.75,76.95 334.55,76.95
GND on BOTTOM (solid shape): 343.15,81.7 336.15,81.7 336.15,82.5 343.15,82.5
GND on BOTTOM (solid shape): 343.15,64.4 336.15,64.4 336.15,65.2 343.15,65.2
GND on BOTTOM (solid shape): 18.27,109.07 17.47,109.07 17.47,111.87 16.27,111.87 16.27,112.67 18.27,112.67
GND on BOTTOM (solid shape): 18.27,94.57 16.27,94.57 16.27,95.37 17.47,95.37 17.47,98.17 18.27,98.17
GND on BOTTOM (solid shape): 334.55,65.2 335.75,65.2 335.75,64.4 333.75,64.4 333.75,68.7 334.55,68.7
GND on BOTTOM (solid shape): 335.75,81.7 334.55,81.7 334.55,78.2 333.75,78.2 333.75,82.5 335.75,82.5
GND on BOTTOM (solid shape): 103.2,57.1 103.2,55.45 119.3,55.45 119.3,54.65 102.4,54.65 102.4,57.1 102.85,57.1
GND on BOTTOM (solid shape): 151,101.86 151,98.68 150.75,98.43 148.4,98.43 148.21,98.62 148.21,101.98 148.34,102.11 150.75,102.11
GND on BOTTOM (solid shape): 189.41,111.2 189.41,109.42 189.26,109.27 185.07,109.27 184.84,109.5 184.84,111.3 184.96,111.43 189.18,111.43
GND on BOTTOM (solid shape): 110.52,58.04 110.52,56.47 110.24,56.19 109.42,56.19 109.15,56.45 109.15,57.78 109.59,58.22 110.34,58.22
GND on BOTTOM (solid shape): 200.83,96.17 200.83,92.81 200.37,92.36 197.44,92.36 197.21,92.58 197.21,96.88 197.49,97.16 199.84,97.16
GND on BOTTOM (solid shape): 118.89,59.72 118.89,58.04 117.54,56.69 114.5,56.69 114.25,56.95 114.25,57.1 114.28,57.13 114.28,59.36 114.85,59.94 118.66,59.94
GND on BOTTOM (solid shape): 216.18,114.11 216.18,112.68 215.89,112.4 215.22,112.4 214.74,111.91 211.18,111.91 210.44,112.65 210.44,114.56 210.57,114.68 215.61,114.68
GND on BOTTOM (solid shape): 231.56,119.97 231.56,118.96 231.25,118.64 227.05,118.64 227.02,118.68 227.02,119.88 227.32,120.17 231.35,120.17
GND on BOTTOM (solid shape): 320.98,33.2 320.68,32.89 320.68,32.51 320.55,32.39 320.3,32.39 320.23,32.45 320.23,32.96 319.99,33.2 319.99,33.59 320.98,33.59
GND on BOTTOM (solid shape): 118.75,87.12 118.75,85.6 118.62,85.47 118.37,85.47 117.98,85.09 114.56,85.09 114.43,85.22 114.43,86.88 114.92,87.38 118.49,87.38
GND on BOTTOM (solid shape): 124.74,69.57 124.74,67.27 124.58,67.12 120.26,67.12 119.29,68.09 119.29,68.31 119.86,68.89 119.69,68.89 120.68,69.88 124.44,69.88
GND on BOTTOM (solid shape): 287.97,29.1 287.97,27.62 287.34,26.99 287.02,26.99 286.96,27.05 286.96,27.31 287.75,28.1 287.75,29.09 287.82,29.16 287.91,29.16
GND on BOTTOM (solid shape): 133.71,120.27 133.71,117.12 133.5,116.92 124.94,116.92 124.52,117.34 124.52,120.81 124.84,121.14 132.84,121.14
GND on BOTTOM (solid shape): 347.47,38.48 347.47,37.91 347.35,37.78 346.52,37.78 346.01,38.29 345.06,38.29 344.87,38.48 344.36,38.48 344.3,38.55 344.3,38.86 344.36,38.93 347.03,38.93
GND on BOTTOM (solid shape): 161.94,82.07 161.94,81.88 161.56,81.5 161.56,80.87 161.43,80.74 161.21,80.74 161.12,80.84 161.12,81.71 161.29,81.89 161.29,81.92 161.59,82.22 161.8,82.22
GND on BOTTOM (solid shape): 249.75,99.75 249.84,99.61 249.97,99.52 250.32,99.18 250.32,95.07 250.19,94.95 248.84,94.95 248.67,95.12 248.67,99.68 248.85,99.86 249.63,99.86
GND on BOTTOM (solid shape): 330.31,70.6 330.31,67.96 330.54,67.74 330.54,67.14 330.45,67.04 329.88,67.04 329.78,67.14 329.67,67.14 329.66,67.15 328.71,67.15 328.59,67.26 328.59,68.85 329.24,69.5 329.24,70.68 329.33,70.77 330.14,70.77
GND on BOTTOM (solid shape): 104.75,94.83 104.75,94.34 105.23,93.86 105.75,93.86 105.96,93.65 105.96,92.96 105.81,92.81 104.32,92.81 104.14,92.99 104.14,93.89 104.04,93.99 104.04,94.92 104.07,94.95 104.63,94.95
GND on BOTTOM (solid shape): 154.82,82.11 154.82,81.92 154.45,81.55 154.45,80.8 154.38,80.74 154.13,80.74 154,80.87 154,81.5 153.62,81.88 153.62,82.07 153.75,82.2 153.94,82.2 154.09,82.06 154.35,82.06 154.52,82.22 154.71,82.22
GND on BOTTOM (solid shape): 157.17,82.09 157.17,81.9 156.8,81.52 156.8,80.8 156.73,80.74 156.48,80.74 156.35,80.87 156.35,81.5 156.35,81.51 156.35,81.65 156.68,81.99 156.68,82.05 156.87,82.23 157.03,82.23
GND on BOTTOM (solid shape): 180.24,111.25 180.24,97.41 179.45,96.62 179.45,94.03 179.27,93.85 176.95,93.85 176.47,94.34 175.11,94.34 174.96,94.49 174.96,94.84 177.74,97.62 177.74,106.09 178.33,106.69 178.33,110.87 178.89,111.43 180.06,111.43
GND on BOTTOM (solid shape): 181.62,121.08 181.62,119.73 181.47,119.58 181.19,119.58 181.11,119.66 180.58,119.66 180.56,119.64 180.53,119.64 180.46,119.58 180.15,119.58 179.96,119.39 179.96,118.22 179.77,118.03 177.03,118.03 176.55,118.5 176.55,121.1 176.67,121.22 181.48,121.22
GND on BOTTOM (solid shape): 54.67,7.3 54.67,7.05 54.55,6.92 54.17,6.92 54.04,6.8 54.04,3.87 54.17,3.75 56.58,3.75 57.28,4.45 58.61,4.45 58.71,4.34 58.71,3.02 58.68,2.99 53.09,2.99 52.71,3.37 52.71,5.13 52.29,5.55 52.29,7.19 52.51,7.42 53.14,7.42 53.15,7.43 54.55,7.43
GND on BOTTOM (solid shape): 188,101.99 188,99.26 189.55,97.72 189.55,93.8 189.33,93.57 187.81,93.57 187.61,93.78 187.61,97.29 187.45,97.44 184.5,97.44 184.48,97.46 184.48,100.74 184.49,100.75 184.49,101.5 184.82,101.82 187.24,101.82 187.37,101.95 187.37,101.99 187.52,102.13 187.86,102.13
GND on BOTTOM (solid shape): 263.26,17.96 263.26,16.52 263.01,16.27 261.41,16.27 261.29,16.39 259.77,16.39 259.69,16.46 259.69,16.63 259.78,16.72 261.37,16.72 261.8,17.15 261.8,17.5 261.41,17.88 259.79,17.88 259.7,17.97 259.7,18.14 259.78,18.22 261.23,18.22 261.27,18.26 262.95,18.26
GND on BOTTOM (solid shape): 274.5,30.02 274.5,29.72 274.64,29.58 276.75,29.58 277.12,29.21 277.12,28.86 276.84,28.58 276.84,27.86 276.67,27.69 274.28,27.69 273.87,27.27 273.33,27.27 273.24,27.36 273.24,29.48 273.26,29.49 273.26,30.05 273.36,30.15 274.37,30.15
GND on BOTTOM (solid shape): 112.33,96.65 112.37,96.61 112.37,94.28 112.37,94.27 112.37,93.99 111.6,93.22 110.81,93.22 110.8,93.22 109.85,93.22 109.68,93.4 109.68,95.35 109.3,95.73 108.35,95.73 108.33,95.75 108.33,97.17 108.79,97.63 111.35,97.63
GND on BOTTOM (solid shape): 163.49,82.13 163.58,82.05 163.77,82.05 163.79,82.07 163.85,82.07 163.97,82.2 164.16,82.2 164.29,82.07 164.29,81.88 163.91,81.5 163.91,80.87 163.78,80.74 163.53,80.74 163.47,80.8 163.47,81.48 163.07,81.87 163.07,82.09 163.21,82.23 163.4,82.23
GND on BOTTOM (solid shape): 144.66,82.04 144.88,82.04 145.05,82.21 145.29,82.21 145.41,82.08 145.41,81.87 145.34,81.81 145.29,81.74 145.29,81.73 145.2,81.64 145.2,80.95 144.98,80.73 144.45,80.73 144.29,80.89 144.29,81.73 144.13,81.9 144.13,82.07 144.27,82.21 144.49,82.21
GND on BOTTOM (solid shape): 203.07,108.99 203.07,107.98 203.96,107.09 203.96,106.1 203.88,106.01 203.8,106.01 203.8,106.01 203.62,106.01 203.61,106.02 203.28,106.02 202.95,105.69 202.04,105.69 201.71,105.36 201.71,102.97 201.37,102.63 200.11,102.63 199.99,102.76 199.99,104.97 200.94,105.92 200.94,109.15 201,109.21 202.86,109.21
GND on BOTTOM (solid shape): 166.67,82.1 166.67,81.91 166.26,81.5 166.26,80.8 166.2,80.74 165.94,80.74 165.81,80.87 165.81,81.5 165.43,81.88 165.43,82.07 165.56,82.2 165.75,82.2 165.88,82.07 165.94,82.07 165.95,82.07 166.03,82.06 166.11,82.07 166.12,82.07 166.17,82.07 166.33,82.23 166.54,82.23
GND on BOTTOM (solid shape): 168.16,82.2 168.21,82.13 168.31,82.07 168.39,82.06 168.47,82.07 168.48,82.07 168.55,82.07 168.67,82.2 168.86,82.2 168.99,82.07 168.99,81.88 168.61,81.5 168.61,80.87 168.48,80.74 168.23,80.74 168.16,80.8 168.16,81.49 167.8,81.86 167.8,82.13 167.92,82.25 168.11,82.25
GND on BOTTOM (solid shape): 116.5,94.39 116.8,94.39 116.98,94.34 117.17,94.39 117.2,94.39 117.41,94.17 117.41,93.79 117.3,93.67 116.03,93.67 115.86,93.93 115.56,93.96 115.53,93.96 115.29,94.2 115.29,94.51 115.37,94.59 116.29,94.59
GND on BOTTOM (solid shape): 204.15,56.45 204.15,54.04 203.99,53.87 203.56,54.32 203.4,53.72 202.25,53.72 201.68,54.29 201.68,56.45 201.74,56.52 203.26,56.52 203.33,56.58 204.03,56.58
GND on BOTTOM (solid shape): 147.74,82.11 147.74,81.84 147.69,81.79 147.65,81.73 147.41,81.48 147.41,80.87 147.25,80.72 146.85,80.72 146.67,80.9 146.67,81.65 146.62,81.69 146.62,81.71 146.57,81.8 146.49,81.86 146.47,81.88 146.47,82.07 146.61,82.21 146.87,82.21 146.97,82.11 146.99,82.1 147.19,82.07 147.35,82.19 147.36,82.2 147.39,82.23 147.61,82.23
GND on BOTTOM (solid shape): 149.26,82.21 149.27,82.2 149.43,82.07 149.63,82.1 149.65,82.11 149.78,82.23 149.97,82.23 150.1,82.11 150.1,81.92 149.72,81.54 149.72,80.9 149.59,80.77 149.18,80.77 149.07,80.89 149.07,81.64 148.97,81.74 148.97,81.74 148.91,81.82 148.83,81.88 148.83,82.09 148.89,82.13 148.93,82.2 148.97,82.23 149.23,82.23
GND on BOTTOM (solid shape): 19.47,48.42 19.47,48.23 19.84,47.85 20.33,47.85 20.81,47.37 20.81,46.4 20.82,46.39 20.82,46.26 20.85,46.23 21.41,46.23 21.63,46 21.66,45.97 21.7,45.94 22.17,45.47 22.17,45.47 22.56,45.08 22.56,44.43 22.51,44.37 22.37,44.37 22.29,44.45 22.29,44.64 22.18,44.75 22.17,44.75 21.71,44.75 21.67,44.71 21.44,44.71 20.85,45.3 20.74,45.3 20.58,45.47 20.56,45.47 19.98,46.05 19.37,46.05 19.26,46.16 18.84,46.16 18.81,46.19 18.81,48.38 18.93,48.51 19.38,48.51
GND on BOTTOM (solid shape): 159.56,82.1 159.56,81.85 159.5,81.79 159.45,81.71 159.45,81.7 159.23,81.48 159.23,80.87 159.08,80.72 158.67,80.72 158.49,80.89 158.49,81.64 158.43,81.7 158.43,81.71 158.37,81.81 158.29,81.87 158.29,82.06 158.43,82.2 158.7,82.2 158.74,82.16 158.76,82.13 158.81,82.09 159,82.07 159.16,82.18 159.2,82.23 159.43,82.23
GND on BOTTOM (solid shape): 11.79,72.26 11.79,72.25 12.05,71.99 12.05,71.26 11.88,71.08 11.2,71.08 11.18,71.06 11.16,71.06 11.12,71.03 11.12,71.01 11.05,70.94 11.05,70.05 10.92,69.93 10.92,69.9 10.92,69.04 10.92,68.96 11.24,68.65 11.31,68.65 11.31,68.64 11.81,68.64 12,68.45 12,67.76 12.32,67.44 12.32,66.99 12.19,66.87 10.86,66.87 10.8,66.93 10.8,67.57 10.22,68.14 10.22,68.64 10.16,68.71 10.05,68.71 10.04,68.72 9.49,68.72 9.47,68.71 9.46,68.71 8.76,68.01 8,68.01 7.96,68.05 7.96,68.56 8.73,69.33 8.73,69.98 8.96,70.21 9.78,70.21 9.87,70.12 10.43,70.12 10.54,70.23 10.54,71.25 10.48,71.3 10.42,71.37 10.36,71.43 10.31,71.48 9.68,71.48 9.65,71.45 8.76,71.45 8.51,71.71 8.51,72.44 8.64,72.57 11.48,72.57
GND on BOTTOM (solid shape): 10.21,79.15 11.18,78.18 12.57,78.18 13.01,77.75 13.01,76.84 12.32,76.15 11.46,76.15 10.36,75.06 6.05,75.06 3.89,72.9 3.89,61.34 3.58,61.04 2.85,61.04 2.52,60.71 2.52,59.97 2.14,59.59 1.15,59.59 1.11,59.59 1.11,75.58 1.34,76.14 1.9,76.37 8.88,76.37 10.05,76.08 9.76,77.26 9.76,79.76 10.21,79.76
GND on BOTTOM (solid shape): 245.7,2.1 248.4,4.8 251.1,2.1 251.1,0.58 251.08,0.57 251.02,0.56 250.95,0.55 250.03,0.55 250.02,0.54 247.08,0.54 246.73,0.18 246.25,0.05 245.7,0.05
GND on BOTTOM (solid shape): 345.7,120.5 343.2,118 340.7,120.5 340.7,121.6 341.57,121.6 341.66,121.6 344.35,121.6 344.35,122.3 344.64,123.01 345.35,123.3 345.7,123.3
GND on BOTTOM (solid shape): 251.2,121.97 251.5,121.25 251.45,119.9 248.7,117.15 245.95,119.9 245.95,122.25 246.95,122.25 247.02,122.24 247.03,122.25 250.47,122.25
GND on BOTTOM (solid shape): outline of 110 points within 0.95,0.05 9.55,7.95
GND on BOTTOM (solid shape): outline of 127 points within 130.86,1.7 147.05,9.49
GND on BOTTOM (solid shape): 20.58,34.77 20.67,34.71 20.66,34.6 20.82,34.09 21.25,34.41 21.32,34.51 21.43,34.49 21.51,34.41 21.71,34.41 21.87,34.57 22.26,34.57 22.51,34.32 22.51,34.19 21.89,33.57 21.88,33.57 21.71,33.4 20.77,33.4 20.77,33.4 19.71,33.4 19.54,33.23 19.54,33.22 19.51,33.19 19.51,30.81 19.61,30.71 22.96,30.71 23.5,31.24 23.5,33.39 23.55,33.5 23.53,33.63 23.52,33.64 23.52,34.4 23.57,34.44 23.93,34.44 24.04,34.33 24.04,32.04 24.16,31.93 24.16,31.91 24.25,31.72 24.44,31.63 24.46,31.62 24.54,31.54 24.54,31.05 24.54,31.02 24.53,30.99 24.22,31.06 23.99,30.86 22.95,29.82 20,29.82 19.68,30.13 19.65,30.13 19.65,30.13 19.3,30.13 19.14,30.29 19.14,30.32 19.06,30.59 18.82,30.73 18.77,30.73 18.78,30.84 18.77,30.89 18.77,34.43 19.11,34.77
GND on BOTTOM (solid shape): 112.33,86.42 112.33,85.4 112.32,85.4 111.86,84.94 111.29,84.94 110.75,84.39 110.75,83.61 110.39,83.26 109.53,83.26 109.48,83.2 109.48,80.61 109.58,80.51 110.34,80.51 110.98,79.87 115.2,79.87 115.79,79.28 115.79,75.71 115.33,75.25 110.49,75.25 110.01,75.72 108.81,75.72 108.69,75.6 108.69,72.63 109.61,72.63 109.98,72.26 109.98,70.8 109.73,70.55 107.88,70.55 107.03,71.4 106.61,71.4 106.39,71.62 106.39,72.64 106.48,72.73 106.67,72.73 106.75,72.69 106.76,72.6 106.76,72.57 106.76,72.54 106.76,72.03 106.91,71.8 107.19,71.85 107.26,71.88 107.33,71.85 107.61,71.8 107.77,72.03 107.77,72.54 107.61,72.78 107.33,72.72 107.26,72.69 107.19,72.72 107.05,72.79 106.9,72.77 106.81,72.78 106.76,72.86 106.76,75.96 107.38,76.58 107.38,77.31 107.39,77.32 107.39,77.65 107.6,77.86 107.6,78.86 107.14,79.32 107.14,80.49 107.2,80.55 107.34,80.55 107.42,80.47 107.42,79.81 107.59,79.63 108.42,79.63 108.53,79.74 108.53,80.71 108.37,80.86 107.66,80.86 107.56,80.97 107.56,83.9 107.89,84.23 107.89,86.23 108.25,86.6 112.16,86.6
GND on BOTTOM (solid shape): 153.23,87.39 153.23,87.13 153.16,87.06 153.16,84.91 153.18,84.9 153.22,84.77 153.32,84.68 153.32,84.61 153.74,84.2 153.93,84.2 154,84.13 154.03,84.09 154.06,84.06 154.06,83.81 154.01,83.77 153.98,83.71 153.92,83.65 153.76,83.65 153.54,83.44 153.44,83.44 153.31,83.3 153.31,83.2 153.16,83.05 153.16,81.74 153.14,81.71 153.14,80.48 153.05,80.4 151.68,80.4 151.57,80.51 151.57,81.53 151.39,81.71 151.39,81.74 151.26,81.87 151.26,82.1 151.4,82.24 151.55,82.24 151.6,82.19 151.73,82.05 152,82.05 152.03,82.1 152.05,82.14 152.08,82.17 152.11,82.2 152.11,82.45 152.08,82.48 152.02,82.63 152.08,82.79 152.11,82.82 152.11,82.96 152.11,83.01 152.11,83.57 152.11,83.61 152.11,83.75 152.08,83.78 152.02,83.93 152.08,84.09 152.11,84.12 152.11,84.26 152.11,84.31 152.11,84.87 152.11,84.91 152.11,85.05 152.08,85.08 152.02,85.23 152.08,85.39 152.11,85.42 152.11,85.56 152.11,85.61 152.11,86.17 152.11,86.21 152.11,86.35 152.08,86.38 152.02,86.54 152.08,86.69 152.11,86.72 152.11,86.86 152.11,86.91 152.11,87.39 152.19,87.47 153.14,87.47
GND on BOTTOM (solid shape): outline of 139 points within 136.35,108.41 163.33,120.41
GND on BOTTOM (solid shape): outline of 117 points within 21.56,55.71 24.85,59.69
GND on BOTTOM (solid shape): outline of 1243 points within 0.21,0.21 352.49,109.58
GND on BOTTOM (solid shape): outline of 1928 points within 1.11,34.24 351.59,123.09
GND on IN1 (solid shape): 10.31,79.61 10.31,79.05 11.18,78.18 12.57,78.18 13.01,77.75 13.01,76.84 12.32,76.15 11.46,76.15 10.34,75.03 6.02,75.03 3.86,72.87 3.86,66.09 3.72,65.95 3.72,59.78 3.53,59.59 1.15,59.59 1.11,59.59 1.11,75.58 1.34,76.14 1.9,76.37 8.88,76.37 10.05,76.08 9.76,77.26 9.76,79.7 10.21,79.7
GND on IN1 (solid shape): outline of 1177 points within 0.21,0.21 352.49,109.58
GND on IN1 (solid shape): outline of 314 points within 1.11,34.24 351.59,123.09
GND on IN2 (solid shape): 10.21,79.15 11.18,78.18 12.57,78.18 13.01,77.75 13.01,76.84 12.32,76.15 11.46,76.15 10.36,75.06 6.05,75.06 3.89,72.9 3.89,61.34 3.58,61.04 2.85,61.04 2.52,60.71 2.52,59.97 2.14,59.59 1.15,59.59 1.11,59.59 1.11,75.58 1.34,76.14 1.9,76.37 8.88,76.37 10.05,76.08 9.76,77.26 9.76,79.76 10.21,79.76
GND on IN2 (solid shape): outline of 1175 points within 0.21,0.21 352.49,109.59
GND on IN2 (solid shape): outline of 322 points within 1.11,34.24 351.59,123.09
GND on IN3 (solid shape): 180.03,109.97 180.03,108.07 180.05,108.05 180.05,97.09 179.78,96.83 177.47,96.83 177.14,97.16 177.14,98.95 176.78,99.31 175.41,99.31 175.13,99.59 175.13,108.12 175.3,108.29 175.82,108.29 176.12,108.6 176.12,109.73 176.53,110.14 179.86,110.14
GND on IN3 (solid shape): 112.35,86.41 112.35,85.07 112.09,84.81 111.15,84.81 110.72,84.38 110.72,83.64 110.34,83.26 109.83,83.26 109.56,83 109.56,80.48 109.73,80.32 110.49,80.32 110.95,79.86 115.16,79.86 115.42,79.6 115.42,75.64 115.01,75.24 110.57,75.24 110.03,75.77 108.9,75.77 108.9,75.76 108.71,75.57 108.71,72.65 108.84,72.52 109.65,72.52 109.93,72.24 109.93,70.82 109.67,70.55 107.82,70.55 107.14,71.24 107.14,72.04 106.83,72.35 106.83,75.86 107.42,76.46 107.42,77.34 108.15,78.08 108.15,78.47 107.57,79.06 107.57,80.34 107.61,80.38 107.61,83.66 107.9,83.95 107.9,86.31 108.18,86.59 112.17,86.59
GND on IN3 (solid shape): 10.21,79.15 11.18,78.18 12.57,78.18 13.01,77.75 13.01,76.84 12.32,76.15 11.46,76.15 10.36,75.06 6.05,75.06 3.89,72.9 3.89,61.34 3.58,61.04 2.85,61.04 2.52,60.71 2.52,59.97 2.14,59.59 1.15,59.59 1.11,59.59 1.11,75.58 1.34,76.14 1.9,76.37 8.88,76.37 10.05,76.08 9.76,77.26 9.76,79.76 10.21,79.76
GND on IN3 (solid shape): outline of 1175 points within 0.21,0.21 352.49,109.59
GND on IN3 (solid shape): outline of 321 points within 1.11,34.24 351.59,123.09
GND on IN4 (solid shape): 112.35,86.41 112.35,85.07 112.09,84.81 111.15,84.81 110.72,84.38 110.72,83.64 110.34,83.26 109.83,83.26 109.56,83 109.56,80.48 109.73,80.32 110.49,80.32 110.95,79.86 115.16,79.86 115.42,79.6 115.42,75.64 115.01,75.24 110.57,75.24 110.03,75.77 108.9,75.77 108.9,75.76 108.71,75.57 108.71,72.65 108.84,72.52 109.65,72.52 109.93,72.24 109.93,70.82 109.67,70.55 107.82,70.55 107.14,71.24 107.14,72.04 106.83,72.35 106.83,75.86 107.42,76.46 107.42,77.34 108.15,78.08 108.15,78.47 107.57,79.06 107.57,80.34 107.61,80.38 107.61,83.66 107.9,83.95 107.9,86.31 108.18,86.59 112.17,86.59
GND on IN4 (solid shape): 10.21,79.15 11.18,78.18 12.57,78.18 13.01,77.75 13.01,76.84 12.32,76.15 11.46,76.15 10.36,75.06 6.05,75.06 3.89,72.9 3.89,61.34 3.58,61.04 2.85,61.04 2.52,60.71 2.52,59.97 2.14,59.59 1.15,59.59 1.11,59.59 1.11,75.58 1.34,76.14 1.9,76.37 8.88,76.37 10.05,76.08 9.76,77.26 9.76,79.76 10.21,79.76
GND on IN4 (solid shape): outline of 1177 points within 0.21,0.21 352.49,109.59
GND on IN4 (solid shape): outline of 321 points within 1.11,34.24 351.59,123.09
GND on IN5 (solid shape): 10.21,79.15 11.18,78.18 12.57,78.18 13.01,77.75 13.01,76.84 12.32,76.15 11.46,76.15 10.36,75.06 6.05,75.06 3.89,72.9 3.89,61.34 3.58,61.04 2.85,61.04 2.52,60.71 2.52,59.97 2.14,59.59 1.15,59.59 1.11,59.59 1.11,75.58 1.34,76.14 1.9,76.37 8.88,76.37 10.05,76.08 9.76,77.26 9.76,79.76 10.21,79.76
GND on IN5 (solid shape): outline of 1177 points within 0.21,0.21 352.49,109.59
GND on IN5 (solid shape): outline of 320 points within 1.11,34.24 351.59,123.09
GND on IN6 (solid shape): 112.35,86.41 112.35,85.07 112.09,84.81 111.15,84.81 110.72,84.38 110.72,83.64 110.34,83.26 109.83,83.26 109.56,83 109.56,80.48 109.73,80.32 110.49,80.32 110.95,79.86 115.16,79.86 115.42,79.6 115.42,75.64 115.01,75.24 110.57,75.24 110.03,75.77 108.9,75.77 108.9,75.76 108.71,75.57 108.71,72.65 108.84,72.52 109.65,72.52 109.93,72.24 109.93,70.82 109.67,70.55 107.82,70.55 107.14,71.24 107.14,72.04 106.83,72.35 106.83,75.86 107.42,76.46 107.42,77.34 108.15,78.08 108.15,78.47 107.57,79.06 107.57,80.34 107.61,80.38 107.61,83.66 107.9,83.95 107.9,86.31 108.18,86.59 112.17,86.59
GND on IN6 (solid shape): 10.21,79.15 11.18,78.18 12.57,78.18 13.01,77.75 13.01,76.84 12.32,76.15 11.46,76.15 10.36,75.06 6.05,75.06 3.89,72.9 3.89,61.34 3.58,61.04 2.85,61.04 2.52,60.71 2.52,59.97 2.14,59.59 1.15,59.59 1.11,59.59 1.11,75.58 1.34,76.14 1.9,76.37 8.88,76.37 10.05,76.08 9.76,77.26 9.76,79.76 10.21,79.76
GND on IN6 (solid shape): outline of 224 points within 0.21,0.21 352.49,109.59
GND on IN6 (solid shape): outline of 322 points within 1.11,34.24 351.59,123.09
GND on TOP: 157.97,69.64 157.59,70.02 157.59,73.43 157.51,73.52 156.63,73.52 156.54,73.43 156.54,68.61 156.78,68.38 157.48,68.38 157.97,68.86
GND on TOP: 260.88,38.72 260.88,38.79 260.86,38.81 260.07,38.81 260.01,38.86 260.01,38.96 260.07,39.02 260.84,39.02 260.86,39.04 260.86,40.24 260.34,40.76 260.34,41.69 260.41,41.76 261.19,41.76 261.37,41.58 261.37,40.87 261.88,40.36 261.88,37.59 261.86,37.58 261.86,35.09 260.61,33.83 260,33.83 259.79,34.04 259.79,35.38 260.4,35.99 260.4,36.73 260.88,37.21
GND on TOP: 300.95,25.97 301.51,25.97 301.65,26.11 301.65,26.59 301.73,26.67 302.78,26.67 302.91,26.54 302.91,25.95 302.98,25.87 305.58,25.87 305.7,26 305.7,27.73 305.51,27.92 301.92,27.92 300.93,26.93 300.93,26
GND on TOP: 168.48,89.03 169.83,89.03 170.14,88.72 170.14,87.83 170.52,87.44 170.52,87.35 170.55,87.33 170.55,86.65 170.38,86.49 170.36,86.49 170.34,86.47 170.34,86.06 170.32,86.03 169.82,86.03 169.8,86.01 169.8,85.34 170.04,85.1 170.04,84.03 169.34,83.33 169.34,82.45 169.34,82.45 169.34,81.84 170.46,80.72 170.46,79.91 170.4,79.84 168.18,79.84 167.98,80.04 167.98,80.7 167.99,80.7 167.99,81.69 167.75,81.92 167.75,82.17 168.08,82.49 168.08,87.64 168.24,87.81 168.24,88.79
GND on TOP: 137.46,108.41 136.37,109.5 136.37,111.87 136.79,112.3 137.5,112.3 137.67,112.46 137.67,113.3 137.94,113.58 138.21,113.58 138.76,114.12 138.76,116.7 138.79,116.73 138.79,117.59 138.99,117.78 138.99,120.06 139.66,120.73 151.08,120.73 151.33,120.47 151.33,120.12 151.11,119.89 150.42,119.89 150.14,119.61 150.14,117.32 150.5,116.97 155.55,116.97 156.44,117.86 156.44,120.31 156.85,120.72 159.08,120.72 159.57,120.24 159.57,118.33 159.42,118.18 158.9,118.18 158.9,118.18 158.43,117.71 158.43,117.46 158.44,117.44 158.44,117.1 158.98,116.56 160.72,116.56 161,116.84 163.01,116.84 163.32,116.53 163.32,114.58 162.77,114.03 162.79,114.01 162.79,113.17 162.83,113.12 163.13,113.12 163.31,112.95 163.31,111.52 163.19,111.4 162.17,111.4 161.01,112.55 161.01,113.72 160.31,114.42 158.16,114.42 158.03,114.56 156.33,114.56 155.73,113.96 155.73,113.96 155.43,113.67 153.28,113.67 152.52,114.43 151,114.43 150.62,114.81 146.23,114.81 146.22,114.81 143.5,114.81 143.3,114.61 143.3,113.8 141.89,112.39 141.89,109.59 140.7,108.41
GND on TOP: 137.67,4.85 136.43,3.61 136.43,1.82 136.2,1.6 133.72,1.6 133.48,1.84 133.48,2.44 133.72,2.68 135.13,2.68 135.28,2.83 135.28,4.28 135.45,4.45 135.57,4.45 136.23,5.12 136.23,5.83 136.03,6.03 135.09,6.03 134.96,6.15 134.96,6.29 134.77,6.48 133.26,6.48 133.13,6.61 133.13,7.06 133.56,7.49 135.97,7.49 136.73,8.26 138.67,8.26 139.19,8.78 139.19,9.37 139.31,9.49 140.06,9.49 140.13,9.41 140.13,6.3 138.69,4.85
GND on TOP: 160.89,83.72 160.82,83.65 160.09,83.65 159.91,83.47 159.91,82.45 160.06,82.31 160.5,82.31 160.55,82.26 160.55,81.19 160.54,81.18 160.54,80.9 160.2,80.55 160.2,80.06 160.2,80.05 160.2,79.98 160.14,79.92 159.38,79.92 159.21,79.75 159.21,78.67 159.11,78.58 156.77,78.58 156.7,78.65 156.7,79.5 156.9,79.7 157.83,79.7 158.08,79.96 158.08,81.14 157.93,81.3 157.93,81.69 158.13,81.89 158.13,82.27 157.93,82.47 157.93,83.63 158.29,84 158.29,87.65 158.47,87.83 160.01,87.83 160.44,87.4 160.44,84.3 160.57,84.17 160.57,84.16 160.6,84.13 160.86,84.13 160.89,84.1
GND on TOP: 152.44,80.14 152.44,70.4 152.35,70.31 152.35,69.62 152.41,69.55 152.81,69.55 152.85,69.6 152.85,69.84 152.86,69.84 152.86,70.1 152.9,70.14 153.47,70.14 153.53,70.09 153.53,69.48 153.28,69.24 153.28,68.76 153.38,68.66 153.72,68.66 153.82,68.76 153.82,69.35 154.05,69.58 154.05,70.08 154.38,70.41 154.38,79.7 154.13,79.96 154.13,81.21 153.67,81.66 152.8,81.66 152.45,81.31 152.45,80.15
GND on TOP: 167.8,116.81 167.39,116.4 167.39,115.89 166.84,115.34 166.84,114.71 166.96,114.59 168.37,114.59 168.76,114.98 168.76,114.99 168.84,115.06 168.84,115.39 168.97,115.53 168.97,115.77 168.74,116 168.74,116.63 168.57,116.81
GND on TOP: 163.65,75.2 165.22,75.2 165.59,74.83 165.59,71.61 165.6,71.61 165.6,69.41 164.78,69.41 164.59,69.22 164.59,68.84 164.81,68.62 165.02,68.62 165.13,68.52 165.13,68.21 165.1,68.18 164.43,68.18 164.28,68.34 164.28,69.34 164.15,69.47 163.46,69.47 163.46,70.45 163.52,70.5 163.52,75.07
GND on TOP: 283.72,33.4 285.5,33.4 285.61,33.29 285.61,32.36 285.58,32.32 283.84,32.32 283.67,32.49 283.67,33.35
GND on TOP: 90.82,17.82 91.45,17.82 91.59,17.68 91.59,16.98 91.2,16.59 89.73,16.59 89.6,16.72 89.6,17.36 89.74,17.5 90.51,17.5
GND on TOP: 11.61,12.57 11.61,10.97 11.6,10.96 14.45,10.96 14.59,10.81 14.59,9.94 14.44,9.79 14.03,9.79 13.25,10.56 11.02,10.56 10.81,10.77 10.29,10.77 9.83,10.31 9.83,9.83 9.73,9.73 8.59,9.73 8.23,9.37 7.04,9.37 6.93,9.48 6.93,12.54 7.15,12.75 8.51,12.75 8.55,12.71 9.34,12.71 9.42,12.7 9.5,12.71 9.97,12.71 10.05,12.7 10.13,12.71 11.46,12.71
GND on TOP: 116.86,3.49 116.73,3.36 116.73,1.83 117.09,1.47 125.91,1.47 126.11,1.68 126.11,3.43 125.91,3.63 119.03,3.63 118.88,3.49
GND on TOP: 258.12,40.98 258.19,40.91 258.19,40.48 258.19,40.48 258.19,38.77 258.09,38.67 256.4,38.67 256.09,38.98 256.09,40.52 256.55,40.98
GND on TOP: 169.59,108.91 169.91,109.23 176.05,109.23 176.68,109.86 178.45,109.86 178.66,110.07 178.66,110.54 178.7,110.57 179.36,110.57 179.5,110.7 179.5,110.96 179.61,111.07 180.21,111.07 180.29,110.99 180.29,97.15 180.26,97.13 180.03,97.13 179.48,96.58 179.48,94.07 179.29,93.88 176.94,93.88 176.48,94.34 175.11,94.34 174.96,94.49 174.96,94.85 177.21,97.11 177.21,103.28 176.61,103.89 174.92,103.89 173.8,102.77 171.01,102.77 170.87,102.91 170.87,103.76 170.52,104.1 169.74,104.1 169.59,104.26
GND on TOP: 164.26,93.71 162.97,95 162.97,99.53 163.42,99.98 163.42,100.79 163.95,101.32 163.95,101.84 163.81,101.98 162.69,101.98 162.57,102.1 162.57,105.3 162.03,105.85 157.85,105.85 157.56,106.13 157.56,106.77 156.82,107.52 154.42,107.52 154.12,107.21 154.12,106.56 153.96,106.41 150.21,106.41 149.88,106.75 149.88,107.22 149.26,107.84 147.85,107.84 147.64,107.64 147.64,106.85 147.42,106.64 143.38,106.64 143.13,106.89 143.13,107.92 144.19,108.98 145.95,108.98 146.98,110.01 159.46,110.01 161.61,107.86 161.9,107.86 162.33,107.44 162.33,106.17 162.81,105.68 163.1,105.68 163.3,105.49 165.13,105.49 165.29,105.32 165.29,101.66 165.97,100.99 167.04,100.99 167.16,101.1 167.16,101.65 167.01,101.8 167.01,102.21 167.13,102.34 168.43,102.34 168.5,102.26 168.5,99.21 168.25,98.96 167.49,98.96 167.31,99.14 166.29,99.14 166.22,99.06 166.22,97.77 166.47,97.51 166.83,97.51 166.84,97.52 167.33,97.03 168.3,97.03 168.58,96.75 168.58,94.18 168.59,94.17 168.59,93.98 168.32,93.71
GND on TOP: 144.73,74.77 143.84,74.77 143.34,74.28 143.34,70.04 143.86,69.52 144.83,69.52 144.95,69.64 144.95,74.56
GND on TOP: 165.38,81.08 165.24,80.93 165.24,80 164.69,79.45 163.57,79.45 163.44,79.58 163.44,79.61 163.42,79.61 163.16,79.86 163.16,81.76 163.1,81.82 162.61,81.82 162.54,81.88 162.54,82.28 162.57,82.31 163.04,82.31 163.16,82.42 163.16,83.44 163.05,83.55 162.58,83.55 162.47,83.65 162.47,84.58 162.51,84.61 163.11,84.61 163.11,87.03 163.21,87.13 163.5,87.13 163.66,86.97 164.06,86.97 164.21,87.12 164.21,87.57 164.32,87.67 164.57,87.67 164.68,87.56 164.68,87.36 164.99,87.05 165,87.04 165.16,86.88 165.16,84.68 165.22,84.62 165.39,84.62 165.57,84.45 165.57,82.7 165.58,82.69 165.38,82.5
GND on TOP: 30.2,26.28 30.2,25.35 30.05,25.2 29.43,25.2 29.29,25.34 29.29,26.92 29.36,27 30.22,27 30.22,27 30.36,27 30.38,26.97 30.38,26.47
GND on TOP: 209.36,119.44 213.3,119.44 213.62,119.76 215.27,119.76 215.52,120.02 215.52,121.03 215.35,121.2 207.94,121.2 207.77,121.03 207.77,120.27 207.9,120.14 208.66,120.14
GND on TOP: 126.85,117.97 126.52,117.64 126.52,117.04 126.35,116.88 124.61,116.88 124.46,117.03 124.46,120.58 124.92,121.04 136.9,121.04 137.03,120.91 137.03,118.26 136.74,117.97
GND on TOP: 175.36,22.19 175.72,22.19 176.95,20.96 177.87,20.96 178,20.83 178,20.14 177.84,19.98 173.54,19.98 173.42,20.1 173.42,20.57 173.71,20.87 174.34,20.87 175.19,21.72 175.19,22.03
GND on TOP: 177.82,119.25 177.82,118.36 178.12,118.06 180.97,118.06 181.21,118.31 181.21,118.74 181.88,119.41 183.14,119.41 183.4,119.66 183.4,120.92 183.13,121.19 175.85,121.19 175.46,120.8 175.46,119.73 175.58,119.61 177.46,119.61
GND on TOP: 171.12,19.77 171.57,19.77 171.61,19.73 171.61,18.98 171.75,18.84 171.75,18.42 171.98,18.19 171.98,11.65 172.01,11.62 172.01,9.17 172.04,9.14 172.04,8.58 171.99,8.53 170.92,8.53 170.78,8.67 170.78,10.99 171.59,11.8 171.59,18 171.05,18.54 171.05,19.7
GND on TOP: 150.88,67.11 151.4,66.6 151.4,65.04 151.03,64.67 150.37,64.67 150.28,64.76 150.28,67.04 150.35,67.11
GND on TOP: 157.07,76.09 159.38,76.09 160.75,74.71 160.75,73.61 160.81,73.55 160.81,71.92 160.74,71.84 160.74,70.69 160.81,70.62 160.81,68.92 160.79,68.91 160.79,68.63 160.25,68.08 159.56,68.08 159.46,68.18 159.46,68.99 159.9,69.42 159.9,73.13 159.64,73.38 159.01,73.38 159,73.4 158.39,73.4 158.04,73.75 158.04,74.56 157.82,74.78 157.05,74.78 156.92,74.91 156.92,75.94
GND on TOP: 208.01,33.21 204.42,33.21 203.84,32.63 203.84,29.15 204.2,28.78 208.15,28.78 208.32,28.94 208.32,32.91
GND on TOP: 195.87,107.55 196.04,107.39 196.04,106.42 195.74,106.12 193.06,106.12 192.74,105.79 192.74,104.61 192.91,104.43 192.91,103.63 192.9,103.62 192.91,103.61 192.91,102.87 192.9,102.76 192.91,102.66 192.91,102.23 192.9,102.13 192.91,102.03 192.91,101.6 192.9,101.49 192.91,101.39 192.91,101.24 192.74,101.07 191.54,101.07 191.29,101.32 191.29,105.2 190.95,105.54 189.1,105.54 188.91,105.35 185.26,105.35 185.26,105.35 185.03,105.59 185.03,109.87 184.66,110.24 184.66,110.87 184.79,111 186.48,111 187.62,109.86 191.01,109.86 191.26,110.11 191.26,113.03 191.45,113.22 194.37,113.22 194.37,111.7 195.06,111.02 195.06,107.7 195.2,107.55
GND on TOP: 325.58,51.18 325.25,51.18 325.15,51.08 325.15,49.61 325.48,49.28 325.98,49.28 326.06,49.35 326.06,50.29 325.71,50.65 325.71,51.06
GND on TOP: 183.94,11.96 179.79,11.96 179.59,11.76 179.59,11.1 179.32,10.83 178.49,10.83 178.32,10.99 178.32,11.69 179.36,12.73 179.36,13.57 179.48,13.69 182.14,13.69 182.46,14.01 184.07,14.01 184.24,13.84 184.24,12.27
GND on TOP: 207.84,61.47 207.76,61.55 207.76,62.27 207.76,62.45 207.8,62.49 207.8,62.87 207.81,62.91 207.8,62.95 207.8,63.63 207.84,63.67 207.84,63.77 207.85,63.87 207.84,63.98 207.84,64.64 207.96,64.77 208.66,64.77 208.92,65.03 208.92,65.85 209.08,66.02 209.08,66.89 209.12,66.93 209.61,66.93 210.19,67.5 210.44,67.5 210.57,67.37 210.57,66.23 210.76,66.04 211.32,66.04 211.53,65.84 211.88,65.84 212.09,66.05 214.08,66.05 214.14,66 214.14,65.47 213.96,65.29 213.96,64.47 213.74,64.25 213.23,64.25 212.97,64.52 210.55,64.52 210.24,64.2 210.24,63.68 208.73,62.17 208.73,62.14 208.49,61.91 208.49,61.51 208.45,61.47 208.09,61.47 208.09,61.47
GND on TOP: 12.55,28.73 14.73,28.73 14.94,28.53 14.94,27.81 14.83,27.71 14.3,27.71 13.72,27.13 12.5,27.13 12.27,27.36 12.27,28.45
