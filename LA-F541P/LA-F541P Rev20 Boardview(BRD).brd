# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ISEN2_GT: length 13.1
  TOP w0.14: v2(107.44,104.63) 107.44,105.12 v5(107.29,105.27)
  TOP w0.203: PC1122.2 112.13,102.99 112.13,103.57 113.55,104.99 PU1100.10
  TOP w0.254: PC1122.2 111.63,101.78 v2(111.82,101.59)
  IN1 w0.254: v2(107.44,104.63) 107.44,104.53 107.19,104.28 107.19,103.81 107.72,103.28 110.14,103.28 v2(111.82,101.59)
  BOTTOM w0.254: PR1306.2 107.19,104.28 107.44,104.53 v2(107.44,104.63)
ISEN2_VCORE: length 19.9
  TOP w0.203: PU1100.22 118.47,102.85 v1(119.24,102.08) 119.24,101.8 v2(119.44,101.6)
  TOP w0.254: v2(124.11,98.62) 124.11,100.01 v2(124.14,100.04) 124.61,100.52 124.61,101.72 126.05,103.15 127.99,103.15 128.4,103.56 v2(128.4,103.8) ; v2(119.44,101.6) 119.44,101.02 PC1123.1
  IN2 w0.254: v2(119.44,101.6) 119.69,101.36 122.49,101.36 123.8,100.04 v2(124.14,100.04)
  BOTTOM w0.254: v2(124.11,98.62) 124.51,98.62 124.75,98.38 PR1217.2 ; PR1205.2 128.4,103.47 v2(128.4,103.8) ; PR1212.2 124.59,100.04 v2(124.14,100.04)
ISEN3_VCORE: length 13.9
  TOP w0.203: PU1100.23 118.87,102.9 119.25,102.52 120.08,102.52 v1(120.57,102.02) 120.57,101.72 120.41,101.55 120.41,101.08 120.4,101.07
  TOP w0.254: v2(124.09,100.69) 123.71,101.07 120.4,101.07 PC1120.1
  BOTTOM w0.254: PR1215.2 124.28,100.69 v2(124.09,100.69) 123.61,100.2 123.61,99.62 123.91,99.32 PR1213.2 125.45,98.68 125.93,98.68 126.37,98.24 PR1209.2
IST_TRIG_T: length 1.5
  TOP w0.089: v2(176.16,60.86) 175.97,60.67 T40.1
  BOTTOM w0.076: UH1.E3 175.61,61.41 v2(176.16,60.86)
ISUMN_GT: length 40.5
  TOP w0.14: v2(119.64,85.6) 119.67,85.57 v5(119.67,84.84)
  TOP w0.254: PC1125.1 PC1112.2 ; PC1125.1 110.1,103.44 109.98,103.33 PR1302.1 PR1304.2 ; PC1125.1 PC1122.1 110.72,101.93 v2(111.11,101.54)
  IN3 w0.254: v2(119.64,85.6) 119.76,85.73 121.02,85.73 122.09,86.79 122.09,97.73 121.59,98.22 119.76,98.22 119.43,98.55 115.83,98.55 115.32,98.05 114.36,98.05 113.48,98.93 112.6,98.93 111.53,100 111.53,101.12 v2(111.11,101.54)
  BOTTOM w0.254: PH1102.2 119.99,85.6 v2(119.64,85.6) ; PC1133.2 110.22,104.46 PR1127.1 ; PC1133.2 PR1123.2 111.13,102.5 PC1119.1 v2(111.11,101.54) ; PC1133.2 PR1130.1
ISUMN_SA: length 38.6
  TOP w0.254: PC1110.1 PR1117.1 124.83,109.41 124.23,109.41 v2(124.14,109.5) 124.05,109.41 PR1115.2
  IN1 w0.254: v2(124.14,109.5) 124.14,109.41 123.57,108.84 123.57,102.87 121.67,100.97 121.67,93.1 121.06,92.49 119.05,92.49 118.38,91.82 115.95,91.82 115.63,92.14 v2(115.63,92.88)
  IN6 w0.254: v2(115.63,92.88) 115.63,92.43 113.18,89.98 v2(111.1,89.98)
  BOTTOM w0.14: v1(124.73,109.41) 124.23,109.41 v2(124.14,109.5)
  BOTTOM w0.254: PC1111.1 PC1136.1 ; PC1111.1 124.03,109.53 124.05,109.5 v2(124.14,109.5) ; PC1111.1 PR1120.1 ; v2(111.1,89.98) 111.1,89.51 111.34,89.27 PL1306.3 ; PH1101.1 115.43,92.67 v2(115.63,92.88)
ISUMN_VCORE: length 63.5
  TOP w0.14: PC1127.1 120.52,98.68 v1(120.63,98.78)
  TOP w0.254: PC1127.1 PC1126.1 118.49,98.87 v2(118.49,99.44) PC1124.2 PC1123.2 120.29,100.05 PC1120.2
  IN1 w0.254: v2(126.7,102.38) 124.98,102.38 123.25,100.65 123.25,96.55 123.71,96.09 126.39,96.09 126.71,96.41 v2(126.71,96.58)
  IN2 w0.254: v2(118.49,99.44) 118.49,100.15 119.34,101 122.34,101 123,100.34 123,98.2 123.67,97.52 124.51,97.52 125.93,98.94 125.93,99.23 126.18,99.48 126.67,99.48 v2(126.71,99.52) 127.13,99.52 127.76,100.15 127.76,101.31 v2(126.7,102.38) 126.9,102.58 129.18,102.58 130.35,101.41 131.5,101.41 133.92,98.99 136.97,98.99 137.27,99.29 142.59,99.29 145.04,101.73 v2(145.67,101.73)
  BOTTOM w0.254: v2(126.71,99.52) 127.18,99.52 PR1203.1 ; v2(126.7,102.38) 126.7,101.77 126.99,101.47 PR1207.1 ; v2(145.67,101.73) 145.73,101.79 PH1103.1 ; PR1211.1 127.14,97.33 126.71,96.91 v2(126.71,96.58) ; PC1124.2 v2(118.49,99.44) 118.37,99.2 118.11,98.93 PR1135.2 118.12,98.64 PC1135.1 119.72,98.64 PR1134.1
ISUMP_GT: length 44.7
  TOP w0.14: v5(105.33,105.14) 105.33,104.47 105.92,103.89
  TOP w0.203: v2(112.14,105.16) 112.14,105.53 112.49,105.87 112.72,105.87 113.03,106.19 PU1100.7
  TOP w0.254: PC1112.1 112.14,104.97 v2(112.14,105.16) ; 105.92,103.89 107.89,103.89 v2(108.14,104.14)
  IN1 w0.254: v2(112.14,105.16) 109.16,105.16 v2(108.14,104.14)
  IN3 w0.254: v2(119.64,86.4) 119.8,86.23 120.89,86.23 121.62,86.96 121.62,97.46 121.29,97.79 119.69,97.79 119.28,98.2 115.98,98.2 115.43,97.65 114.26,97.65 113.33,98.58 112.45,98.58 111.14,99.9 111.14,100.72 110.56,101.31 110.56,101.98 108.4,104.14 v2(108.14,104.14)
  BOTTOM w0.254: PR1122.1 120.16,86.93 v2(119.64,86.4) ; v2(112.14,105.16) 112.04,105.06 PC1133.1 PR1123.1
ISUMP_SA: length 31.1
  TOP w0.203: PU1100.32 121.01,106.99 v2(121.11,106.88)
  TOP w0.254: v2(125.75,105.36) 125.99,105.6 PR1309.2
  IN1 w0.254: v2(115.67,93.63) 115.69,93.64 117.65,93.64 119.9,95.89 119.9,96.51 120.09,96.7 120.09,102.27 119.94,102.42 119.94,103.9 120.17,104.13 120.17,105.75 121.11,106.69 v2(121.11,106.88)
  IN3 w0.254: v2(125.75,105.36) 125.75,104.75 125.29,104.29 123.57,104.29 122.31,105.55 122.31,105.68 v2(121.11,106.88)
  BOTTOM w0.14: v1(122.49,111.53) PR1120.2
  BOTTOM w0.254: PR1121.2 115.6,93.55 v2(115.67,93.63) ; PR1120.2 PC1111.2 PC1136.2 122.49,108.48 121.11,107.1 v2(121.11,106.88)
ISUMP_VCORE: length 61.6
  TOP w0.203: v2(117.4,102.21) 117.27,102.34 PU1100.19
  TOP w0.254: PC1127.2 119.6,97.77 118.82,96.99 v2(118.78,96.99)
  IN2 w0.254: v2(117.4,102.21) 117.87,102.68 119.66,102.68 120.26,102.08 123.18,102.08 124.03,102.93 129.32,102.93 130.5,101.76 131.65,101.76 134.07,99.34 136.82,99.34 137.12,99.64 142.32,99.64 145.04,102.36 v2(145.67,102.36)
  BOTTOM w0.254: v2(118.78,96.99) 118.79,96.99 118.79,97.02 118.78,97.03 118.78,97.52 PC1135.2 119.72,97.73 PR1134.2 120.4,98.4 120.4,101.58 119.97,102.01 ; PR1136.2 146.03,102.72 v2(145.67,102.36) ; v2(117.4,102.21) 119.76,102.21 119.97,102.01 ; 119.97,102.01 123.01,102.01 124.6,103.59 125.81,103.59 126.01,103.39 126.56,103.39 127.45,104.28 128.6,104.28 129.95,102.93 129.95,101.65 PR1206.2 130.59,101 PR1202.2 130.38,99.53 PR1210.2
JTAG_CLK: length 36.5
  TOP w0.14: v2(295.36,16.57) UE3.C8 ; RP20.3 309.5,29.41 310.27,30.18 v2(310.95,30.18) 311.02,30.18 311.49,30.65 311.49,31.05 v5(311.07,31.47)
  IN3 w0.076: v2(295.36,16.57) 295.95,15.98 297.82,15.98 298.46,16.61 298.46,17.58 298.78,17.91 298.78,19.12 299.04,19.38 299.04,19.69
  IN3 w0.091: 299.04,19.69 299.04,20.15 299.49,20.6 299.71,20.6 299.95,20.83 299.95,21.05 300.67,21.78 303.31,21.78 303.76,21.34 304.19,21.34 304.42,21.57 305.84,21.57 306.08,21.8 306.08,21.8 307.02,22.75 307.02,26.69 308.04,27.71 308.24,27.71 309.08,28.55 309.08,29.65 308.62,30.11 308.62,30.71 309.49,31.58 310.34,31.58 310.47,31.45 310.47,30.66 v2(310.95,30.18)
  BOTTOM w0.14: v2(310.95,30.18) 311.2,30.18 311.52,30.49 JDEG1.4
JTAG_RST#: length 13.1
  TOP w0.14: UE3.G13 299.02,20.23 299.02,21.33 299.47,21.78 299.47,22.45 CE44.1 RE61.1 299.2,23.64 299.2,24.65 v2(299.01,24.84) 299.01,25.63 RE59.2 299.16,26.24 298.84,26.56 v1(298.84,26.8)
  IN6 w0.099: v2(299.01,24.84) 299.34,24.84 300.43,25.92 302.13,25.92 302.42,26.21 v2(302.42,26.98)
  BOTTOM w0.14: v2(302.42,26.98) 302.32,26.88 302.32,26.25 JTAG1.1
JTAG_TDI: length 37.3
  TOP w0.14: v2(296.96,17.37) UE3.E9 ; v5(312.79,31.1) 312.34,30.66 v2(312.34,30.56) 312.34,29.68 311.56,28.9 RP20.1
  IN3 w0.076: 298.25,19.69 298.25,18.51 297.11,17.37 v2(296.96,17.37)
  IN3 w0.091: v2(312.34,30.56) 312.34,31.06 311.35,32.05 309.26,32.05 307.57,30.36 307.57,29.63 306.48,28.55 306.48,26.07 305.43,25.02 303.67,25.02 302.86,24.21 302.86,23.73 303.09,23.51 305.2,23.51 305.59,23.12 305.59,22.71 305.35,22.48 304.3,22.48 304.21,22.57 300.16,22.57 298.25,20.66 298.25,19.69
  BOTTOM w0.14: v2(312.34,30.56) 312.52,30.73 JDEG1.2
JTAG_TDO: length 30.5
  TOP w0.14: RP20.4 309,29.65 v5(309.68,30.32) 310.19,30.83 v2(311.05,30.83) ; v2(297.76,14.17) UE3.F6
  IN3 w0.076: v2(297.76,14.17) 298.81,15.22 298.81,17.37 299.23,17.79 299.51,17.79 299.77,18.05 299.77,18.37 299.77,18.37 299.77,19.13 300,19.36 300.52,19.36 300.85,19.69
  IN3 w0.091: 300.85,19.69 301.5,20.34 302.08,20.34 302.36,20.07 303.86,20.07 304.7,20.9 306.12,20.9 307.8,22.58 307.8,22.74 307.8,25.93 309.93,28.05 309.93,28.22 311.46,29.74 311.46,30.43 v2(311.05,30.83)
  BOTTOM w0.14: JDEG1.5 311.02,30.87 v2(311.05,30.83)
JTAG_TMS: length 33.3
  TOP w0.14: v2(296.16,13.37) UE3.C5 ; RP20.2 310,29.17 310.29,29.45 311.53,29.45 v5(311.66,29.58) 311.88,29.8 v2(311.88,30.1)
  IN3 w0.076: 301.12,19.69 300.57,19.13 300.57,14.02 300.32,13.77 299.14,13.77 299.06,13.86 298.07,13.86 297.99,13.77 296.56,13.77 v2(296.16,13.37)
  IN3 w0.091: 301.12,19.69 301.58,20.15 302,20.15 302.27,19.87 304.01,19.87 304.85,20.71 306.2,20.71 308.33,22.84 308.53,22.84 309.54,23.84 309.54,25.84 310.44,26.75 310.44,28.3 311.88,29.74 v2(311.88,30.1)
  BOTTOM w0.14: JDEG1.3 312.02,31.53 311.88,31.39 v2(311.88,30.1)
KB_DET#: length 110.7
  TOP w0.14: v2(69.11,5.93) 69.07,5.97 66.93,5.97 RH557.1 ; v2(150.9,11.74) v5(151.49,11.74)
  IN3 w0.089: 101.98,9.84 100.33,8.19 99.64,8.19 99.46,8.01 98.4,8.01 97.67,8.74 95.86,8.74 95.52,8.4 92.09,8.4 v2(91.81,8.11) 91.8,8.11 90.39,9.53 89.6,9.53 89.37,9.76 87.89,9.76 86.23,8.1 85.4,8.1 84.8,7.5 84.8,7 84.35,6.56 83.48,6.56 83.16,6.87 83.16,7.4 83.97,8.21 83.97,9.15 83.66,9.46 83.14,9.46 82.82,9.78 81.41,9.78 81.12,9.49 80.56,9.49 80.2,9.12 79.78,9.12 79.53,9.37 79.2,9.37 79,9.17 78.13,9.17 77.78,8.81 77.06,8.81 76.33,8.08 73.33,8.08 73.28,8.03
  IN3 w0.091: v2(69.11,5.93) 69.11,5.94 69.49,6.32 70.69,6.32 71.81,7.43 72.69,7.43 73.28,8.03 ; 101.98,9.84 102.97,10.83 104.62,10.83 104.9,11.11 108.48,11.11 109.5,10.1 112.06,10.1 112.34,10.37 117.63,10.37 117.94,10.69 117.94,12.02 119.52,13.6 134.68,13.6 135.59,12.7 137.67,12.7 138.43,11.94 138.88,11.94 139.32,11.49 140.08,11.49 140.56,11.97 141.13,11.97 141.29,11.81 148.54,11.81 148.87,12.14 150.65,12.14 150.9,11.89 v2(150.9,11.74)
  BOTTOM w0.089: v2(91.81,8.11) 91.81,8.12 UH2.AW15
  BOTTOM w0.14: v2(150.9,11.74) 151.4,12.24 158.05,12.24 158.63,11.66 160.9,11.66 161.3,11.26 JKB.5
LAN_WAKE#: length 248.8
  TOP w0.076: v2(302.87,10.04) 302.67,10.24 302.67,11.65 UE3.L3
  TOP w0.089: v1(77.74,4.53) 77.17,3.97 v2(77.17,3.91) 77.03,3.76 RH545.1
  IN3 w0.089: v2(77.17,3.91) 77.46,4.19 78.62,4.19 79.69,5.27 84.23,5.27 84.39,5.42 85.54,5.42 85.79,5.17 87.66,5.17 87.88,4.95 89.46,4.95 90.09,5.58 91.11,5.58 91.4,5.28 93.76,5.28 94.56,4.49 97.56,4.49 98.19,5.13 98.79,5.13 99.28,5.61 101.76,5.61 101.98,5.83
  IN3 w0.091: v2(280.09,7.6) 274.43,7.6 272.87,6.05 267.63,6.05 267.31,6.37 262.91,6.37 262.03,5.48 260.07,5.48 259.69,5.86 252.89,5.86 251.63,7.11 239.14,7.11 238.13,6.1 214.63,6.1 211.85,8.88 205.9,8.88 204.57,7.55 202.68,7.55 201.83,6.7 197.92,6.7 196.9,5.68 188.33,5.68 187.82,6.19 182.31,6.19 182.03,5.91 179.41,5.91 178.22,7.1 171.16,7.1 170.55,6.5 163.59,6.5 162.79,7.3 161.46,7.3 160.63,6.47 156.57,6.47 156.22,6.82 151.52,6.82 150.71,7.63 150.18,7.63 149.49,8.31 147.89,8.31 147.6,8.02 146.69,8.02 145.42,9.29 141.7,9.29 140.87,8.46 136.63,8.46 136.33,8.76 133.77,8.76 133.29,9.24 130.49,9.24 128.72,11.01 126.7,11.01 126.33,10.64 123.28,10.64 122.16,9.52 121.18,9.52 117.96,6.29 117.17,6.29 116.76,5.89 116.76,5 116.22,4.46 111.75,4.46 111.28,4.93 107.01,4.93 106.8,5.14 104.18,5.14 103.27,6.05 102.2,6.05 101.98,5.83
  IN6 w0.099: v2(302.87,10.04) 302.83,10.08 300.59,10.08 299.5,8.99 298.4,8.99 297.23,7.82 290.97,7.82 289.98,6.83 288.44,6.83 286.82,8.45 285.93,8.45 285.45,7.97 280.46,7.97 v2(280.09,7.6)
  BOTTOM w0.089: UH2.BG44 v2(77.17,3.91)
LCD_BL_PWM: length 29
  TOP w0.14: v2(196.78,56.14) 196.78,55.7 196.9,55.58 198.65,55.58 199.01,55.22 v1(199.01,54.24) 199.01,54.23 198.48,53.7 RV1841.1 RV1834.1
  IN6 w0.099: v2(196.78,56.14) 197.42,56.78 197.42,60.36 198.1,61.04 198.59,61.04 199.36,61.81 203.47,61.81 203.77,62.12 205.34,62.12 205.66,61.8 207.63,61.8 208.28,62.45 208.28,63.78 209.17,64.67 v2(209.17,64.77)
  BOTTOM w0.14: UV18.N8 212.07,64.3 211.03,65.34 209.74,65.34 v2(209.17,64.77)
LCD_BLEN: length 14.9
  TOP w0.14: v2(211.6,48.79) 212.14,48.25 RV1838.1 ; v2(212.51,60.6) 212.89,60.22 v1(212.89,60.15)
  IN1 w0.099: v2(212.51,60.6) 212.05,60.14 212.05,58.76 212.87,57.95 212.87,51.76 211.6,50.5 v2(211.6,48.79)
  BOTTOM w0.14: v2(212.51,60.6) 212.55,60.6 212.94,60.99 UV18.M4
LCD_DBC: length 42.4
  TOP w0.14: v1(67.63,33.39) 67.06,33.96 RV1843.1 66.77,33.76 66.53,33.52 60.78,33.52 v6(59.9,32.64)
  IN1 w0.099: v2(60.71,26.81) 60.71,31.82 v6(59.9,32.64)
  BOTTOM w0.089: 73.28,11.76 73.93,11.11 74.93,11.11 75.07,10.97 UH2.AP48
  BOTTOM w0.14: 73.28,11.76 72.91,12.13 72.26,12.13 72.07,12.32 71.38,12.32 70.74,12.96 68.33,12.96 RH528.1 67.82,12.47 67.16,13.13 67.16,13.41 RH527.1 66.04,14.53 66.04,18.2 65.44,18.8 65.44,21.91 64.75,22.61 64.75,23.88 62.77,25.85 61.12,25.85 60.71,26.26 v2(60.71,26.81)
LCD_DBC_R: length 14.4
  TOP w0.14: v1(66.43,34.99) 66.19,34.74 RV1843.2 59.6,33.96 58.43,35.12 55.01,35.12 v2(54.61,35.52)
  BOTTOM w0.14: v2(54.61,35.52) 54.73,35.64 JEDP1.27
LCD_TST: length 314.7
  TOP w0.14: UE3.M2 303.34,10.99 304.06,10.99 304.83,10.22 305.63,10.22 306.2,9.65 307.82,9.65 308.04,9.87 308.04,10.15 v1(308.33,10.44) v2(308.88,10.44) 309.03,10.29 RE32.2
  IN1 w0.099: v6(44.84,19.81) 45.23,20.2 46.55,20.2 47.02,19.73 52.08,19.73 52.98,20.63 54.75,20.63 55.97,19.41 55.97,17.16 57.38,15.75 57.38,14.21 57.95,13.64 59.56,13.64 60.63,12.58 60.63,6.66 61.34,5.94 62.8,5.94 63.21,6.35 65.06,6.35 v2(65.85,5.56)
  IN2 w0.089: 75.06,3.37 75.18,3.25 77.03,3.25 77.53,3.76 77.53,4.01 77.68,4.16 78.55,4.16 79.72,5.33 80.16,5.33 80.26,5.43 85.05,5.43 85.35,5.13 87.68,5.13 87.86,4.94 89.18,4.94 89.89,5.65 90.93,5.65 91.22,5.37 92.85,5.37 93.79,4.42 101.46,4.42 101.86,4.83 101.86,5.35 101.98,5.46
  IN2 w0.099: v2(65.85,5.56) 66.21,5.91 68.25,5.91 68.7,5.47 68.7,5.24 69.37,4.57 73.86,4.57 75.06,3.37 ; v2(113.48,7.48) 112.79,6.78 110.12,6.78 109.35,7.56 105.99,7.56 104.29,5.86 102.38,5.86 101.98,5.46
  IN5 w0.099: v2(113.48,7.48) 114.27,6.69 117.15,6.69 119.6,9.15 131.48,9.15 132.97,7.66 136.45,7.66 136.89,8.1 140.01,8.1 141.06,9.15 145.44,9.15 147.25,7.33 150.96,7.33 151.33,6.96 159.1,6.96 159.65,6.41 170.11,6.41 170.74,7.04 178.22,7.04 178.9,6.35 181.07,6.35 182.06,7.35 193.76,7.35 195.1,8.68 196.64,8.68 199.19,11.23 212.41,11.23 215.58,8.07 234.51,8.07 235.27,8.83 254.67,8.83 254.99,9.14 261.57,9.14 263.13,7.58 268.52,7.58 268.82,7.88 270.44,7.88 271.58,6.73 278.64,6.73 279.92,8.01 280.49,8.01 281.29,7.21 286.42,7.21 287.06,7.85 291.4,7.85 291.96,7.29 294.74,7.29 294.93,7.47 296.63,7.47 296.83,7.67 298.66,7.67 299.25,8.26 304.29,8.26 305.41,9.37 306.61,9.37 306.85,9.6 308.04,9.6 v2(308.88,10.44)
  BOTTOM w0.14: RV110.1 49.15,25.73 49.28,25.6 49.28,21.9 48.54,21.16 46.03,21.16 44.86,19.99 44.86,19.83 v6(44.84,19.81)
LCD_VCC_TEST_EN: length 271.9
  TOP w0.14: v2(292.81,25.17) v1(292.81,24.59) ; DV7.2 68.64,30.54 69.44,31.34 69.44,32.54 v2(71.49,34.59) ; UE3.E1 297.42,10.51 v2(297.42,9.86)
  IN1 w0.099: v2(252.64,29.01) 252.89,28.76 253.56,28.76 257.18,25.15 266.21,25.15 266.7,25.64 268.62,25.64 270.06,24.2 277.46,24.2 277.9,24.64 281.8,24.64 282.43,24 288.12,24 288.77,24.65 291.89,24.65 292,24.54 292.47,24.54 292.81,24.88 v2(292.81,25.17)
  IN2 w0.099: v2(71.49,34.59) 71.61,34.59 72.38,35.36 80.48,35.36 81.47,34.37 82.01,34.37 82.99,35.36 88.51,35.36 91.63,38.47 96.13,38.47 96.3,38.64 100.98,38.64 102.33,37.29 104.22,37.29 107.56,33.94 115.87,33.94 v2(116,33.81)
  IN4 w0.091: v2(252.64,29.01) 251.79,28.15 241,28.15 239.02,26.16 239.02,21.85 238.51,21.34 231.53,21.34 230.39,20.19 203.07,20.19 201.93,21.34 185.29,21.34 184.76,21.87 184.76,25.43 184.28,25.91 184.28,26.35 183.52,27.12 174.64,27.12 173.81,27.94 164.14,27.94 160.35,31.73 117.76,31.73 116,33.48 v2(116,33.81)
  BOTTOM w0.076: 296.17,15.5 296.52,15.15 296.52,14.77 296.71,14.58 297.13,14.58 297.36,14.35 297.36,13.92 297.51,13.77 297.92,13.77 298.15,13.53 298.15,10.63 297.42,9.9 v2(297.42,9.86)
  BOTTOM w0.14: 296.17,15.5 294.85,15.5 293.14,17.21 293.14,19.26 292.41,20 292.41,24.47 292.81,24.88 v2(292.81,25.17)
LCD_VDD: length 8.4
  TOP w0.14: v2(214.18,57.84) v1(214.18,57.02)
  IN3 w0.091: v2(214.18,57.84) 212.92,59.1 212.92,60.98 212.51,61.39 v2(212.51,61.44)
  BOTTOM w0.14: v2(214.18,57.84) 214.8,57.23 214.8,56.99 215.65,56.14 RV1837.1 ; v2(212.51,61.44) 212.87,61.8 UV18.M5
LDO1_CAP: length 5
  BOTTOM w0.203: UA1.44 12.6,41.03 12.98,41.41 12.98,43.09 13.96,44.07 v1(13.97,44.07) 13.97,45.04 CA30.1
LDO2_CAP: length 4.8
  TOP w0.14: CA27.1 2.73,37.72 2.82,37.81 CA26.1 2.82,38.62 v2(2.93,38.74) 3.73,38.74 v1(3.94,38.94)
  BOTTOM w0.14: UA1.22 4.66,39.03 4.62,38.98 4.61,38.98 4.6,38.97 3.16,38.97 v2(2.93,38.74)
LDO3_CAP: length 4.8
  TOP w0.14: v2(3.49,36.7) 3.62,36.7 4.22,36.11 CA130.1 4.53,36.11 4.83,35.82 4.83,35.07 CA77.1
  BOTTOM w0.14: UA1.18 4.38,37.43 v1(3.94,36.98) 3.66,36.7 v2(3.49,36.7)
LDO_3V: length 7.6
  TOP w0.14: v1(131.14,2.48) 131.3,2.32 v2(131.79,2.32)
  TOP w0.254: v2(131.79,2.32) 131.79,2.6 132.22,3.03 PC505.1
  BOTTOM w0.254: PU500.17 131.54,6.45 131.32,6.23 131.32,6.14 ; 131.32,6.14 130.96,5.78 130.96,4.17 131.67,3.46 131.67,2.44 v2(131.79,2.32) ; 131.32,6.14 131.47,6 PU500.16
LDO_IN: length 6.3
  TOP w0.508: v2(73.3,26.57) 73.27,26.6 73.27,26.9 PR276.1
  IN3 w0.508: v2(68.62,24.62) 68.82,24.82 71.4,24.82 73.15,26.57 v2(73.3,26.57)
  vias: v1(65.91,23.61)
LG1_ISL88738: length 8.3
  TOP w0.14: v2(48.18,7.72) 48.26,7.72 48.71,7.28 v1(49.7,7.28)
  TOP w0.203: v2(47.02,12.7) 47.39,12.7 47.51,12.83 PU1900.9
  IN3 w0.508: v2(48.18,7.72) 48.31,7.85 48.31,11.81 47.42,12.7 v2(47.02,12.7)
LG2_ISL88738: length 13.1
  TOP w0.203: v6(45.81,13.3) 45.81,13.48 46.45,14.11 PU1900.7
  IN1 w0.508: v2(52.82,12.88) 51.88,13.82 50.75,13.82 50.31,13.38 46.53,13.38 46.45,13.3 v6(45.81,13.3)
  BOTTOM w0.508: PQ1904.4 50.58,15.11 50.64,15.05 50.65,15.05 v1(51.03,14.67) v2(52.82,12.88)
LG_3V: length 3
  TOP w0.14: v2(338.36,22.63) v1(338.36,23.24)
  IN1 w1.016: 340.55,22.16 338.2,22.16
  vias: v2(337.66,22.63) v2(341.69,22.29) v2(342.2,21.97)
LG_5V: length 12.6
  IN1 w1.016: 340.38,19.56 340.38,18.57 339.24,17.43 333.79,17.43 332.61,18.61
  BOTTOM w0.14: v2(342.1,19.72) 344.77,19.72 v1(344.92,19.57)
  vias: v2(332.19,18.13) v2(332.82,18.13) v2(341.5,19.72)
LID_CL_SIO#: length 46.1
  TOP w0.14: UE3.N11 304.09,18.9 304.65,18.9 304.99,19.24 v2(305.4,19.24) 305.93,19.24 306.19,19.5 CE31.1 RE45.2 RE41.2 306.38,21.26 306.83,21.72 307.6,21.72 308.23,22.35 310.77,22.35 311.15,21.97 313.56,21.97 315.28,23.69 315.28,31.56 314.83,32.01 314.83,38.99 315.22,39.37 316.49,39.37 317.5,38.36 v2(317.5,37.72)
  IN3 w0.091: v2(312.94,16.14) 311.81,17.27 310.26,17.27 309.31,18.23 307.04,18.23 306.02,19.24 v2(305.4,19.24)
  BOTTOM w0.14: R5841.1 319.83,37.89 319.15,37.21 318.01,37.21 v2(317.5,37.72)
LID_FPR#: length 7.1
  BOTTOM w0.14: v1(322.07,37.97) 321.35,37.25 D323.1 ; JFP.3 317.1,35.98 317.95,36.83 320.55,36.83 320.68,36.96 D323.1 ; R5841.2 319.96,37.25 D323.1
LID_SW_IN#: length 130.4
  TOP w0.14: v2(347.28,117.54) 347.59,117.23 CE16.1 348.06,118.86 348.34,119.14 348.34,120.39 349.18,121.23 UE2.3 ; RE45.1 307.55,20.32 307.95,19.93 v2(308.1,19.93) 308.1,19.58 v5(308.28,19.39)
  IN6 w0.099: v2(347.28,117.54) 347.28,117.53 346.46,117.53 343.9,114.97 343.9,106.36 343.01,105.47 343.01,103.81 344.15,102.67 344.15,97.71 341.13,94.68 339.89,94.68 336.22,91.01 336.22,89.57 335.5,88.85 335.5,87.34 333.5,85.35 333.5,82.09 333.2,81.79 333.2,71.35 331.28,69.43 331.28,65.98 331.95,65.3 331.95,63.5 332.71,62.75 332.71,58.16 330.65,56.11 330.65,50.74 329.54,49.62 329.54,43.91 328.48,42.84 328.48,39.94 326.09,37.55 320,37.55 315.98,33.53 314.53,33.53 313.08,32.08 313.08,30.42 312.1,29.44 311.73,29.44 310.08,27.79 310.08,26.52 309.71,26.15 309.71,20.09 309.15,19.53 308.49,19.53 v2(308.1,19.93)
LINE1-VREFO: length 10
  TOP w0.127: DA7.2 15.14,42.66 v1(15.32,42.84)
  TOP w0.508: RA27.1 12.46,41.97 12.96,42.47 DA14.2 DA7.2 14.16,43.24 14.03,43.37 v2(13.97,43.37)
  IN3 w0.508: v2(10.79,44) 12.21,44 12.65,43.56 13.78,43.56 v2(13.97,43.37)
  BOTTOM w0.203: UA1.40 10.44,42.85 10.27,43.02 10.27,43.53 10.75,44 v2(10.79,44)
LINE1_L: length 3.9
  TOP w0.508: CA45.1 8.18,43.75 8.03,43.91 8.03,44.45 v2(7.88,44.6)
  BOTTOM w0.203: v2(7.88,44.6) 8.03,44.45 v1(8.03,44.1) 8.03,43.97 8.44,43.56 UA1.35
LINE1_L_C: length 2.8
  TOP w0.127: CA119.2 8.59,41.5 8.48,41.4 v1(7.62,41.4)
  TOP w0.508: CA119.2 9.01,42.36 RA31.1
LINE1_R: length 4.5
  TOP w0.508: v2(7.38,43.93) 6.92,43.47 6.92,43.05 v1(6.73,42.86) 6.73,42.74 7.11,42.36 CA119.1
  BOTTOM w0.203: UA1.34 8.04,43.53 7.63,43.93 v2(7.38,43.93)
LINE1_R_C: length 1.2
  TOP w0.508: CA45.2 9.48,43.31 9.94,43.77 RA30.1
LPC_PD#: length 2.8
  TOP w0.076: 304.29,12.17 UE3.N3
  TOP w0.14: RE286.1 306.4,11.88 v1(305.41,11.88) 304.88,11.88 304.6,12.17 304.29,12.17
LPS_PROTECT#: length 1.5
  TOP w0.254: PT200.1 24.65,10.48 PR260.2
LX1_ISL88738: length 5.4
  TOP w0.508: 41.66,6.27 41.66,8.64 42.17,9.15 43.12,9.15 PC1913.2
  vias: v1(40.17,3.18) v2(40.72,3.47) v2(40.74,2.85) v2(41.45,5.54) v2(41.42,4.82) v2(41.42,4.12) v2(41.4,3.49) v2(41.43,2.88) v2(42.04,4.83) v2(42.04,4.13) v2(42.03,3.51) v2(42.05,2.89) v2(42.07,5.56)
LX1_NVVDD: length 18.1
  IN6 w0.762: 165.49,112.75 165.49,112.23 166.58,111.14 167.26,111.14 170.14,108.25 170.14,107.85 173.23,104.76 173.23,100.91 173.49,100.66 173.49,99.21 174.11,98.59
  vias: v1(174.91,95.45) v2(166.41,113.08) v2(166.88,113.47) v2(170.51,100.13) v2(170.52,97.53) v2(170.51,96.54) v2(171.58,100.13) v2(171.58,97.53) v2(171.58,96.54) v2(172.65,100.13) v2(172.65,96.55) v2(172.66,97.53) v2(174.37,97.78) v2(174.37,97.2) v2(174.38,96.51) v2(174.38,95.93) v2(175.07,98.35) v2(175.09,97.78) v2(175.09,97.19) v2(175.15,96.51) v2(175.15,95.93) v2(175.62,98.13) v2(175.59,97.5) v2(175.74,96.32) v2(175.88,96.94) v2(176.16,98.35) v2(176.16,97.5)
LX1_NVVDDS: length 13.2
  TOP w0.14: PR1512.1 188.56,101.92 v1(188.37,101.73)
  IN1 w0.762: 190.05,104.22 191.13,105.29 191.13,108.81 189.4,110.53 189.4,111.17 190.72,112.49 190.72,113.79
  vias: v2(189.79,102.93) v2(190.37,102.93) v2(190.68,115.01) v2(191.19,114.68)
LX2_ISL88738: length 6.7
  IN1 w0.508: v2(44.9,13.53) 44.46,13.96 44.46,15.46 44.04,15.88 v2(40.01,15.88)
  vias: v1(37.3,12.05) v2(37.41,16.05) v2(38.01,16.02) v2(38.74,15.88) v2(38.74,15.24) v2(38.74,14.61) v2(38.74,13.97) v2(38.74,13.34) v2(39.37,15.88) v2(39.37,15.24) v2(39.37,14.61) v2(39.37,13.97) v2(39.37,13.34) v2(40.01,15.24) v2(40.01,14.61) v2(40.01,13.97) v2(40.01,13.34) v2(40.58,14.99) v2(40.58,14.35) v2(40.58,13.72)
LX2_NVVDD: length 6.9
  TOP w0.14: v2(175.26,108.71) v1(175.26,108.21)
  IN6 w0.762: 174.17,108.64 172.85,108.64 170.99,110.5 170.99,112.28 170.49,112.78
  vias: v2(169.35,113.6) v2(169.85,113.26) v2(175.26,109.35) v2(177.01,116.07) v2(177.01,115) v2(177.01,113.94) v2(177.04,112.47) v2(177.67,112.47) v2(177.67,111.86) v2(178,116.07) v2(178,115) v2(178,113.94) v2(178.31,112.47) v2(178.31,111.86) v2(178.94,112.47) v2(178.94,111.86) v2(178.99,116.07) v2(178.99,115.01) v2(178.99,113.94) v2(179.58,112.47) v2(179.58,111.86) v2(179.98,116.07) v2(179.98,115) v2(179.98,113.94) v2(180.97,115) v2(180.97,113.93)
LX_0.95V:
  vias: v1(107.21,60.2) v2(105.68,59.84) v2(106.05,60.3) v2(110.62,60.96) v2(111.25,60.96)
LX_1.8VSP: length 0.5
  TOP w0.14: v2(242.57,101.93) v1(242.02,101.93)
  vias: v2(242.57,101.35) v2(243.76,106.88) v2(244.17,106.43)
LX_1V:
  vias: v1(133.27,8.13) v2(130.92,8.32) v2(131.51,8.32) v2(135.28,8.32) v2(135.86,8.32)
LX_1VSP:
  vias: v1(237.62,115.77) v2(233.63,115.89) v2(233.63,115.25) v2(238,115.13) v2(238.63,115.32) v2(243.13,116.36) v2(243.71,116.36)
LX_3V:
  vias: v2(338.94,28.83) v2(338.96,28.17) v2(344.36,24.03) v2(344.36,23.43) v5(339.5,27.28)
LX_5V: length 18.7
  IN1 w1.016: 338.09,9.61 339.39,8.32 345.76,8.32 349.31,11.88 349.31,16.07 348.43,16.96
  vias: v2(337.02,10.29) v2(337.69,10.26) v2(346.65,17.97) v2(347.03,17.53) v5(340.47,11)
M2280_DEVSLP: length 204.1
  TOP w0.14: v2(266.75,11.82) v1(266.75,12.43) 266.75,12.58 RD7.2
  IN2 w0.089: v2(82.28,13.22) 82.77,13.22 83.65,12.35 86.74,12.35 87.22,11.86 88.74,11.86 89.54,12.67 91.52,12.67 91.81,12.38 92.11,12.38 92.99,11.5 94.95,11.5 95.99,10.47 96.91,10.47 97.24,10.13 97.66,10.13 97.84,10.31 97.84,11.18 98.89,12.23 100.97,12.23 101.45,12.71 101.98,12.71
  IN2 w0.099: 101.98,12.71 102.13,12.71 103.4,13.98 104.09,13.98 104.3,14.18 108.76,14.18 108.94,14.36 109.48,14.36 111.97,16.84 113.39,16.84 113.79,17.25 115.33,17.25 115.54,17.45 121.6,17.45 122.01,17.04 128.35,17.04 130.2,15.19 140.75,15.19 142.86,13.08 150.6,13.08 151.85,11.83 154.23,11.83 155.52,10.54 157.23,10.54 157.54,10.24 163.55,10.24 164.14,9.65 169.48,9.65 169.74,9.91 177.8,9.91 178.7,10.81 187.69,10.81 188.47,10.03 210.44,10.03 214.89,5.59 242.23,5.59 244.67,8.02 256.56,8.02 257.67,9.13 261.61,9.13 262.51,10.03 264.97,10.03 v2(266.75,11.82)
  BOTTOM w0.089: v2(82.28,13.22) 82.46,13.4 UH2.AH35
  BOTTOM w0.14: JNGFF2.38 267.17,13.79 267.06,13.68 267.06,12.13 v2(266.75,11.82)
M2280_PCIE_SATA#: length 196
  TOP w0.089: RH508.1 79.63,14.65 v2(79.65,14.63)
  IN2 w0.089: 101.98,13.21 101.92,13.15 101.39,13.15 100.83,12.59 100.54,12.59 100.53,12.59 98.56,12.59 98.19,12.22 96.1,12.22 94.77,13.55 94.77,14.3 93.88,15.19 90.67,15.19 89.87,14.38 89.87,14.01 89.48,13.62 87.41,13.62 86.78,12.98 83.95,12.98 81.94,14.99 80,14.99 v2(79.65,14.63)
  IN2 w0.099: 101.98,13.21 103.15,14.38 103.93,14.38 104.13,14.58 108.59,14.58 108.78,14.76 109.32,14.76 111.8,17.25 113.22,17.25 113.63,17.65 114.99,17.65 115.2,17.87 121.82,17.87 122.24,17.45 128.8,17.45 130.58,15.68 140.9,15.68 142.98,13.59 150.66,13.59 152.01,12.23 155.84,12.23 156.21,11.86 159.67,11.86 160.41,11.11 169.23,11.11 169.93,10.42 177.42,10.42 178.5,11.49 187.9,11.49 188.8,10.59 210.77,10.59 215.27,6.1 242.06,6.1 244.54,8.57 255.1,8.57 v2(255.23,8.71)
  BOTTOM w0.089: UH2.AJ43 78.85,13.5 78.98,13.37 79.46,13.37 79.65,13.56 v2(79.65,14.63)
  BOTTOM w0.14: v2(255.23,8.71) 254.5,7.97 RD58.1
M_CLK_DDR0: length 59.1
  IN6 w0.079: v2(142.3,24.38) 142.09,24.59 141.88,24.59 141.66,24.82 141.66,25.79 141.88,26.01 141.88,28.28 142.05,28.45 142.32,28.45 142.5,28.27 142.5,26.67 142.58,26.6 142.69,26.6 142.82,26.72 142.82,27.34 142.99,27.51 143.33,27.51 143.4,27.59 143.4,27.75 143.33,27.83 142.99,27.83 142.82,28 142.82,28.37 142.29,28.9 142.29,32.3 142.5,32.52 142.74,32.52 142.91,32.35 142.91,30.42 142.99,30.35 143.15,30.35 143.28,30.47 143.28,33.28 154.66,44.66 154.66,46.09 155.48,46.91 155.48,50.41 155.63,50.56 155.63,53.35 155.89,53.61 156.12,53.61 v2(156.29,53.78)
  BOTTOM w0.076: v2(156.29,53.78) 156.45,53.62 157.22,53.62 158.93,55.33 158.93,57.55 159.22,57.83 159.22,59.95 159.33,60.06 159.33,60.4 159.25,60.48 159.11,60.48 159.03,60.41 UH1.AG1
  BOTTOM w0.14: JDIMM1.137 141.37,26.82 141.47,26.72 141.47,24.82 141.78,24.51 142.17,24.51 v2(142.3,24.38)
M_CLK_DDR1: length 56.5
  IN6 w0.079: v2(142.3,21.84) 142.54,21.6 142.69,21.6 143.06,21.97 143.06,26.05 144.04,27.04 144.04,33 152,40.95 155.3,44.25 155.3,45.83 156.58,47.11 156.58,48.67 156.5,48.75 156.38,48.75 156.21,48.92 156.21,49.21 156.38,49.38 156.5,49.38 156.58,49.46 156.58,49.61 156.5,49.69 156.38,49.69 156.21,49.86 156.21,50.18 157.34,51.31 157.34,52.55 157.26,52.63 156.84,52.63 156.67,52.8 156.67,53.09 156.84,53.26 157.26,53.26 157.34,53.33 157.34,53.49 157.26,53.57 156.84,53.57 156.67,53.74 156.67,54.55 156.41,54.81 156.1,54.81 155.73,55.18 155.73,56.65 155.9,56.82 156.18,56.82 156.35,56.65 156.35,55.64 156.43,55.56 156.59,55.56 156.67,55.64 156.67,57.85 156.48,58.04 156.37,58.04 v2(156.14,57.81)
  BOTTOM w0.089: v2(156.14,57.81) 155.9,58.06 155.62,58.06 155.39,58.28 155.39,59.34 156.11,60.05 156.11,60.47 UH1.AK2
  BOTTOM w0.14: JDIMM1.138 141.63,20.44 141.79,20.61 141.79,20.66 141.62,20.84 141.62,21.42 141.87,21.68 142.13,21.68 v2(142.3,21.84)
M_CLK_DDR2: length 97.2
  IN3 w0.081: v2(154.85,65.13) 154.86,65.13 155.23,64.76 155.23,63.83 155.53,63.54 156.27,63.54 156.82,63 156.92,63 157.26,62.65 157.26,62.35 156.44,61.52 156.44,60.56 156.85,60.16 156.85,54.26 157.65,53.46 157.65,53.2 157.37,52.92 157.37,52.58 157.65,52.3 157.65,49.24 166.54,40.35 170.74,40.35 171.74,39.34 193.95,39.34 195.86,37.43 210.55,37.43 217.58,30.4 217.58,24.82 217.79,24.61 218.01,24.61 218.15,24.47 v2(218.15,24.38)
  BOTTOM w0.076: v2(154.85,65.13) 155.17,65.45 UH1.AM9
  BOTTOM w0.14: JDIMM2.137 217.69,27.05 217.39,26.75 217.39,24.85 217.71,24.53 218,24.53 v2(218.15,24.38)
M_CLK_DDR3: length 98.5
  IN3 w0.081: v2(218.15,21.9) 218.37,21.67 218.57,21.67 218.76,21.86 218.76,26.41 218.24,26.93 218.24,30.66 210.82,38.08 196.13,38.08 194.22,39.99 172.02,39.99 171.01,41 166.81,41 158.31,49.5 158.31,49.83 158.48,50.01 158.8,50.01 158.88,50.09 158.88,50.25 158.8,50.33 158.48,50.33 158.31,50.51 158.31,51.39 158.09,51.6 158.09,53.61 157.9,53.81 157.9,59.75 157.32,60.33 157.32,61.41 157.66,61.76 157.66,62.99 156.71,63.95 156.5,63.95 156.17,64.28 156.17,64.62 156.11,64.68 155.97,64.68 v2(155.76,64.47)
  BOTTOM w0.076: v2(155.76,64.47) 155.44,64.15 UH1.AM7
  BOTTOM w0.14: JDIMM2.138 217.93,20.47 218.02,20.56 218.02,20.74 217.7,21.06 217.7,21.45 v2(218.15,21.9)
M_CLK_DDR#0: length 59.1
  IN6 w0.079: v2(156.29,53.15) 156.29,53.31 156.14,53.46 155.95,53.46 155.78,53.29 155.78,50.49 155.68,50.39 155.63,50.34 155.63,46.85 154.81,46.03 154.81,44.59 143.43,33.21 143.43,30.41 143.21,30.19 142.93,30.19 142.76,30.36 142.76,32.28 142.68,32.36 142.57,32.36 142.44,32.24 142.44,28.97 142.97,28.44 142.97,28.06 143.05,27.98 143.39,27.98 143.56,27.81 143.56,27.53 143.39,27.36 143.05,27.36 142.97,27.28 142.97,26.66 142.76,26.44 142.52,26.44 142.35,26.61 142.35,28.21 142.26,28.3 142.12,28.3 142.03,28.22 142.03,25.95 141.81,25.72 141.81,24.88 141.94,24.75 142.15,24.75 142.3,24.9 v2(142.3,25.02)
  BOTTOM w0.076: UH1.AG2 159.03,60.79 159.12,60.7 159.34,60.7 159.55,60.49 159.55,59.97 159.46,59.89 159.46,57.73 159.17,57.45 159.17,55.23 157.32,53.38 156.52,53.38 v2(156.29,53.15)
  BOTTOM w0.14: v2(142.3,25.02) 142.1,24.82 141.91,24.82 141.78,24.95 141.78,26.72 141.88,26.82 JDIMM1.139
M_CLK_DDR#1: length 56.4
  IN6 w0.079: v2(142.3,21.21) 142.3,21.35 142.4,21.45 142.76,21.45 143.21,21.9 143.21,25.99 144.2,26.98 144.2,32.93 152.16,40.89 155.45,44.19 155.45,45.76 156.74,47.05 156.74,48.74 156.57,48.91 156.44,48.91 156.36,48.99 156.36,49.14 156.44,49.22 156.57,49.22 156.74,49.39 156.74,49.68 156.57,49.85 156.44,49.85 156.36,49.92 156.36,50.11 157.49,51.25 157.49,52.62 157.32,52.79 156.9,52.79 156.82,52.87 156.82,53.02 156.9,53.1 157.32,53.1 157.49,53.27 157.49,53.56 157.32,53.73 156.9,53.73 156.82,53.8 156.82,54.62 156.47,54.97 156.16,54.97 155.88,55.25 155.88,56.59 155.96,56.66 156.12,56.66 156.2,56.59 156.2,55.57 156.37,55.4 156.65,55.4 156.82,55.57 156.82,57.91 156.54,58.19 156.21,58.19 156.14,58.26 v2(156.14,58.45)
  BOTTOM w0.089: v2(156.14,58.45) 156,58.31 155.72,58.31 155.65,58.38 155.65,59.23 156.26,59.84 156.4,59.84 156.58,59.67 156.73,59.67 156.84,59.78 156.84,60.17 156.78,60.24 156.52,60.24 UH1.AK1
  BOTTOM w0.14: JDIMM1.140 142.12,20.57 142.03,20.66 142.03,20.79 141.87,20.95 141.87,21.24 142,21.37 142.14,21.37 v2(142.3,21.21)
M_CLK_DDR#2: length 97.3
  IN3 w0.081: v2(218.15,25.02) 218.15,24.93 217.98,24.77 217.86,24.77 217.74,24.89 217.74,30.47 210.61,37.59 195.93,37.59 194.02,39.5 171.81,39.5 170.81,40.51 166.61,40.51 157.81,49.3 157.81,52.37 157.53,52.65 157.53,52.85 157.81,53.13 157.81,53.53 157.01,54.33 157.01,60.22 156.6,60.63 156.6,61.46 157.43,62.28 157.43,62.72 156.99,63.16 156.89,63.16 156.34,63.7 155.59,63.7 155.4,63.9 155.4,65.21 v2(154.85,65.76)
  BOTTOM w0.076: v2(154.85,65.76) 154.53,65.45 UH1.AN9
  BOTTOM w0.14: JDIMM2.139 218.19,27.12 217.7,26.63 217.7,24.98 217.84,24.84 217.96,24.84 v2(218.15,25.02)
M_CLK_DDR#3: length 98.4
  IN3 w0.081: v2(218.15,21.26) 218.15,21.42 218.23,21.51 218.64,21.51 218.92,21.79 218.92,26.47 218.4,26.99 218.4,30.73 210.89,38.25 196.2,38.25 194.29,40.16 172.08,40.16 171.08,41.16 166.88,41.16 158.47,49.57 158.47,49.76 158.55,49.84 158.87,49.84 159.05,50.02 159.05,50.32 158.87,50.5 158.55,50.5 158.47,50.58 158.47,51.45 158.26,51.67 158.26,53.68 158.06,53.88 158.06,59.82 157.49,60.4 157.49,61.35 157.83,61.69 157.83,63.06 156.78,64.11 156.57,64.11 156.33,64.35 156.33,64.69 156.18,64.85 155.86,64.85 155.76,64.94 v2(155.76,65.12)
  BOTTOM w0.076: v2(155.76,65.12) 155.44,64.8 UH1.AM8
  BOTTOM w0.14: JDIMM2.140 218.43,20.51 218.34,20.6 218.34,20.85 218.15,21.05 v2(218.15,21.26)
M_ODT0: length 55.9
  IN6 w0.089: v2(159.92,55.24) 159.52,55.24 159.36,55.08 159.36,52.98 161.84,50.5
  IN6 w0.117: v2(149.18,24.75) 149.48,24.75 149.69,24.53 149.69,22.99 149.82,22.86 150.1,22.86 150.23,22.99 150.23,24.82 150.1,24.94 149.83,24.94 149.71,25.07 149.71,25.27 149.83,25.4 149.97,25.4 150.08,25.51 150.08,27.1 150.21,27.22 150.79,27.22 150.92,27.35 150.92,27.57 150.79,27.69 150.21,27.69 150.08,27.82 150.08,28.06 150.21,28.19 150.76,28.19 150.92,28.34 150.92,28.57 150.76,28.72 150.21,28.72 150.08,28.85 150.08,30.23 152.05,32.19 152.05,33.44 160.59,41.98 160.59,43.69 161.84,44.95 161.84,50.5
  BOTTOM w0.076: UH1.AD3 161.32,61.54 161.27,61.48 161.27,59.91 161.53,59.64 161.53,56.86 v2(159.92,55.24)
  BOTTOM w0.221: JDIMM1.155 147.87,26.44 148,26.31 148,26.1 148.15,25.96 148.15,25.41 148.81,24.75 v2(149.18,24.75)
M_ODT1: length 54.9
  IN6 w0.117: v2(150.74,25.98) 150.63,25.98 150.5,26.11 150.5,26.72 150.59,26.8 151.2,26.8 151.34,26.93 151.34,29.03 151.22,29.15 151.02,29.15 150.89,29.28 150.89,29.49 151.02,29.62 151.21,29.62 151.34,29.75 151.34,29.96 151.21,30.09 151.01,30.09 150.88,30.21 150.88,30.43 151.01,30.55 151.22,30.55 151.34,30.67 152.47,31.8 152.47,32.59 152.57,32.69 153.43,32.69 153.56,32.83 153.56,33.05 153.43,33.18 152.91,33.18 152.78,33.31 152.78,33.52 152.91,33.65 153.83,33.65 153.96,33.78 153.96,34.75 161.01,41.8 161.01,43.52 162.27,44.77 162.27,48.4 162.38,48.52 162.87,48.52 162.99,48.64 162.99,48.87 162.87,48.99 162.38,48.99 162.27,49.1 162.27,49.34 162.38,49.45 162.87,49.45 162.99,49.57 162.99,49.8 162.87,49.92 162.38,49.92 162.27,50.04 162.27,51.17 161.75,51.69 161.58,51.69 161.35,51.46 161.18,51.46 161.02,51.63 161.02,51.79 161.25,52.02 161.25,52.19 161.08,52.35 160.92,52.35 160.69,52.12 160.52,52.12 160.36,52.29 160.36,52.45 160.59,52.68 160.59,52.85 160.36,53.08 v2(160.13,53.08)
  BOTTOM w0.076: UH1.AE4 160.62,62.19 160.37,61.94 160.37,60.02 160.48,59.9 160.48,59.24 160.3,59.05 160.3,58.26 159.34,57.3 159.34,53.15 159.49,53 160.05,53 v2(160.13,53.08)
  BOTTOM w0.221: JDIMM1.161 149.37,26.22 149.99,25.6 150.18,25.6 150.57,25.98 v2(150.74,25.98)
M_ODT2: length 99
  IN3 w0.122: v2(160.33,64.5) 160.8,64.03 160.8,61.41 161.9,60.31 161.9,57.35 162.25,57 163.47,57 169.34,51.14 171.01,51.14 175.29,46.86 196.07,46.86 198.68,44.24 201.53,44.24 202.29,45 203.04,45 203.79,44.24 209.44,44.24 210.74,45.53 212.08,45.53 225.71,31.91 225.71,29.27 225.39,28.96 225.39,24.15 v2(226.26,23.29)
  BOTTOM w0.076: v2(160.33,64.5) 159.98,64.15 UH1.AF7
  BOTTOM w0.221: JDIMM2.155 224.18,25.37 v2(226.26,23.29)
M_ODT3: length 101
  IN3 w0.122: v2(226.26,26.34) 227.14,27.22 227.14,31.68 212.43,46.39 201.59,46.39 200.25,47.73 188.53,47.73 188.41,47.85 188.41,48.18 188.28,48.31 188.04,48.31 187.92,48.18 187.92,47.85 187.79,47.73 187.56,47.73 187.44,47.85 187.44,48.21 187.31,48.34 187.08,48.34 186.95,48.21 186.95,47.85 186.82,47.73 186.59,47.73 186.46,47.85 186.46,48.16 186.33,48.29 186.1,48.29 185.97,48.16 185.97,47.85 185.85,47.73 185.62,47.73 185.5,47.85 185.5,48.16 185.37,48.29 185.13,48.29 185.01,48.16 185.01,47.85 184.88,47.73 184.65,47.73 184.52,47.85 184.52,48.16 184.39,48.29 184.16,48.29 184.03,48.16 184.03,47.85 183.91,47.73 183.67,47.73 183.54,47.85 183.54,48.16 183.42,48.29 183.18,48.29 183.06,48.16 183.06,47.85 182.93,47.73 182.7,47.73 182.57,47.85 182.57,48.16 182.44,48.29 182.21,48.29 182.08,48.16 182.08,47.85 181.95,47.73 181.72,47.73 181.59,47.85 181.59,48.16 181.47,48.29 181.23,48.29 181.11,48.16 181.11,47.85 180.98,47.73 180.68,47.73 180.55,47.85 180.55,48.2 180.42,48.32 180.19,48.32 180.06,48.2 180.06,47.85 179.94,47.73 179.7,47.73 179.58,47.85 179.58,48.2 179.45,48.32 179.22,48.32 179.09,48.2 179.09,47.85 178.96,47.73 178.73,47.73 178.6,47.85 178.6,48.2 178.47,48.32 178.24,48.32 178.11,48.2 178.11,47.85 177.99,47.73 177.75,47.73 177.63,47.85 177.63,48.2 177.5,48.32 177.26,48.32 177.14,48.2 177.14,47.85 177.01,47.73 176.78,47.73 176.65,47.85 176.65,48.2 176.52,48.32 176.29,48.32 176.16,48.2 176.16,47.85 176.04,47.73 175.63,47.73 171.37,51.99 169.68,51.99 163.32,58.34 163.32,60.39 162.37,61.34 162.37,62.97 161.57,63.78 161.57,64.02 v2(161.22,64.37)
  BOTTOM w0.076: UH1.AE8 v2(161.22,64.37)
  BOTTOM w0.221: JDIMM2.161 225.67,26.92 v2(226.26,26.34)
ME_EN: length 2.7
  TOP w0.14: RH487.1 115.77,6.4 RH454.1 115.75,6.17 115.83,6.1 115.83,5.23 115.7,5.11 SW4.2
ME_FWP: length 249.4
  TOP w0.14: UE3.G12 299.44,19.85 299.44,20.88 299.47,20.91 v2(299.47,21.02) ; v2(312.55,5.43) 313.05,4.93 v1(313.09,4.93) ; SW4.3 117.29,4.88 v2(117.29,5.53) RH487.2 ; v2(300.6,24.66) 300.36,24.9 RE68.2 RE70.2
  IN2 w0.099: v2(117.29,5.53) 117.29,7.17 119.53,9.42 124.18,9.42 125.52,10.76 130.47,10.76 132.43,8.79 133.61,8.79 134.41,7.99 134.41,7.17 136.27,5.31 139.98,5.31 142.66,7.99 145.61,7.99 147.33,6.26 151.17,6.26 151.95,5.48 155.82,5.48 156.04,5.7 159.88,5.7 160.11,5.93 169.69,5.93 170.81,7.05 175.97,7.05 176.8,7.88 182.14,7.88 184.46,5.56 184.77,5.56 185.11,5.22 185.11,4.88 185.4,4.6 185.97,4.6 187.08,5.72 201.88,5.72 204.67,8.51 209.93,8.51 215.14,3.3 235.71,3.3 236.35,3.94 243.25,3.94 245.75,6.44 261.56,6.44 262.37,7.25 268.47,7.25 268.99,6.73 270.64,6.73 271.27,7.37 279.15,7.37 279.97,6.54 286.66,6.54 287.68,5.51 291.14,5.51 292.41,6.79 298.67,6.79 300.8,4.66 306.87,4.66 307.06,4.47 308.62,4.47 308.81,4.29 309.17,4.29 310.33,5.46 312.52,5.46 v2(312.55,5.43)
  IN5 w0.099: v2(299.47,21.02) 299.54,20.94 299.54,20.93 299.7,20.78 300.58,20.78 300.8,20.56 302.37,20.56 303.82,19.11 303.82,17.62 304.17,17.27 304.7,17.27 305.13,17.7 306.72,17.7 308.29,16.13 308.29,15.43 310.58,13.14 310.58,9.15 312.73,7.01 312.73,5.6 v2(312.55,5.43)
  IN6 w0.099: v2(300.6,24.66) 299.44,23.51 299.44,21.12 299.47,21.1 v2(299.47,21.02)
ME_SUS_PWR_ACK: length 234.9
  TOP w0.076: 294.67,20.83 294.84,20.65 294.84,20.42 294.96,20.31 UE3.B13
  TOP w0.089: RH5873.1 100.15,5.39 v2(100.15,5.05) 100.12,5.05 99.51,4.45 RH506.1
  TOP w0.14: v2(290.37,23) 290.76,22.61 v1(291.77,22.61) 292.38,22.61 292.63,22.35 292.63,21.77 292.95,21.45 294.04,21.45 294.67,20.83
  IN3 w0.089: 101.98,4.69 100.52,4.69 v2(100.15,5.05)
  IN3 w0.091: v2(292.82,5.67) 292.75,5.67 292.32,5.24 287.26,5.24 287.05,5.04 286.94,4.92 274.53,4.92 274.42,5.04 274.35,5.11 273.41,5.11 273.13,4.83 268.03,4.83 267.07,5.79 263.15,5.79 262.25,4.88 259.85,4.88 259.45,5.28 252.62,5.28 251.55,6.35 240.41,6.35 238.63,4.57 214.76,4.57 211.03,8.3 206.14,8.3 204.81,6.97 202.92,6.97 202.07,6.12 198.16,6.12 196.7,4.66 188.53,4.66 187.58,5.61 182.55,5.61 182.27,5.33 179.17,5.33 178.38,6.12 177.17,6.12 176.91,5.87 176.71,5.87 176.49,5.65 175.05,5.65 174.88,5.81 158.07,5.81 157.48,5.22 151.06,5.22 149.9,6.38 149.9,7.09 149.65,7.34 149.25,7.74 148.16,7.74 147.87,7.44 146.39,7.44 145.12,8.71 141.94,8.71 140.1,6.87 140.1,6.29 139.5,5.69 136.49,5.69 136.03,6.15 133.73,6.15 132.17,4.59 132.17,4.34 131.6,3.77 131,3.77 130.54,3.32 125.64,3.32 125.09,3.86 120.42,3.86 119.32,4.96 118.44,4.96 117.55,4.07 111.56,4.07 111.09,4.54 106.73,4.54 106.67,4.59 103.37,4.59 103.21,4.43 102.85,4.43 102.59,4.69 101.98,4.69
  BOTTOM w0.127: v2(290.37,23) 290.37,20.55 291.76,19.16 291.76,16.81 292.25,16.31 292.25,14.58 291.97,14.3 291.97,13.78 292.27,13.49 293.14,13.49 293.98,12.65 293.98,10.46 294.43,10.01 294.43,7.74 292.86,6.17 292.86,5.72 v2(292.82,5.67)
ME_SUS_PWR_ACK_R: length 23.9
  TOP w0.089: v2(99.56,5.07) 99.5,5.07 99.37,5.2 RH5873.2 98.67,5.59 v1(98.49,5.41)
  IN5 w0.089: v2(99.56,5.07) 98.88,5.74 93.94,5.74 93.76,5.93 89.63,5.93 89.2,5.5 86.42,5.5 85.77,6.15 82.34,6.15 81.14,7.35 80.54,7.35 v2(80.32,7.57)
  BOTTOM w0.089: UH2.BC37 81.25,7.05 80.88,7.42 80.47,7.42 v2(80.32,7.57)
MEC_XTAL1: length 6
  TOP w0.076: 292.99,10.57 UE3.A1
  TOP w0.14: 292.99,10.57 292.89,10.57 291.92,9.6 290.75,9.6 CE42.1 289.6,9.84 YE1.1
MEC_XTAL2: length 3.2
  TOP w0.14: RE51.2 291.16,11 290.86,10.7 CE43.1 289.89,10.7 YE1.2
MEC_XTAL2_R: length 3.5
  TOP w0.076: UE3.A3 294.16,11.96 293.24,11.05 292.99,11.05
  TOP w0.14: RE51.1 291.77,10.08 292.74,11.05 292.99,11.05
MEDIACARD_IRQ#: length 292.8
  TOP w0.089: RH546.1 87.76,8.48 v2(87.31,8.03)
  TOP w0.14: v2(342.77,34.42) v1(342.77,33.78)
  IN1 w0.099: v2(342.77,34.42) 342.28,33.92 341.64,33.92 340.46,32.74 330.17,32.74 328.42,31 328.42,27.31 327.92,26.8 324.7,26.8 318.85,20.95 317.83,20.95 314.72,17.84 314.72,16.67 314.02,15.96 314.02,13.06 314.76,12.31 v2(314.76,10.51)
  IN2 w0.089: 101.98,9.8 100.94,8.76 100.94,8.17 99.93,7.16 99.28,7.16 98.76,7.68 96.88,7.68 95.9,6.7 95.3,6.7 94.18,7.82 92.65,7.82 92.58,7.75 91.5,7.75 91.11,8.14 89.7,8.14 89.45,8.39 87.67,8.39 87.31,8.03 v2(87.31,8.03)
  IN2 w0.099: 101.98,9.8 103,10.82 104.08,10.82 105.08,11.82 106.17,11.82 106.74,12.39 109.93,12.39 110.97,13.44 112.11,13.44 113,14.33 113.75,14.33 114.17,14.74 120.24,14.74 121.02,13.96 123.02,13.96 123.78,13.2 136.59,13.2 139.1,10.69 152.41,10.69 155.14,7.95 156.91,7.95 157.79,7.07 159.24,7.07 160.06,7.89 163.77,7.89 164.26,8.38 170.23,8.38 170.51,8.11 175.02,8.11 176.24,9.34 183.49,9.34 184.12,9.97 187.54,9.97 187.99,9.53 210.34,9.53 215.54,4.32 234.7,4.32 235.4,5.02 242.63,5.02 245.16,7.54 257.01,7.54 257.9,8.44 283.14,8.44 283.94,7.64 284.54,7.64 285.49,8.59 286.64,8.59 287.27,7.95 291.61,7.95 291.82,7.74 302.74,7.74 303.58,8.59 303.58,9.92 303.78,10.11 307.36,10.11 307.51,9.97 309.63,9.97 310.41,10.75 314.53,10.75 v2(314.76,10.51)
  BOTTOM w0.089: UH2.BB26 86.67,7.35 87.31,7.99 v2(87.31,8.03)
  BOTTOM w0.14: v2(342.77,34.42) 342.95,34.6 RR10.1
MEM_SMBCLK: length 27.7
  IN3 w0.089: v2(87.18,6.94) 87.32,6.94 87.7,7.32 87.7,8.51 87.87,8.69 89.27,8.69 89.83,8.13 90.65,8.13 91.36,7.42 93.7,7.42 93.8,7.32 94.42,7.32 94.98,6.76 96.01,6.76 96.58,7.33 99.2,7.33 99.39,7.14 100.09,7.14 100.6,7.65 100.69,7.65 101.98,8.94
  IN3 w0.091: 101.98,8.94 102.56,9.52 103.92,9.52 104.56,10.16 105.89,10.16 v2(106.1,10.37)
  BOTTOM w0.089: UH2.BE26 86.74,5.84 86.93,6.03 86.93,6.16 87.18,6.4 v2(87.18,6.94)
  BOTTOM w0.14: QH4.6 108.27,10.81 107.94,11.14 v1(107.49,11.14) 107.32,11.14 107.06,10.88 RH458.2 106.86,10.37 v2(106.1,10.37)
MEM_SMBDATA: length 35
  IN3 w0.089: v2(87.33,7.47) 86.94,7.86 86.94,8.24 87.68,8.98 89.39,8.98 89.95,8.42 90.77,8.42 91.49,7.71 93.82,7.71 93.92,7.61 94.54,7.61 95.1,7.05 95.89,7.05 96.46,7.62 99.32,7.62 99.51,7.43 99.97,7.43 100.48,7.94 100.57,7.94 101.69,9.06 101.69,9.06 101.76,9.13 101.76,9.14 101.98,9.36
  IN3 w0.091: v2(112.57,9.77) 109.25,9.77 108.25,10.77 105.75,10.77 105.43,10.45 104.44,10.45 103.8,9.82 102.44,9.82 101.98,9.36
  BOTTOM w0.089: UH2.BF26 86.72,5.57 87.11,5.96 87.11,6.08 87.54,6.51 87.54,7.26 v2(87.33,7.47)
  BOTTOM w0.14: QH4.3 110.79,9.51 111.02,9.27 RH459.2 111.3,9.58 111.49,9.77 v2(112.57,9.77)
MEM_VDD_CTL: length 138.4
  TOP w0.14: v2(216.03,43.94) 216.03,43.69 214.33,41.99 197.6,41.99 195.16,44.43 195.16,55.72 v2(196.15,56.71) ; v2(187.58,117.73) 187.45,117.6 PR717.1 RV1836.1 186.64,116.66 186.18,116.21 184.02,116.21 v1(183.52,116.71) ; v2(228.99,45.13) RV1086.2
  IN1 w0.099: v2(228.99,45.13) 228.99,44.83 228.44,44.28 216.36,44.28 v2(216.03,43.94)
  IN2 w0.099: v2(200.85,109.77) 199.48,108.39 199.48,105.66 198.72,104.9 198.72,102.52 197.91,101.71 197.91,97.81 196.71,96.6 193.15,96.6 190.51,93.96 190.51,86.18 189.43,85.1 189.43,82.07 195.76,75.74 195.76,71.44 v2(196.65,70.55)
  IN4 w0.091: v2(187.58,117.73) 188.09,118.24 189.36,118.24 190.25,117.35 192.15,117.35 195.4,114.11 195.4,111.13 196.28,110.25 200.37,110.25 v2(200.85,109.77)
  IN4 w0.099: v2(196.15,56.71) 195.96,56.71 195.52,57.15 195.52,57.85 196.15,58.48 196.15,65.41 196.41,65.66 196.41,67.06 196.15,67.31 196.15,70.05 v2(196.65,70.55)
MEM_VREF: length 143.3
  TOP w0.508: QV102.2 243.13,95.12 v1(242.49,95.76) 242.36,95.89 v2(242.36,97.07) ; QV101.2 218.84,107.89 v2(219.37,108.42)
  IN2 w0.508: v2(234.13,50.78) 233.77,50.42 223.72,50.42 219.8,54.34 219.28,54.34 217.4,56.22 v2(214.86,56.22)
  IN6 w0.508: v2(219.37,108.42) 219.37,108.79 220.56,109.98 224.92,109.98 226.85,111.91 238.15,111.91 239.24,110.82 239.24,109.63 240.54,108.33 240.54,107.11 239.75,106.33 239.75,104.73 241.43,103.05 241.43,101.35 242.36,100.41 v2(242.36,97.07) 242.84,96.6 246.66,96.6 248.74,94.51 248.74,93.83 250.96,91.61 250.96,80.02 248.72,77.78 245.9,77.78 244.2,76.07 244.2,71.96 246.76,69.39 249.2,69.39 250.52,68.07 250.52,62.84 249.28,61.6 249.28,60.48 250.47,59.28 250.47,57.51 249.66,56.69 249.66,54.84 247.8,52.99 240.41,52.99 238.2,50.78 v2(234.13,50.78)
  BOTTOM w0.254: UV18.L1 213.74,58.06 213.53,57.85 213.53,55.92 RV567.1
  BOTTOM w0.508: RV567.1 214.34,55.7 v2(214.86,56.22)
MIC1-VREFO_L: length 24.3
  IN3 w0.508: v2(9.92,44.73) 9.92,44.95 10.31,45.34 10.91,45.34 11.39,44.87 13.69,44.87 14.73,45.91 14.73,52.7 13.83,53.6 13.83,56.21 11.32,58.73 v2(11.32,59.12)
  BOTTOM w0.203: UA1.38 9.64,43.76 9.78,43.9 9.78,44.59 v2(9.92,44.73)
  BOTTOM w0.508: RA20.1 v2(11.32,59.12) RA21.1
MIC1-VREFO_R: length 5.3
  TOP w0.127: v1(9.98,46.41) RA19.1
  TOP w0.508: RA19.1 10.01,45.43 RA75.1 10.76,44.92 10.53,44.69 v2(10.53,44.58)
  BOTTOM w0.203: UA1.39 10.04,42.83 9.97,42.9 9.97,43.65 10.1,43.78 10.1,44.26 10.42,44.58 v2(10.53,44.58)
MONO_IN: length 2.4
  BOTTOM w0.14: UA1.23 4.72,39.43 4.52,39.22 4.51,39.22 4.5,39.21 4.05,39.21 3.95,39.31 CA16.2
MONO_IN_R: length 11.4
  TOP w0.14: v2(2.35,38.74) 2.24,38.62 v1(2.24,34.76) CA19.1 RA57.1 RA4.2 RA7.2
  BOTTOM w0.14: CA16.1 2.25,38.84 v2(2.35,38.74)
MSCLK: length 11.7
  TOP w0.14: RE288.2 304.15,29.25 RE299.2 305.13,29.29 306.19,30.35 v3(306.78,30.35) 308.27,30.35 308.57,30.05 308.57,29.41 v2(308.38,29.22) 307.78,29.22 RE63.2
  BOTTOM w0.14: JDEG1.6 310.47,31.82 310.47,30.04 310.01,29.58 308.73,29.58 v2(308.38,29.22)
MSCLK_R: length 17
  TOP w0.076: UE3.H10 299.76,17.75 v2(300.13,17.38)
  TOP w0.14: v2(300.86,28.34) 301.28,28.34 301.42,28.47 301.42,28.78 301.78,29.14 302.28,29.14 RE288.1
  BOTTOM w0.076: v1(299.35,20.13) 298.58,19.35 298.58,17.63 299.24,16.97 299.72,16.97 v2(300.13,17.38)
  BOTTOM w0.14: v1(299.35,20.13) 299.96,20.74 299.96,22.32 299.48,22.8 299.48,27.49 300.11,28.12 300.65,28.12 v2(300.86,28.34)
MSDATA: length 11.5
  TOP w0.14: RE287.2 303.54,28.43 RE27.1 303.94,28.83 305.23,28.83 v3(305.7,29.3) 306.36,29.96 308.05,29.96 v2(308.13,29.88) 307.94,29.69 307.11,29.69 306.83,29.41 RE65.2
  BOTTOM w0.14: v2(308.13,29.88) 308.15,29.88 308.24,29.97 309.85,29.97 310.07,30.2 310.07,31.83 JDEG1.7
MSDATA_R: length 14.4
  TOP w0.076: UE3.G9 298.97,16.97 v2(299.39,17.39)
  TOP w0.14: v2(300.83,27.72) 300.92,27.81 301.52,27.81 301.89,28.19 RE287.1
  BOTTOM w0.076: v2(299.39,17.39) 299.17,17.39 298.91,17.66 298.91,19.22 299.46,19.77 299.5,19.77 299.58,19.85 299.63,19.85 299.91,20.13
  BOTTOM w0.14: v2(300.83,27.72) 300.82,27.73 300.27,27.73 299.87,27.33 299.87,22.96 300.39,22.45 300.39,20.61 299.91,20.13
NB_MUTE#: length 382.8
  TOP w0.14: JAUDIO.4 4.8,12.6 4.5,12.9 3.96,12.9 v2(3.66,13.2) ; UE3.A4 293.96,12.97 v2(293.49,12.5)
  IN3 w0.091: v2(13.27,37.53) 13.27,37.15 11.69,35.56 5.27,35.56 2.6,32.89 2.6,27.76 7.67,22.7 7.67,19.93 5.01,17.27 4.7,17.27 3.81,16.38 3.81,14.67 3.66,14.51 v2(3.66,13.2)
  IN5 w0.089: 73.28,9.74 73.56,10.02 73.76,10.02 74.19,9.58 75.61,9.58 77.42,7.77 78.44,7.77 78.86,8.2 80.03,8.2 80.39,8.55 81.13,8.55 81.85,9.27 83.82,9.27 83.99,9.1 83.99,8.38 83.09,7.47 83.09,6.77 83.36,6.5 84.73,6.5 84.76,6.53 85.89,6.53 86.57,5.86 89.05,5.86 89.48,6.28 94.09,6.28 94.22,6.15 97.48,6.15 97.94,6.62 97.94,7.06 97.35,7.66 96.69,7.66 96.57,7.77 96.57,8.46 96.86,8.75 97.54,8.75 98.32,7.97 98.95,7.97 99.56,7.37 101.37,7.37 101.47,7.47 101.98,7.47
  IN5 w0.099: v2(58.47,13.11) 59.03,12.55 60.43,12.55 60.69,12.29 60.69,11.24 61.01,10.92 62.16,10.92 63.42,9.67 68.13,9.67 68.65,9.15 69.49,9.15 69.8,8.84 69.8,7.98 70.02,7.77 71.33,7.77 71.74,8.17 71.74,8.94 72.4,9.6 73.14,9.6 73.28,9.74 ; v2(293.49,12.5) 293.49,13.08 293.14,13.43 293.14,14.1 292.26,14.98 292.26,15.19 291.3,16.15 290.78,16.15 290.06,15.43 288.07,15.43 287.02,14.38 282.26,14.38 281.65,13.77 278.69,13.77 278.3,13.38 278.3,12.39 277.5,11.58 277.5,10.03 277.12,9.65 275.34,9.65 273.56,11.43 273.08,11.43 272.6,10.95 268.74,10.95 268.68,11.01 266.14,11.01 265.32,11.83 263.33,11.83 262.8,11.31 249.03,11.31 247.08,13.26 226.16,13.26 225.55,13.87 215.08,13.87 214.09,14.86 201.81,14.86 201.81,14.86 186.9,14.86 183.65,11.61 165.12,11.61 164.87,11.36 158.09,11.36 157.1,12.34 149.07,12.34 148.08,11.35 138.04,11.35 137.61,10.92 131.09,10.92 130.24,11.77 125.51,11.77 124.6,10.86 122.68,10.86 122.08,10.25 118.49,10.25 117.51,9.27 115.25,9.27 114.29,8.31 112.41,8.31 111.87,8.84 111.02,8.84 108.6,6.42 105.24,6.42 104.19,7.47 101.98,7.47
  IN6 w0.099: v2(58.47,13.11) 57.97,13.62 56.41,13.62 56.26,13.77 50.95,13.77 50.48,13.3 50.48,9.83 50.29,9.64 50.29,7.94 44.67,2.32 42.44,2.32 41.61,1.49 31.99,1.49 30.15,3.34 30.15,9.71 29.13,10.73 16.85,10.73 15.75,11.83 8.34,11.83 7.57,12.61 7.57,13.32 6.61,14.28 4.73,14.28 v2(3.66,13.2)
  BOTTOM w0.14: v1(2.99,13.27) 3.05,13.2 v2(3.66,13.2) ; RA12.2 14.91,36.77 14.4,37.28 13.94,37.28 RA68.1 13.57,37.23 v2(13.27,37.53) 12.98,37.82 UA1.52
NRB_BIT: length 22.5
  TOP w0.089: v1(101.65,6.78) 101.4,6.53 RH524.2 101.15,5.84 100.64,6.35 100.64,6.44 100.61,6.47 100.61,6.5 v2(100.62,6.52)
  IN1 w0.076: v2(100.62,6.52) 100.61,6.5 100.61,5.92 100.58,5.89 99.24,5.89 98.83,5.47 97,5.47 96.64,5.11 94.42,5.11 94.06,5.47 90.12,5.47 89.06,4.41 87.66,4.41 87.45,4.61 85.45,4.61 84.61,3.77 v2(84.58,3.77)
  BOTTOM w0.089: UH2.BE30 84.88,5.19 84.38,4.69 84.38,4.21 84.58,4.01 v2(84.58,3.77)
NVVDD_EN: length 111.7
  TOP w0.203: U33.18 v1(205.57,54.45) 205.57,55.57 v2(204.22,56.92)
  TOP w0.254: 166.3,115.08 166.3,115.18 167.02,115.9 CV919.1 167.02,116.54 167.24,116.75 QZ15.2 ; 166.3,115.08 165.67,115.71 v2(165.55,115.71) 165.48,115.71 RV1130.1 164.55,114.53 165.7,113.39 DA56.2 ; 166.3,115.08 PC1015.1
  IN3 w0.254: v2(204.22,56.92) 203.73,56.44 201.28,56.44 200.86,56.02 198.88,56.02 195.56,59.34 195.56,61.32 194.93,61.95 192.3,61.95 191.96,62.29 191.96,63.69 186.8,68.85 186.31,68.85 182.97,72.18 182.97,76.77 185.06,78.86 185.06,82.81 183.51,84.36 181.99,84.36 180.86,85.5 180.86,87.39 181.28,87.81 181.28,89.54 180.48,90.35 180.48,93.72 179.91,94.29 177.6,94.29 177.04,93.73 175.44,93.73 175.03,94.14 173.18,94.14 172.14,95.19 172.14,106.38 171.58,106.94 171.58,109.76 173.53,111.71 173.53,113.39 172.31,114.61 172.31,116.28 170.2,118.4 168.23,118.4 v2(165.55,115.71)
  BOTTOM w0.254: PR1004.1 165.43,115.71 v2(165.55,115.71) 165.62,115.71 165.67,115.66 PU1001.3
