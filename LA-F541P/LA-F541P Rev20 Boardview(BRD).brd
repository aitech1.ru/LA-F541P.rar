# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SML1ALERT#: length 5.6
  TOP w0.089: v2(82.78,4.73) 82.79,4.73 83.63,4.73 v1(84.05,4.31) 84.22,4.14 85.08,4.14 85.98,5.04 RH504.2
  BOTTOM w0.089: UH2.BD33 83.23,6.07 82.92,5.75 82.92,5.45 82.75,5.29 82.75,4.75 v2(82.78,4.73)
SNB_0.95V: length 1.6
  TOP w0.14: PR801.2 109.35,64.01 v1(109.92,64.58)
SNB_1.8VSP: length 0.7
  BOTTOM w0.14: 240.65,97.93 v1(239.99,97.93)
SNB_1V: length 0.6
  BOTTOM w0.14: 126.35,1.8 126.35,1.68 v1(126,1.32)
SNB_1VSP: length 1.7
  TOP w0.14: v1(234.98,117.17) 235.27,116.88 PR901.2
SNUB_1.2V: length 1.9
  BOTTOM w0.14: v1(263.65,27.62) 263.97,27.94 PC611.1
SNUB_3V: length 1.5
  TOP w0.14: v1(332.42,34.1) 332.87,33.66 PC414.1
SNUB_5V:
  vias: v1(340.65,17.17)
SNUB_CHG1:
  vias: v1(37.4,6.74)
SNUB_CHG2: length 2
  TOP w0.14: PR1916.2 v5(33.59,16.56)
SP7_SDWP: length 9
  TOP w0.14: v2(343.72,36.45) 346.22,33.95 v1(347.79,33.95) v2(348.24,33.5)
  BOTTOM w0.14: v2(343.72,36.45) 343.72,37.07 343.47,37.31 342.67,37.31 342.59,37.39 UR1.29 ; v2(348.24,33.5) QR1.1
SP7_SDWP_C: length 21.7
  TOP w0.14: v2(347.59,31.6) v5(346.74,32.45) 343.24,35.94 343.19,35.94 340.79,38.34 339.42,38.34 339.22,38.14 338.42,38.14 338.22,38.34 333.29,38.34 331.83,39.8 JCR.11
  BOTTOM w0.14: v2(347.59,31.6) QR1.3
SPK_DET#: length 365.6
  TOP w0.14: RE139.2 310.83,12.07 v2(311.06,12.29) ; JAUDIO.6 5.6,13 v2(6.3,13.7) ; v2(311.76,6.45) v1(312.34,6.45) ; v2(67.44,5.51) 67.44,5.5 67.44,5.31 67.96,4.79 67.96,4.22 67.5,3.76 RH572.1
  IN1 w0.076: v6(82.39,7.45) 82.47,7.37 83.12,7.37 84.31,8.56 84.67,8.56 85.24,7.99 86.48,7.99 87.67,9.18 87.67,9.37 88.08,9.78 89.44,9.78 89.84,9.38 89.84,9.18 89.82,9.15 v2(89.82,9.07)
  IN3 w0.089: 76.8,7.72 73.61,7.72 73.39,7.51 ; 77.46,7.82 77.51,7.78 78.59,7.78 79.1,8.28 79.86,8.28 80.13,8.55 81.78,8.55 82.15,8.18 82.15,7.96 82.33,7.77 82.33,7.51 v6(82.39,7.45)
  IN3 w0.091: 77.46,7.82 76.9,7.82 76.8,7.72 ; 73.39,7.51 72.92,7.04 71.96,7.04 71.56,6.64 71.56,6.31 70.02,4.77 69.19,4.77 68.83,5.13 68.83,5.37 68.21,5.99 67.86,5.99 67.44,5.58 v2(67.44,5.51)
  IN5 w0.089: 101.98,6.94 100.19,6.94 99.18,5.92 94.02,5.92 93.83,6.11 89.55,6.11 89.12,5.68 86.49,5.68 85.84,6.33 83.19,6.33 82.76,6.75 82.76,7.08 v6(82.39,7.45)
  IN5 w0.099: v2(311.76,6.45) 311.73,6.47 307.22,6.47 306.58,7.11 305.56,7.11 304.93,6.48 304.58,6.48 303.95,7.11 299.78,7.11 298.63,5.96 297.36,5.96 297.18,5.78 297.18,5.27 296.52,4.61 289.41,4.61 288.88,5.14 284.83,5.14 284.49,4.79 284.37,4.79 284.37,4.61 284.13,4.37 283.79,4.37 283.56,4.61 283.56,4.79 280.5,4.79 280.35,4.94 275.15,4.94 274.19,5.91 268.68,5.91 268.21,6.37 263.58,6.37 263.07,5.86 258.32,5.86 257.32,6.86 244.72,6.86 243.73,5.87 213.92,5.87 210.57,9.22 205.51,9.22 203.84,7.55 198.15,7.55 195.51,4.91 188.38,4.91 187.42,5.87 182.7,5.87 181.69,4.85 177.83,4.85 177.08,5.6 159.84,5.6 159.49,5.26 156.22,5.26 156,5.48 147.68,5.48 144.98,8.18 142.35,8.18 139.21,5.04 136.91,5.04 135.24,3.37 131.35,3.37 130.73,2.74 126.99,2.74 126.09,3.65 120.59,3.65 117.94,6.29 111.57,6.29 110.53,5.24 105.78,5.24 104.09,6.94 101.98,6.94
  IN6 w0.099: v2(6.3,13.7) 6.9,13.7 7.37,13.23 7.37,12.52 8.26,11.63 15.66,11.63 16.77,10.53 29.05,10.53 29.95,9.63 29.95,3.26 31.91,1.29 41.7,1.29 42.52,2.12 44.27,2.12 45.09,1.29 53.15,1.29 53.41,1.55 53.41,2.13 54.39,3.11 58.96,3.11 59.49,3.64 59.49,4.58 59.18,4.89 59.18,6.33 60.77,7.92 60.77,8.75 61.09,9.07 64.03,9.07 67.44,5.66 v2(67.44,5.51)
  BOTTOM w0.089: v2(89.82,9.07) 89.79,9.11 89.79,9.15 89.72,9.22 UH2.AV21
  BOTTOM w0.14: v2(311.06,12.29) 311.37,12.29 311.76,11.9 v2(311.76,6.45)
SPK_DET#_EC: length 8.3
  TOP w0.076: UE3.N9 303.89,16.83 304.29,16.83
  TOP w0.14: RE139.1 309.35,12.07 308.87,12.55 308.87,13.02 v2(308.89,13.04) ; v2(305.57,16.19) 304.93,16.83 304.29,16.83
  IN2 w0.099: v2(305.57,16.19) 305.57,15.74 307.72,13.59 308.34,13.59 v2(308.89,13.04)
SPKR: length 129.7
  TOP w0.14: v2(3.55,28.41) 3.32,28.41 2.88,27.98 RA7.1 ; v2(68.03,5.45) 68.05,5.42 68.65,5.42 68.92,5.14 68.92,4.71 67.87,3.66 67.87,3.39 67.46,2.99 RH82.2
  IN2 w0.099: v2(68.03,5.45) 68.03,5.42 67.63,5.03 67.41,5.03 65.05,2.67 64.19,2.67 63.99,2.86 62.22,2.86 61.75,3.33 61.55,3.33 61.37,3.51 60.78,3.51 60.44,3.85 60.44,4.45 60.14,4.76 60.14,5.25 60.4,5.51 60.4,12.1 60.37,12.13 60.37,13.88 60.89,14.4 60.89,15.11 58.88,17.12 57.99,17.12 57.67,17.44 57.67,18.62 57.74,18.69 57.74,21.07 56.12,22.69 52.74,22.69 51.72,21.67 51.72,21.19 51.19,20.66 33.57,20.66 33.5,20.73 33.47,20.73 32.18,22.01 32.18,22.05 32.17,22.06 32.17,22.91 29.87,25.21 27.04,25.21 23.68,28.57 20.72,28.57 20.08,29.21 20.08,29.62 19.69,30 18.96,30 18.7,29.74 18.31,29.74 15.34,32.71 15.34,36.29 14.63,37.01 11.55,37.01 10.62,36.07 5.79,36.07 4.62,34.9 4.62,34.34 4.1,33.82 4.1,31.99 4.23,31.87 4.23,31.37 3.91,31.05 3.24,31.05 2.86,30.67 2.86,28.77 3.21,28.41 v2(3.55,28.41)
  IN3 w0.089: v6(83.3,8.32) 83.3,8.19 82.76,7.65 82.76,6.71 82.48,6.43 79.43,6.43 78.25,7.6 77.4,7.6 77.14,7.34 75.59,7.34 75.39,7.54 73.74,7.54 73.55,7.35
  IN3 w0.091: 73.55,7.35 73.02,6.82 72.06,6.82 71.75,6.52 71.75,6.12 70.2,4.58 68.46,4.58 68.45,4.56 68.19,4.56 67.88,4.87 67.88,5.28 68.03,5.42 v2(68.03,5.45)
  BOTTOM w0.089: v6(83.3,8.32) 83.44,8.18 83.86,8.18 84.23,8.55 84.98,8.55 UH2.AW29
  BOTTOM w0.14: v1(3.2,27.99) 3.55,28.34 v2(3.55,28.41)
SRCCLKREQ1#: length 273.1
  TOP w0.14: RT5856.1 306.67,24.73 306.9,24.96 308.29,24.96 v2(308.48,25.15)
  IN2 w0.099: v2(312.85,19.44) 312.85,22.68 312.29,23.24 311.21,23.24 309.31,25.15 v2(308.48,25.15)
  IN5 w0.089: 94.37,1.91 93.82,2.46 90.22,2.46 89.9,2.15 88.59,2.15 87.81,2.93 87.34,2.93 86.95,2.54 v2(86.95,1.97)
  IN5 w0.099: 94.37,1.91 94.53,1.75 109.9,1.75 110.98,2.83 115.17,2.83 116.74,1.27 148.49,1.27 150.04,2.82 195.3,2.82 198.77,6.28 204.55,6.28 206.21,7.94 209.73,7.94 215.14,2.53 242.09,2.53 245.17,5.6 250.86,5.6 251.97,4.5 263.69,4.5 264.29,5.1 267.38,5.1 268.73,3.75 268.73,3.33 269,3.07 273.25,3.07 274.09,3.91 279.8,3.91 280.41,3.3 288.47,3.3 288.97,3.8 295.56,3.8 296.08,3.29 301.62,3.29 302.25,3.91 305.55,3.91 306.05,3.41 311.19,3.41 311.74,3.96 313.06,3.96 314.53,5.43 314.53,7.1 313.95,7.68 313.95,16.26 314.43,16.74 314.43,17.87 v2(312.85,19.44)
  BOTTOM w0.089: UH2.BE31 84.36,5.58 84.28,5.5 84.28,5.11 84.01,4.84 84.01,3.75 83.85,3.58 83.85,3 84.39,2.45 v1(84.65,2.45) RH549.2 86.53,2.45 86.95,2.03 v2(86.95,1.97)
SRCCLKREQ2#: length 3.2
  TOP w0.089: v1(82.93,12.8) 83.3,12.8 84,12.1 RH550.2 84,11.34 v2(84.43,10.9)
  BOTTOM w0.089: UH2.AR32 84.27,10.74 v2(84.43,10.9)
SRCCLKREQ8#: length 11.9
  TOP w0.089: v2(79.05,14.75) 78.69,15.11 78.29,15.11 78.03,15.38 77.07,15.38 76.17,16.28 74.95,16.28 74.34,16.9 74.34,17.54 74.86,18.06 74.86,18.81 v1(74.84,18.83) 74.58,19.09
  TOP w0.14: RP22.7 72.09,19.19 72.42,19.52 74.15,19.52 74.58,19.09
  BOTTOM w0.089: v2(79.05,14.75) 79.4,15.1 UH2.AE41
SRCCLKREQ9#: length 6.1
  TOP w0.089: v2(74.78,15.16) 74.78,15.34 73.42,16.69 73.42,17.39 73.29,17.51
  TOP w0.14: 73.29,17.51 72.62,18.19 RP22.5
  BOTTOM w0.089: v2(74.78,15.16) 75.16,15.16 75.62,14.71 UH2.AF48
SRCCLKREQ10#: length 9
  TOP w0.089: 74.91,19.41 76.01,18.31 v1(77.15,18.31) v2(78.36,17.1)
  TOP w0.14: 74.91,19.41 74.5,19.81 72.37,19.81 72.25,19.69 RP22.8
  BOTTOM w0.089: UH2.AC41 79.28,16.48 78.67,17.1 v2(78.36,17.1)
SRCCLKREQ11#: length 9.7
  BOTTOM w0.076: UH2.AC39 79.83,16.48 78.4,17.91 77.12,17.91 76.81,18.03 75.73,18.03 75.4,18.35 74.74,18.35 74.3,18.8
  BOTTOM w0.14: RP23.5 73.47,19.92 74.27,19.12 74.27,18.82 74.3,18.8
SRCCLKREQ12#: length 11.2
  TOP w0.089: v2(78.42,14.73) 77.97,15.18 77.01,15.18 76.12,16.07 74.54,16.07 v1(74.04,16.56) 73.66,16.95 73.66,17.53 73.48,17.7
  TOP w0.14: 73.48,17.7 72.91,18.28 v2(72.91,18.76)
  BOTTOM w0.089: v2(78.42,14.73) 78.47,14.73 78.96,15.23 78.96,15.38 79.21,15.63 79.84,15.63 80.14,15.32 UH2.AE39
  BOTTOM w0.14: v2(72.91,18.76) 72.67,18.51 72.56,18.41 72.42,18.41 72.42,18.42 RP23.8
SRCCLKREQ13#: length 6.2
  BOTTOM w0.089: 73.66,18.04 75.05,16.65 75.62,16.65 UH2.AB48
  BOTTOM w0.14: 73.66,18.04 73.61,18.09 73.61,19.23 73.27,19.57 72.45,19.57 72.3,19.42 RP23.6
SRCCLKREQ14#: length 12.1
  BOTTOM w0.089: UH2.AC44 77.88,16.66 77.56,16.97 76.91,16.97 76.78,16.84 76.17,16.84 75.75,16.43 74.85,16.43 73.53,17.75
  BOTTOM w0.14: 73.53,17.75 73.35,17.93 73.35,19.02 73.1,19.27 72.67,19.27 72.32,18.92 RP23.7 71.6,18.92 71.48,18.8 71.48,18.17 71.29,17.98 70.31,17.98 69.83,18.47 v1(69.25,18.47)
SRCCLKREQ15#: length 8.1
  TOP w0.089: v2(74,18.41) 73.95,18.45
  TOP w0.14: RP22.6 72.2,18.69 72.72,19.2 73.2,19.2 v1(73.33,19.08) 73.95,18.45
  BOTTOM w0.076: 75.48,17.88 75.48,17.88 75.84,17.53 76.48,17.53 76.81,17.19 77.7,17.19 78.42,16.48 UH2.AC43
  BOTTOM w0.089: 75.48,17.88 75.31,18.06 74.35,18.06 v2(74,18.41)
SSD_EN: length 49
  TOP w0.14: v1(233.68,7.11) 234.19,7.11 v2(234.7,6.61) RZ1956.2 235.01,5.47 235.25,5.47 235.25,5.48 UZ6.4 ; v2(274.45,11.56) UZ32.3
  IN2 w0.099: v2(234.7,6.61) 235.33,7.24 242.89,7.24 244.44,8.8 254.6,8.8 255.02,9.21 256.92,9.21 257.3,9.59 261.05,9.59 262.07,10.61 264.22,10.61 266.45,12.83 267.72,12.83 267.97,12.57 272.16,12.57 272.67,12.07 272.67,10.8 273.05,10.42 273.81,10.42 274.45,11.05 v2(274.45,11.56)
SSD_PCIE_WAKE#: length 4.2
  TOP w0.127: RD59.1 RD8.1 267.24,9.78 266.97,9.51 266.91,9.51 v2(266.9,9.52)
  TOP w0.14: RD8.1 267.51,10.25 v1(266.99,10.77)
  BOTTOM w0.127: JNGFF2.54 267.03,9.8 266.9,9.67 v2(266.9,9.52)
SSD_SCP#: length 40.9
  TOP w0.076: UE3.H5 v2(300.16,13.37)
  TOP w0.14: RD101.2 269.38,20.96 RE307.1 269.94,20.42 v2(269.94,19.37)
  IN6 w0.076: v2(300.16,13.37) 299.75,12.96 299.75,12.41 299.5,12.15 298.35,12.15 298.16,12.35 298.16,12.8 297.99,12.97 297.6,12.97 297.59,12.98 297.58,12.98 297.37,13.19 297.37,13.2 297.37,13.57 297.17,13.76 294.98,13.76 294.7,14.03 294.7,14.75 293.96,15.49 293.56,15.49
  IN6 w0.099: v2(269.94,19.37) 269.94,19.36 272.62,16.69 276.31,16.69 277.14,15.86 281.76,15.86 283.08,14.54 287.09,14.54 287.52,14.97 288.44,14.97 289.47,13.94 289.47,13.25 289.64,13.07 290.15,13.07 292.56,15.49 293.56,15.49
SSD_SCP#_R: length 5.1
  TOP w0.14: v2(266.96,20.54) 267.38,20.96 RD101.1 267.69,20.96 268.17,21.44 269,21.44 269.18,21.62 269.33,21.62 v1(269.69,21.97)
  BOTTOM w0.14: v2(266.96,20.54) 266.96,21.17 267.09,21.29 JNGFF2.8
SSD_SCP_PWR_EN: length 99.8
  TOP w0.076: UE3.H8 v2(300.16,15.76)
  TOP w0.14: 240.79,6.1 239.99,6.1 RZ1958.1 237.67,4.81 UZ6.2 ; 240.79,6.1 v1(240.79,6.1) ; 240.79,6.1 250.44,6.1 252.31,4.23 252.31,3.65 252.88,3.07 256.85,3.07 258.07,4.3 264.02,4.3 264.48,3.83 v2(264.48,3.22)
  IN6 w0.076: v2(300.16,15.76) 300.16,15.84 299.83,16.17 298.78,16.17 298.49,15.89 294.96,15.89 293.67,17.18 293.56,17.18
  IN6 w0.099: v2(263.11,15.31) 262.74,14.94 261.27,14.94 261.11,15.11 261.11,20.47 261.67,21.03 261.67,23.89 262.28,24.5 262.88,24.5 263.92,25.54 267.98,25.54 268,25.53 268.84,25.53 269.44,24.92 269.44,24.08 270.47,23.06 270.53,23.06 272.91,20.68 277.4,20.68 278.19,19.89 280.53,19.89 280.88,20.24 282.51,20.24 284.5,18.24 287.04,18.24 287.26,18.46 289.42,18.46 290.7,17.18 293.56,17.18
  BOTTOM w0.14: v2(264.48,3.22) 264.48,5.08 265.23,5.83 265.23,13.19 v2(263.11,15.31)
SSD_SUSCLK: length 3.4
  TOP w0.14: v1(269.84,7.21) v2(269.29,7.21) 268.94,6.86 RD9.1
  BOTTOM w0.127: v2(269.29,7.21) 269.26,7.19 269.26,6.86 268.7,6.29 JNGFF2.60
STRAP0: length 14.1
  TOP w0.14: v2(215.79,58.17) 217.74,58.17 218.76,57.15 219.84,57.15 v1(220.4,56.59) 222.97,54.01 222.97,52.27 RV651.2 223.45,51.37 223.46,51.35 RV645.1
  BOTTOM w0.107: v2(215.79,58.17) 215.79,58.22 215.85,58.28 215.85,58.71 215.81,58.75 215.81,58.75 215.59,58.97 215.59,58.97 215.44,59.12 UV18.J2
STRAP1: length 27.4
  TOP w0.14: RV652.2 v2(228.23,51.12) RV646.1
  IN6 w0.127: v2(214.99,63.86) 214.99,63.06 215.39,62.65 216.08,62.65 216.27,62.46 216.27,61.62 216.29,61.6 216.29,60.97 216.18,60.86 216.18,59.66 220.85,54.99 226.26,54.99 228.23,53.03 v2(228.23,51.12)
  BOTTOM w0.102: v2(214.99,63.86) 215.34,63.5 UV18.J7
  BOTTOM w0.14: v1(227.6,54.4) 227.6,52.91 228.23,52.28 v2(228.23,51.12)
STRAP2: length 23.2
  TOP w0.14: RV653.2 v2(227.34,51.12) RV647.1
  IN5 w0.099: v2(227.34,51.12) 227.34,51.41 226.2,52.54 220.73,52.54 216.8,56.47 216.8,59.09 216.25,59.64 216.25,60.85 216.4,61 216.92,61 217.1,61.18 217.1,62.36 216.81,62.64 216.28,62.64 v2(215.85,63.07)
  BOTTOM w0.102: UV18.J6 215.47,62.65 215.85,63.02 v2(215.85,63.07)
STRAP3: length 24.4
  TOP w0.14: RV654.2 v2(229.12,51.12) RV648.1 229.99,50.44 v1(230.14,50.59)
  IN5 w0.099: v2(215.85,62.2) 215.95,62.2 216.28,61.87 216.28,61.16 216.03,60.91 216.03,59.49 216.55,58.97 216.55,56.44 220.65,52.34 225.55,52.34 227.17,50.72 228.71,50.72 v2(229.12,51.12)
  BOTTOM w0.102: v2(215.85,62.2) 215.45,61.8 UV18.J5
STRAP4: length 15.7
  TOP w0.14: v2(215.02,59.8) 215.95,58.87 217.74,58.87 218.95,57.66 220.41,57.66 v1(221.91,56.16) 223.94,54.13 223.94,52.29 RV655.2 RV649.1
  BOTTOM w0.102: UV18.J3 215.42,60.2 v2(215.02,59.8)
STRAP5: length 13.3
  TOP w0.14: v2(215.36,57.11) 216.84,55.64 v1(218.3,55.64) 218.54,55.64 219.09,55.09 219.09,54.92 220.2,53.81 220.2,52.42 220.67,51.95 RV656.2 222.44,51.44 222.57,51.31 RV650.1
  BOTTOM w0.102: UV18.J1 215.21,58.37 215.21,57.56
  BOTTOM w0.14: 215.21,57.56 215.21,57.27 v2(215.36,57.11)
SUS_ON_EC: length 24.9
  TOP w0.14: UE3.D2 296.98,10.94 296.98,9.62 v2(296.83,9.47) ; RE39.2 309.41,21.86 v2(308.68,21.86) 308.5,21.86 v1(308.23,21.59)
  IN1 w0.076: 304.17,16.97 303.37,16.17 301.6,16.17 301.37,16.4 301.37,16.72 301.12,16.97 300.73,16.97 300.54,16.78 300.54,16.38 300.33,16.17 299.52,16.17 299.51,16.17 299.18,16.17 299.18,16.17 298.97,16.17 298.15,15.35 298.15,11.39 298.07,11.3
  IN1 w0.099: v2(296.83,9.47) 296.99,9.63 296.99,10.23 298.07,11.3 ; 304.17,16.97 304.62,16.97 307.02,19.37 307.02,20.64 308.24,21.86 v2(308.68,21.86)
SUS_ON_EC_P: length 284
  TOP w0.14: Q5.2 275.34,25.66 275.59,25.4 275.59,24.51 275.46,24.39 273.81,24.39 273.09,23.66 v1(271.48,23.66) v2(270.91,23.66) ; 119.63,65.98 119.96,65.98 120.41,66.44 UZ22.4 121.01,66.44 121.28,66.71 121.32,66.71 122.23,67.62 123.57,67.62 RZ1966.1 123.85,67.87 124.37,67.35 DZ59.1 ; 119.63,65.98 RZ87.1 ; 119.63,65.98 v2(119.63,66.94) ; UZ23.1 v2(105.22,53.86) 105.22,54.88 RZ91.1 105.33,55.28 105.93,55.88 RZ1954.2 ; v2(180.75,27.64) 182.84,27.64 184.28,26.2 184.28,23.43 184.59,23.11 184.59,22.36 184.78,22.17 184.78,18.97 184.68,18.87 184.68,12.21 183.98,11.51 183.98,9.82 183.3,9.15 PR1801.1
  IN1 w0.089: 134.62,68.09 136.93,68.09 137.68,67.35 138.56,67.35 139.07,67.86 v2(139.07,67.87)
  IN1 w0.099: v2(134.43,68.2) 134.54,68.09 134.62,68.09
  IN2 w0.099: v2(134.43,68.2) 134.18,67.95 131.83,67.95 130.81,68.96 123.34,68.96 121.32,66.94 v2(119.63,66.94)
  IN3 w0.089: 181.1,68.71 175.87,68.71 174.95,69.62 171.5,69.62 170.38,70.75 159.96,70.75 158.99,71.72 154.67,71.72 154.55,71.61 154.55,70.41 154.1,69.95 153.31,69.95 153.05,70.21 145.56,70.21 144.83,69.47 143.03,69.47 142.7,69.8 142.22,69.8 140.7,68.28 139.49,68.28 v2(139.07,67.87)
  IN3 w0.091: v2(105.22,53.86) 106.95,55.59 110.41,55.59 110.93,56.11 114.53,56.11 116.61,58.19 116.61,63.29 119.03,65.7 119.03,66.33 v2(119.63,66.94) ; v2(185.64,64.01) 185.2,64.01 182.91,66.3 182.91,68.35 182.55,68.71 181.1,68.71
  IN5 w0.099: v2(270.91,23.66) 270.91,22.76 270.05,21.9 263.54,21.9 261.05,24.39 261.05,26.48 257.25,30.27 252.84,30.27 251.41,28.84 248.04,28.84 244.19,32.7 183.95,32.7 180.75,29.49 v2(180.75,27.64)
  IN6 w0.099: v2(185.64,64.01) 185.64,62.25 189.98,57.92 189.98,55.2 191.16,54.01 191.16,50.67 188.43,47.94 188.43,37.72 182.06,31.35 182.06,28.94 v2(180.75,27.64)
SUS_ON_EC_R: length 286.5
  TOP w0.14: v2(120.44,15.46) 120.23,15.46 118.29,17.4 114.55,17.4 114.07,17.88 114.07,18.58 113.61,19.05 112.47,19.05 110.93,20.59 110.93,25.99 108.41,28.51 108.41,36.88 111.58,40.05 116.01,40.05 121.43,45.48 v1(121.43,46.47) 121.43,48.37 120.73,49.07 120.42,49.07 119.1,47.76 v2(118.26,47.76) ; v2(123.83,65.03) 123.71,65.14 UZ22.1 ; v2(308.7,19.94) 309.3,19.94 RE30.1 310.34,20.73 RE38.1 RE39.1
  IN2 w0.099: v2(123.83,65.03) 123.82,65.02 123.82,59.81 122.73,58.72 122.73,53.84 122.44,53.56 122.44,51.18 123.1,50.53 123.1,49.44 121.16,47.5 118.52,47.5 v2(118.26,47.76)
  IN5 w0.099: v2(308.7,19.94) 308.7,20.11 309.04,20.45 309.04,20.96 308.74,21.26 307.53,21.26 306.38,22.42 304.86,22.42 304.48,22.8 300.36,22.8 299.41,23.74 299.41,25.07 298.83,25.66 298.14,25.66 297.42,24.95 296.35,24.95 295.85,24.45 295.85,23.92 295.25,23.32 294.75,23.32 293.94,22.51 292.21,22.51 291.19,23.53 289.61,23.53 288.43,22.34 288.43,22.09 286.36,20.02 281.56,20.02 280.75,19.2 276.45,19.2 274.58,17.34 269.43,17.34 269.02,17.74 261.76,17.74 261.23,17.21 258.32,17.21 257.52,16.4 257.52,15.88 256.2,14.56 253.57,14.56 252.61,15.52 250.87,15.52 248.79,17.61 215.66,17.61 215.34,17.93 206.16,17.93 204.9,19.19 184.6,19.19 182.37,21.43 181.53,21.43 180.95,22.01 179.7,22.01 179.5,21.81 179.5,19.07 176.11,15.69 165.11,15.69 164.61,16.19 141.8,16.19 141.01,15.39 130.69,15.39 130.35,15.73 120.7,15.73 v2(120.44,15.46)
SUS_ON_EC_ST: length 127.1
  TOP w0.089: v2(179.78,85.88) 179.75,85.88 179.62,85.75 UZ15.4
  TOP w0.14: v1(109.48,53.96) 109.41,53.9 v2(109.41,53.24) 108.92,52.75 108.92,52.58 108.87,52.52 108.37,52.52 108.33,52.56 UZ23.4 107.88,53.09 107.11,53.86 CZ588.1 RZ91.2
  IN1 w0.099: v2(118.98,48.34) 118.98,47.17 117.88,46.07 117.57,46.07 v2(117.51,46.13)
  IN2 w0.099: v2(131.22,64.24) 131.12,64.14 126.09,64.14 124.13,62.18 124.13,59.73 122.93,58.53 122.93,57.41 123.66,56.68 123.66,54.5 122.64,53.48 122.64,51.26 123.47,50.44 123.47,49.28 120.26,46.07 117.57,46.07 v2(117.51,46.13)
  IN3 w0.089: v2(179.78,85.88) 179.77,85.87 179.77,85.69 179.9,85.56 ; 181.1,72.53 177.72,69.14 175.69,69.14 175.04,69.8 171.57,69.8 170.45,70.92 160.04,70.92 159.01,71.95 149.94,71.95 149.79,71.8 149.79,71.16 149.22,70.58 145.17,70.58 144.24,69.65 143.1,69.65 142.77,69.98 142.14,69.98 141.24,69.08 140.79,69.08 v2(140.4,69.47)
  IN3 w0.091: 179.9,85.56 181.73,83.73 182.02,83.73 182.86,82.89 182.86,79.05 181.17,77.36 181.17,72.59 181.1,72.53
  IN6 w0.089: 134.62,67.35 135.33,68.06 137.73,68.06 138.16,68.49 138.46,68.49 139.44,69.47 v2(140.4,69.47)
  IN6 w0.099: 134.62,67.35 133.18,65.91 132,65.91 131.78,66.13 131.42,66.13 131.12,65.82 131.12,65.34 131.29,65.16 131.29,64.31 v2(131.22,64.24)
  BOTTOM w0.14: v2(118.98,48.34) 118.29,49.03 116.1,49.03 115.34,49.8 114.09,49.8 113.1,48.81 111.49,48.81 110.52,49.78 110.52,50.9 109.41,52.01 v2(109.41,53.24)
SUSACK#: length 16.9
  TOP w0.14: UE3.K12 301.75,18.97 v2(301.75,18.92) ; v2(299.24,4.95) 298.93,4.64 RH5872.1
  BOTTOM w0.076: 300.36,9.59 301.37,10.6 301.37,15.17 301.52,15.33 301.52,16.05 301.37,16.2 v1(301.37,17.74) 301.37,18.6 301.68,18.92 v2(301.75,18.92)
  BOTTOM w0.14: 300.36,9.59 299.24,8.47 v2(299.24,4.95)
SUSACK#_R: length 233
  TOP w0.14: v2(298.27,4.05) 298.33,4 298.33,3.62 298.56,3.39 RH5872.2 ; v1(269.8,3.47) 269.26,3.47 v2(269.18,3.54)
  IN2 w0.099: v2(298.27,4.05) 297.75,3.53 295.3,3.53 294.52,4.31 289.55,4.31 288.92,3.68 285.49,3.68 285.36,3.81 273.74,3.81 273.05,3.13 269.56,3.13 269.18,3.51 v2(269.18,3.54)
  IN5 w0.089: 101.98,2.06 101.45,2.06 101.43,2.08 95.96,2.08 94.69,3.35 93.06,3.35 92.35,2.64 90.15,2.64 89.83,2.33 88.66,2.33 87.88,3.11 86.61,3.11 86.02,2.52 84.33,2.52 83.96,2.89 83.96,3.65 83.85,3.76 82.58,3.76 v2(82.2,4.14)
  IN5 w0.099: 101.98,2.06 109.76,2.06 110.86,3.16 115.25,3.16 116.11,2.3 125.59,2.3 126.4,1.49 148.29,1.49 149.95,3.16 178.04,3.16 178.53,3.65 195.68,3.65 198.51,6.48 204.22,6.48 205.96,8.22 209.93,8.22 215.42,2.73 242.01,2.73 245.08,5.8 250.95,5.8 252.05,4.7 263.41,4.7 264.08,5.37 267.54,5.37 269.2,3.71 269.2,3.56 v2(269.18,3.54)
  BOTTOM w0.089: UH2.BE35 82.16,5.81 82.57,5.4 82.57,5.1 82.41,4.94 82.41,4.53 82.2,4.32 v2(82.2,4.14)
SUSCLK: length 382.3
  TOP w0.14: v2(270.12,14.94) v1(268.83,14.94) 268.24,14.94 266.11,12.8 266.11,11.57 266.42,11.26 266.42,8.55 266.09,8.21 266.09,7.33 266.56,6.86 RD9.2 ; v2(341.2,100.65) RN1.2
  IN1 w0.099: v2(212.98,9.86) 214.14,8.7 218.44,8.7 221.68,11.94 226.93,11.94 227.8,11.08 252.01,11.08 252.87,10.21 260.03,10.21 262.9,13.08 267.26,13.08 269.06,14.89 270.07,14.89 v2(270.12,14.94) 271.36,16.18 273.44,16.18 273.97,16.7 283.48,16.7 284.13,16.05 285.27,16.05 285.52,15.8 287.35,15.8 287.53,15.98 289.74,15.98 290.5,16.73 292.93,16.73 294.95,18.76 294.95,19.28 295.28,19.61 297.42,19.61 299.6,21.78 302.26,21.78 302.57,21.48 302.57,20.65 302.97,20.24 303.78,20.24 304.14,20.6 304.96,20.6 307.76,23.4 309.2,23.4 309.45,23.65 309.45,26.04 310.33,26.93 313.06,26.93 313.44,27.31 313.44,28.97 318,33.53 326.26,33.53 328.23,35.5 328.23,36.28 328.7,36.75 329.01,36.75 329.19,36.93 329.19,38.93 330.07,39.82 330.07,48.26 330.29,48.48 330.7,48.48 331.45,47.74 332.1,47.74 332.37,48.01 332.37,51.54 335.08,54.25 335.08,56.72 v2(335.74,57.38)
  IN2 w0.099: v2(335.74,57.38) 336.81,58.45 336.81,61.98 334.7,64.09 334.7,64.8 333.12,66.38 333.12,75.6 330.25,78.46 330.25,79.09 329.07,80.28 329.07,81.88 328.83,82.12 328.14,82.12 327.6,82.65 327.6,83.43 328.3,84.12 329.18,84.12 334.96,89.91 334.96,98.58 337.91,101.53 337.91,102.44 339.17,103.69 340.24,103.69 341.2,102.73 v2(341.2,100.65)
  IN6 w0.089: v2(77.12,6.35) 77.12,6.04 77.6,5.56 84.66,5.56 85.58,4.64 86.69,4.64 86.74,4.59 89.72,4.59 90.32,5.19 96.73,5.19 97.11,5.57 97.75,5.57 98.04,5.27 98.83,5.27 99.53,4.57 99.77,4.57 100.57,3.77 101.98,3.77
  IN6 w0.099: v2(212.98,9.86) 212.78,9.65 184.6,9.65 183.64,8.7 177.74,8.7 175.55,6.51 166.5,6.51 165.74,5.76 157.36,5.76 156.94,5.34 152.44,5.34 152.19,5.59 148,5.59 145.01,8.57 140.85,8.57 140.53,8.89 135.07,8.89 134.31,8.14 134.31,5.47 133.54,4.7 133.54,3.75 132.89,3.09 130.93,3.09 130.4,2.57 125.6,2.57 124.8,3.37 116.9,3.37 116.52,3.75 115.83,3.75 115.41,3.33 105.47,3.33 105.02,3.77 101.98,3.77
  BOTTOM w0.089: UH2.BE45 77.12,5.85 77.12,6.31 v2(77.12,6.35)
SUSCLK_R: length 10.4
  TOP w0.14: RN1.1 342.72,100.09 342.2,99.57 341.58,99.57 v1(341.26,99.25) 341.26,96.12 341.95,95.43 v2(341.95,94.38)
  BOTTOM w0.14: v2(341.95,94.38) 340.8,93.23 JNGFF1.42
SW_1.2V: length 13.8
  IN6 w1.016: 284.35,28.3 281.64,28.3 279.65,30.29 276.06,30.29 275.31,31.04 273.23,31.04 v2(272.16,29.97)
  vias: v2(270.89,29.97) v2(285.69,28.45) v2(286.13,28.83)
SYS_PEX_RST_MON#: length 24.4
  TOP w0.14: v1(220.98,51.54) v2(221.36,51.16) 221.74,50.78 RV557.1
  IN2 w0.099: v2(221.36,51.16) 217.2,55.32 215.01,55.32 214.4,55.93 214.4,57.38 215.59,58.56 215.59,60.96 215.42,61.14 215.42,62.43 215.21,62.64 213.07,62.64 211,64.71 v2(210,64.71)
  BOTTOM w0.14: v2(210,64.71) 210.03,64.71 UV18.R8
SYS_PEX_RST_MON#_L: length 7.7
  TOP w0.14: RV587.1 224.85,42.04 v1(226.38,42.04) 227.28,42.04 228,42.76 228,43.53 228.55,44.07 228.55,45.6 UV19.4
SYS_PWROK: length 335.7
  TOP w0.14: v2(302.58,5.46) 302.58,5.23 302.97,4.84 RE33.2 303.03,4.83 RE303.2 304.03,4.83 v1(305.18,3.68)
  IN1 w0.099: v2(296.91,8.63) 296.62,8.63 294.12,11.13 291.11,11.13 290.04,12.19 290.04,12.28 289.82,12.51 287.71,12.51 286.84,13.39 274.02,13.39 273.41,12.78 268.83,12.78 268.4,12.34 268.4,11.47 268.03,11.1 263.17,11.1 261.19,9.12 252.54,9.12 251.64,10.02 240.27,10.02 239.21,8.95 227.14,8.95 v2(226.19,9.91)
  IN3 w0.089: v2(100.1,9.7) 100.1,9.57 99.68,9.16 99.51,9.16 99.07,8.72 98.45,8.72 98.16,9 98.16,9.48 99.22,10.55 99.22,11.14 98.11,12.26 98.11,12.94 98.01,13.04 98.01,14.72 98.42,15.13 98.42,18.61 99.1,19.29 99.45,19.29 100.19,20.03 v6(100.19,20.14)
  IN3 w0.091: v2(302.58,5.46) 302.53,5.51 300.23,5.51 297.11,8.63 v2(296.91,8.63)
  IN4 w0.091: v6(100.19,20.14) 100.19,20.29 100.65,20.75 101.03,20.75 101.44,21.15 101.44,32.81 100.81,33.43 100.81,36.04 102.39,37.62 106.77,37.62 109.75,40.6 109.75,41.19 113.74,45.19 117.59,45.19 119.71,47.31 119.71,49.99 119.93,50.21 119.93,59.82 122.19,62.08 122.19,62.75 125.87,66.44 125.87,85.44 123.62,87.69 123.62,93.02 124.49,93.88 124.92,93.88 v2(125.31,93.49)
  IN6 w0.089: 101.98,9.44 101.05,9.44 100.92,9.31 100.26,9.31 100.1,9.47 v2(100.1,9.7)
  IN6 w0.099: 101.98,9.44 103.43,9.44 104.1,8.76 105.13,8.76 106.3,9.93 110.43,9.93 110.88,9.48 111.71,9.48 112.56,10.33 113.64,10.33 113.84,10.53 117.81,10.53 119,11.72 121.31,11.72 123.05,13.46 137.9,13.46 138.53,12.83 141.36,12.83 143.1,11.09 147.82,11.09 148.82,10.1 150.88,10.1 151.2,10.42 152.07,10.42 152.32,10.67 163.42,10.67 164.4,11.65 185.11,11.65 185.33,11.43 192.82,11.43 194.75,13.36 222.73,13.36 v2(226.19,9.91)
  BOTTOM w0.076: v2(100.1,9.7) 100.1,9.72 99.76,10.06 98.9,10.06 98.71,9.87 98.38,9.87 98.12,9.6 UH2.AU3
  BOTTOM w0.089: 101.98,9.96 101.78,10.16 100.56,10.16 v2(100.1,9.7)
  BOTTOM w0.14: RH91.2 102.13,9.81 101.98,9.96 ; RH490.1 127.27,93.88 125.71,93.88 v2(125.31,93.49)
SYS_PWROK_R: length 39.1
  TOP w0.076: UE3.G4 v2(298.57,12.58)
  TOP w0.14: v1(303.82,2.81) 304.12,3.11 v2(304.12,3.31) 303.82,3.61 RE303.1
  IN2 w0.099: v2(311.51,12.71) 312.36,11.86 315.25,11.86 315.94,11.18 315.94,9.38 313.32,6.75 313.32,6.25 313.66,5.9 313.66,4.19 313.23,3.76 310.16,3.76 309.24,2.83 304.6,2.83 v2(304.12,3.31)
  IN4 w0.091: v2(311.51,12.71) 310.19,12.71 309.44,13.46 305.59,13.46 305.09,12.97 UE3.G4 v2(298.57,12.58)
SYS_RESET#: length 199.5
  TOP w0.089: v1(99.05,9.34) 98.88,9.17 v2(98.57,9.17)
  IN2 w0.089: v2(98.57,9.17) 98.57,9.71 99.04,10.19 101.05,10.19 101.98,11.12
  IN2 w0.099: v2(172.42,8.89) 171.71,9.6 169.87,9.6 169.55,9.27 164.16,9.27 163.8,8.91 157.05,8.91 155.86,10.11 155.02,10.11 153.61,11.52 151.7,11.52 151.08,12.14 148.61,12.14 147.85,11.39 139.47,11.39 136.89,13.97 124.05,13.97 122.61,15.41 121.95,15.41 120.86,16.5 115.96,16.5 115.67,16.2 114.07,16.2 113.58,15.71 112.15,15.71 109.65,13.21 106.45,13.21 105.8,12.56 103.43,12.56 101.98,11.12
  IN3 w0.089: v6(98.69,13.44) 98.51,13.26 98.51,12.18 99.4,11.29 99.4,10.27 98.57,9.44 v2(98.57,9.17)
  IN4 w0.091: v6(98.69,13.44) 98.69,15.19 99.31,15.81 99.65,15.81 100.22,16.38 100.22,17.59 100.7,18.07 100.7,19.13 100.48,19.35 99.98,19.35 99.64,19.68 99.64,20.35 100.45,21.15 100.98,21.15 101.09,21.27 101.09,29.06 98.49,31.67 98.49,32.96 98.81,33.28 98.93,33.28 100.5,34.84 100.5,36.28 102.15,37.94 106.67,37.94 109.28,40.55 109.28,41.14 113.64,45.51 117.46,45.51 119.42,47.46 119.42,50.12 119.61,50.31 119.61,60.36 121.82,62.57 121.82,63.02 123.21,64.41 123.21,65.12 123.83,65.74 124.46,65.74 125.58,66.87 125.58,85.32 123.32,87.58 123.32,93.2 v2(124.77,94.64)
  BOTTOM w0.089: 101.98,9.43 101.04,9.43 100.73,9.13 98.61,9.13 v2(98.57,9.17) UH2.AU2
  BOTTOM w0.14: RH8.2 125.16,95.04 v2(124.77,94.64) ; v2(172.42,8.89) 172.49,8.82 172.49,8.68 172.62,8.55 JAPS.13 ; RH571.1 104.45,10.33 104.04,9.92 103.74,9.92 103.25,9.43 101.98,9.43
TACH_FAN1: length 228.8
  TOP w0.14: v2(296.93,11.74) 297.35,12.17 UE3.E3 ; v1(255.4,28.96) 255.27,28.96 254.97,29.26 v2(254.46,29.26) ; RE81.2 100.71,34.95 DE7.2 101.66,34.93 102.29,34.3 v2(102.62,34.3) 102.82,34.51 CE66.1
  IN1 w0.099: v2(292.23,24.94) 292.14,25.03 287.87,25.03 287.22,24.39 282.7,24.39 282.13,24.96 277.69,24.96 277.24,24.51 270.19,24.51 268.77,25.94 266.57,25.94 266.1,25.46 258.26,25.46 v2(254.46,29.26)
  IN3 w0.091: v2(113.34,31.65) 113.32,31.67 113.32,31.99 110.8,34.52 102.83,34.52 v2(102.62,34.3)
  IN4 w0.091: v2(254.46,29.26) 252.41,27.22 243.49,27.22 242.46,26.19 242.46,22.15 239.74,19.43 202.81,19.43 201.79,20.45 183.77,20.45 178.75,25.46 175.38,25.46 173.79,27.06 164.06,27.06 160.03,31.08 116.9,31.08 115.8,32.18 114.68,32.18 114.1,31.6 113.39,31.6 v2(113.34,31.65)
  BOTTOM w0.076: 294.74,14.96 295.14,14.56 296.41,14.56 296.56,14.42 296.56,14.06 296.85,13.77 297.16,13.77 297.35,13.58 297.35,12.17 v2(296.93,11.74)
  BOTTOM w0.14: 294.74,14.96 294.74,15.12 292.55,17.32 292.55,19.37 291.4,20.52 291.4,22.12 291.92,22.65 291.92,24.61 292.23,24.91 v2(292.23,24.94)
TACH_FAN2: length 70.3
  TOP w0.14: v2(296.39,9.86) 296.56,10.02 UE3.D1
  IN1 w0.076: 303.77,17.4 303.34,16.97 301.6,16.97 301.35,17.22 301.35,17.53 301.1,17.79 299.23,17.79 298.93,17.49 298.93,16.39 297.94,15.41 297.64,15.41 297.37,15.13 297.37,11.3
  IN1 w0.099: 303.77,17.4 304.6,17.4 306.5,19.31 306.5,20.69 308.08,22.26 309.99,22.26 312.04,24.31 312.04,24.46 313.68,26.1 318.07,26.1 319.28,27.31 319.28,30.61 320.87,32.2 325.82,32.2 326.14,32.51 326.14,32.89 328.55,35.31 328.55,36.15 328.85,36.45 329.24,36.45 329.57,36.78 329.57,38.74 330.54,39.71 v2(330.54,48.07)
  IN1 w0.127: v2(296.39,9.86) 296.56,10.02 296.56,10.5 297.37,11.3
  BOTTOM w0.14: DE8.2 335.98,48.24 CE67.1 334.25,48.24 RE83.2 v1(332.92,48.22) 332.72,48.22 332.13,47.64 330.97,47.64 v2(330.54,48.07)
TB_HDMI_HPLUG: length 3.8
  TOP w0.089: v2(25.24,45.66) 25.49,45.91 25.49,46.35 25.5,46.36
  TOP w0.14: 25.5,46.36 25.6,46.46 25.6,47.67 25.77,47.84 RT1134.1
  BOTTOM w0.102: UT1.G1 24.73,45.15 v2(25.24,45.66)
TBT_BATLOW#: length 4.5
  TOP w0.089: v4(24.13,45.52) 24.13,46.36
  TOP w0.14: RT25.2 24.97,47.83 24.97,47.4 v1(24.56,46.99) 24.13,46.56 24.13,46.36
  BOTTOM w0.089: UT1.F2 24.03,44.74 24.03,45.42 v4(24.13,45.52)
TBT_CIO_PLUG_EVENT#: length 121.2
  TOP w0.14: v2(31.18,47.31) RT23.2 ; RH5889.1 97.07,1.87 96.91,2.03 v2(96.91,2.66)
  IN3 w0.089: 30.54,46.36 30.54,44.93 30.25,44.64 27.73,44.64 27.35,44.26 27.35,43.35 26.36,42.36 26.36,41.76 27.54,40.59 28.16,40.59 28.37,40.37 28.37,39.65 27.99,39.27 27.99,36.98 27.53,36.53 26.95,36.53 25.88,35.46 25.88,33.66 26.01,33.53
  IN3 w0.091: v2(31.18,47.31) 31.18,47.18 30.54,46.55 30.54,46.36 ; v2(49.77,21.31) 49.77,21.35 49.55,21.58 42.86,21.58 39.64,24.79 39.64,25.56 37.66,27.55 37.66,28.44 36.7,29.39 33.02,29.39 32.73,29.68 32.73,31.87 31.93,32.67 26.87,32.67 26.01,33.53
  IN6 w0.089: 75.06,3.23 75.39,2.9 77.17,2.9 77.46,3.19 78.5,3.19 79.6,2.09 ; v2(96.91,2.66) 96.91,2.34 96.48,1.91 95.87,1.91 ; 83.53,1.91 83.35,2.09
  IN6 w0.099: 75.06,3.23 73.05,5.23 72.01,5.23 71.12,6.12 71.12,10.67 70.74,11.05 69.22,11.05 68.64,11.63 68.64,12.21 66.7,14.15 66.7,17.04 65.84,17.9 62.16,17.9 60.29,19.77 57.67,19.77 56.68,20.76 52.01,20.76 51.72,21.05 51.72,21.54 51.53,21.73 50.08,21.73 49.77,21.43 v2(49.77,21.31) ; 95.87,1.91 95.26,1.29 93.58,1.29 92.99,1.88 90.19,1.88 89.61,1.29 84.15,1.29 83.53,1.91 ; 83.35,2.09 81.66,2.09 81.66,2.09 79.6,2.09
  BOTTOM w0.089: UH2.BF8 95.71,4.9 95.89,4.73 95.89,4.45 96.22,4.12 96.22,3.35 v2(96.91,2.66) ; 30.74,46.36 30.74,45.39 30.48,45.13 30.48,44.73 UT1.W2
  BOTTOM w0.14: v2(31.18,47.31) 31.18,47.25 30.87,46.94 30.87,46.81 30.74,46.67 30.74,46.36
TBT_CONFIG: length 3.2
  TOP w0.14: v2(23.12,59.39) 23.14,59.41 23.14,60.91 22.86,61.19 RT183.1 22.73,61.2 RT1093.2
  BOTTOM w0.081: v2(23.12,59.39) UT4.H6
TBT_DDC_CLK: length 3.8
  TOP w0.14: RT5848.2 30.9,45.85 v2(31.56,45.85) 31.75,46.04 RT33.2
  BOTTOM w0.076: UT1.Y2 30.94,44.73 30.94,45.13 31.5,45.69 31.5,45.78 v2(31.56,45.85)
TBT_DDC_DATA: length 4.2
  TOP w0.14: RT5847.2 30.67,46.74 v2(31.14,46.27) 31.48,46.61 RT34.2
  BOTTOM w0.076: UT1.Y1 30.71,45.13 31.08,45.5 31.08,46.21 v2(31.14,46.27) 31.23,46.36
  BOTTOM w0.14: 31.23,46.36 31.41,46.53 v1(31.6,46.53)
TBT_FORCE_PWR: length 122.8
  TOP w0.089: v1(91.67,3.72) 92.23,4.29 v6(92.23,4.55)
  TOP w0.14: v2(26.8,46.5) 26.8,46.53 27.36,47.1 27.36,47.87 27.63,48.13 RT38.2 28.22,48.2 28.65,48.63 RT5846.1
  IN1 w0.089: 30.86,33.53 29.14,35.25 28.34,35.25 27.55,36.04 27.55,36.51 27.92,36.88 27.92,39.52 28.38,39.98 28.38,40.32 28.42,40.32 28.51,40.41 28.51,40.7 29.21,41.4 29.21,42.54 28.8,42.95 28.8,43.71 29.01,43.92 29.01,44.46 28.7,44.77 28.28,44.77 27,46.04 27,46.36
  IN1 w0.099: v2(26.8,46.5) 26.9,46.5 27,46.4 27,46.36 ; 30.86,33.53 32.26,32.13 32.26,31.78 28.84,28.36 28.84,24.26 29.7,23.4 29.97,23.4 v2(32.03,21.34)
  IN2 w0.089: v6(92.23,4.55) 91.71,5.08 91.25,5.08 90.86,5.48 89.96,5.48 89.25,4.76 87.79,4.76 87.6,4.95 85.28,4.95 84.98,5.25 80.34,5.25 80.24,5.15 79.8,5.15 78.05,3.4 77.49,3.4 77.02,2.93 75.22,2.93 75.06,3.09
  IN2 w0.099: v2(32.03,21.34) 32.32,21.05 32.32,19.87 32.42,19.77 36.68,19.77 37.37,20.46 51.28,20.46 51.92,21.1 51.92,21.59 52.82,22.49 56.04,22.49 57.54,20.99 57.54,18.78 57.47,18.71 57.47,17.34 57.89,16.92 58.79,16.92 59.95,15.77 59.95,14.33 60.17,14.1 60.17,12.05 60.2,12.02 60.2,8.17 59.34,7.31 59.34,5.27 60.24,4.37 60.24,3.76 60.7,3.31 61.29,3.31 61.46,3.13 61.67,3.13 62.14,2.66 63.91,2.66 64.12,2.45 65.25,2.45 67.18,4.37 73.77,4.37 75.06,3.09
  BOTTOM w0.089: v6(92.23,4.55) 92.26,4.58 92.26,5.02 92.5,5.26 92.5,5.65 92.34,5.81 UH2.BE15
TBT_FORCE_PWR_R: length 9.3
  TOP w0.089: 26.19,46.36 26.19,46.09 25.91,45.81 25.91,45.37 25.63,45.09 24.79,45.09 24.38,44.68 24.38,43.87 v2(24.77,43.49) 24.69,43.49 24.13,42.93 v1(24.13,42.8)
  TOP w0.14: 26.19,46.36 26.19,46.57 26.88,47.27 26.88,47.62 27.11,47.85 27.11,48.42 27.39,48.71 RT5846.2
  BOTTOM w0.089: UT1.H4 25.08,43.75 24.82,43.49 v2(24.77,43.49)
TBT_I2C_CLK: length 26.8
  IN3 w0.089: 25.73,46.36 26.43,45.66 28.08,45.66 v2(28.5,46.08)
  IN3 w0.091: 25.73,46.36 25.18,46.91 21.1,46.91 20.18,45.99 19.33,45.99 18.17,47.16 18.17,56.48 17.93,56.72 17.48,56.72 v2(17.35,56.59)
  BOTTOM w0.089: UT1.U2 29.57,44.73 29.57,45.41 28.9,46.08 v2(28.5,46.08) 28.5,46.33 28.53,46.36
  BOTTOM w0.14: v2(17.35,56.59) 17.56,56.8 18.37,56.8 18.45,56.72 RT5837.1 ; 28.53,46.36 RT36.2
TBT_I2C_CLK_R: length 1.9
  BOTTOM w0.081: UT4.D2 21.11,56.83 20.91,56.62 19.48,56.62 RT5837.2
TBT_I2C_DATA: length 25.8
  IN3 w0.089: 26.22,46.36 26.22,46.35 26.57,46 27.74,46 v2(27.9,46.15)
  IN3 w0.091: 26.22,46.36 25.32,47.25 20.95,47.25 20.04,46.34 19.47,46.34 18.51,47.3 18.51,56.62 18.07,57.07 17.48,57.07 v2(17.35,57.2)
  BOTTOM w0.089: 27.64,46.36 27.84,46.15 v2(27.9,46.15) 28.45,45.59 29.03,45.59 29.33,45.3 UT1.U1
  BOTTOM w0.14: 27.64,46.36 27.36,46.64 RT35.2 ; v2(17.35,57.2) 18.37,57.2 18.45,57.28 RT5836.1
TBT_I2C_DATA_R: length 1.4
  BOTTOM w0.081: RT5836.2 19.84,56.82 20.56,56.82 UT4.D1
TBT_JTAG_TCK: length 7.3
  TOP w0.089: 33.66,44.91 33.57,45 33.57,45.14 33.03,45.68 32.21,45.68 31.8,45.28 30.8,45.28 30.61,45.09 28.91,45.09 T198.1 28.66,44.84 28.66,44.11 v2(28.65,44.1)
  TOP w0.14: RT7.2 33.88,44.68 33.66,44.91
  BOTTOM w0.102: UT1.T4 28.68,44.1 28.66,44.1 28.66,44.1 v2(28.65,44.1)
TBT_JTAG_TDI: length 5.7
  TOP w0.089: v4(29.95,44.1) 30.36,44.5 T196.1 31.53,44.5 32.62,43.4 33.57,43.4 33.6,43.44 33.66,43.44
  TOP w0.14: RT9.2 33.82,43.44 33.66,43.44
  BOTTOM w0.089: UT1.Y4 30.85,43.8 30.56,44.1 v4(29.95,44.1)
TBT_JTAG_TDO: length 5.3
  TOP w0.089: v2(29.95,43.49) 30.48,44.02 31.76,44.02 33.03,42.75 T199.1 33.3,42.88 33.66,42.88
  TOP w0.14: RT6.2 33.66,42.88
  BOTTOM w0.102: v2(29.95,43.49) 30.26,43.8 UT1.W4
TBT_JTAG_TMS: length 6.4
  TOP w0.089: 33.66,44.17 33.04,44.17 32.86,44.34 32.11,44.34 31.48,44.97 30.96,44.97 30.79,44.79 T197.1 29.57,44.37 29.57,43.76 29.32,43.51 v4(29.32,43.5)
  TOP w0.14: 33.66,44.17 33.84,44.17 RT8.2
  BOTTOM w0.102: v4(29.32,43.5) 29.32,43.52 29.61,43.8 UT1.V4
TBT_LSRX: length 28.2
  IN2 w0.099: v2(21.05,43.04) 21.04,43.04 20.92,42.92 20.81,42.92 20.17,43.56 20.17,45.7 20.89,46.42 20.89,47.73 20.33,48.3 19.98,48.3 19.53,48.75 19.53,52.64 19.93,53.04 20.58,53.04 21.08,53.54 21.08,55.37 20.96,55.5 20.96,60.33 21.6,60.97 v2(21.75,60.97)
  IN6 w0.099: v2(21.29,63.54) 21.29,63.46 21.36,63.38 21.36,62.78 22.17,61.97 22.17,61.39 v2(21.75,60.97)
  BOTTOM w0.076: UT1.A4 21.89,43.58 21.77,43.46
  BOTTOM w0.081: v2(21.75,60.97) 21.86,60.86 21.86,60.16 22.11,59.9 UT4.K4
  BOTTOM w0.089: 21.77,43.46 21.59,43.46 21.15,43.02 21.06,43.02 v2(21.05,43.04) 20.96,42.96 20.62,42.96 20.6,42.98 20.58,42.98
  BOTTOM w0.14: 20.58,42.98 20.36,42.98 RT45.2 ; RT232.1 21.25,63.69 21.25,63.58 v2(21.29,63.54)
TBT_LSTX: length 27
  IN2 w0.099: v2(21.05,42.43) 20.91,42.57 20.66,42.57 19.82,43.41 19.82,45.84 20.54,46.56 20.54,47.59 20.18,47.94 19.84,47.94 19.18,48.6 19.18,52.79 19.78,53.39 20.43,53.39 20.73,53.69 20.73,55.23 20.61,55.35 20.61,60.48 v2(21.77,61.64)
  BOTTOM w0.081: RT233.1 22.05,61.92 v2(21.77,61.64) 22.19,61.22 22.19,60.72 22.11,60.65 UT4.L4
  BOTTOM w0.089: 20.58,42.59 20.6,42.59 20.62,42.61 20.87,42.61 v2(21.05,42.43) 21.05,42.61 21.11,42.68 21.29,42.68 21.73,43.12 UT1.A5
  BOTTOM w0.14: RT44.2 20.36,42.59 20.58,42.59
TBT_PCIE_RBIAS: length 1.1
  TOP w0.381: RT1.1 28.03,37.63 v2(27.36,37.63)
  BOTTOM w0.089: UT1.N16 v2(27.36,37.63)
TBT_PCIE_WAKE#: length 412.1
  TOP w0.14: v2(308.46,24.51) RT5856.2 ; v2(73.17,3.07) 73.18,3.08 73.18,3.17 73.23,3.22 73.23,3.84 72.56,4.51 RT5849.2 72.54,4.65 RT5843.2
  IN1 w0.099: v2(81.79,34.8) 80.52,36.07 70.31,36.07 69.86,36.51 47.13,36.51 46.61,37.03 45.21,37.03 43.71,38.53 42.79,38.53 35.84,45.48 35.84,45.68 34.26,47.26 32.64,47.26 32.57,47.18 32.49,47.18 v2(32.47,47.17)
  IN2 w0.099: v2(116.71,33.71) 116.19,34.24 107.67,34.24 104.17,37.73 102.17,37.73 101.06,38.84 97.23,38.84 96.84,39.23 91.5,39.23 87.85,35.57 82.56,35.57 v2(81.79,34.8)
  IN3 w0.091: v2(73.17,3.07) 73.18,3.08 73.18,3.17 73.26,3.25 73.26,3.91 73.12,4.05 66.91,4.05 65.98,3.11 64.44,3.11 63.22,4.33 63.22,4.71 62.8,5.13 62.8,5.9 65.59,8.7 65.59,9.36 66.71,10.48 66.71,12.94 65.04,14.61 63.89,14.61 63.5,14.23 62.61,14.23 62.49,14.35 62.49,14.67 63.06,15.24 63.12,15.24 63.44,15.56 63.44,17.34 62.74,18.03 62.74,19.35 62.28,19.81 61.53,19.81 v2(61.41,19.69)
  IN4 w0.091: v2(61.41,19.69) 61.41,20.83 63.69,23.12 63.99,23.12 66.41,25.53 68.59,25.53 78.07,35.01 81.57,35.01 v2(81.79,34.8)
  IN5 w0.099: v2(124.68,18.39) 125.87,17.2 140.7,17.2 140.83,17.32 165.29,17.32 165.7,16.92 175.5,16.92 178.37,19.79 178.37,22.39 187.35,31.37 243.78,31.37 247.57,27.58 250.92,27.58 251.96,26.53 257.72,26.53 259.39,24.87 259.39,23.99 262.66,20.71 262.66,20.26 262.56,20.16 262.56,19.42 263.08,18.9 268.61,18.9 268.65,18.94 270.12,18.94 270.59,19.41 272.81,19.41 273.22,19.81 280.52,19.81 281.15,20.45 286.22,20.45 288.03,22.25 288.03,22.51 289.48,23.97 291.32,23.97 292.38,22.91 293.67,22.91 296.11,25.35 297.26,25.35 297.97,26.06 299.44,26.06 300.1,25.4 300.1,24.19 300.8,23.5 303.79,23.5 304.8,24.51 v2(308.46,24.51)
  BOTTOM w0.089: UT1.W1 30.25,45.15 30.56,45.45 30.56,46.03 30.23,46.36
  BOTTOM w0.14: v2(32.47,47.17) 32.44,47.17 32.26,47.35 31.6,48.01 31.31,48.01 31.31,48 31.04,48 30.47,47.43 30.47,46.92 30.21,46.66 RT22.2 30.1,46.48 30.23,46.36 ; v2(124.68,18.39) 124.1,17.81 110.29,17.81 109.53,18.57 107.47,18.57 107.09,18.95 107.09,20.63 105.79,21.92 105.79,22.61 105.17,23.23 105.17,24.4 106.17,25.4 106.17,28.05 107.22,29.1 110.41,29.1 111.57,30.25 111.96,30.25 112.56,30.84 115.02,30.84 116.71,32.54 v2(116.71,33.71)
TBT_POC_RST#: length 23.4
  TOP w0.14: DT29.2 30.73,49.59 30.99,49.59 31.41,49.18 RT244.1 32.44,49.18 RT202.2 32.45,49.59 32.58,49.72 v1(32.58,50.1) 32.54,50.1 v2(30.99,51.65)
  IN1 w0.089: v2(24.12,43.49) 24.12,43.73 25.84,45.45 25.84,46.36
  IN1 w0.099: v2(30.99,51.65) 30.39,51.65 28.8,53.24 25.68,53.24 24.15,51.71 24.15,49.34 25.15,48.33 25.15,47.2 25.84,46.51 25.84,46.43 25.84,46.43 25.84,46.36
  BOTTOM w0.089: UT1.F4 24.12,43.49 v2(24.12,43.49)
TBT_PWR_EN: length 1.2
  TOP w0.089: T5990.1 75.69,20.14 75.59,20.24 v2(75.59,20.26)
  BOTTOM w0.089: v2(75.59,20.26) 75.89,19.97 UH2.T48
TBT_RBIAS: length 1.2
  TOP w0.508: v2(24.77,42.17) 24.77,41.92 25.02,41.67 RT10.1
  BOTTOM w0.203: UT1.H6 25.08,42.48 v2(24.77,42.17)
TBT_RESET_N_EC: length 328.8
  TOP w0.14: v2(289.71,21.24) 289.66,21.24 288.67,22.23 RZ41.1 ; UE3.L8 v2(301.76,16.57) ; RT245.2 28.13,57.41 29.44,56.1 29.44,50.34 29.54,50.24 29.57,50.24 v6(29.81,50.01) 29.88,50.01 30.49,50.62 31.23,50.62 31.69,50.17 RT244.2 ; v2(276.35,15.42) v1(276.98,15.42)
  IN1 w0.089: 33.26,46.36 33.09,46.19 31.85,46.19 31.69,46.36
  IN1 w0.099: v6(29.81,50.01) 29.81,49.98 30.2,49.58 30.2,48.66 30.7,48.17 30.7,47.12 31.08,46.74 31.31,46.74 31.69,46.36 ; v2(40.74,39.55) 40.74,40.15 35.64,45.26 35.64,45.52 34.34,46.81 33.71,46.81 33.26,46.36
  IN2 w0.089: 79.67,29.21 79.67,28.28 79.62,28.24 v2(79.62,25.63)
  IN2 w0.099: 79.67,29.21 79.67,29.33 80.25,29.92 80.25,30.79 78.6,32.43 74.98,32.43 72.98,30.44 67.28,30.44 66.79,30.93 66.79,32.88 65.13,34.55 59.34,34.55 58.55,33.76 51.44,33.76 50.98,34.21 50.98,34.42 48.72,36.68 46.97,36.68 46.48,37.16 45.14,37.16 43.74,38.56 42.39,38.56 41.4,39.55 v2(40.74,39.55)
  IN3 w0.091: v2(276.35,15.42) 276.51,15.57 281.53,15.57 285.24,19.28 287.48,19.28 289.08,20.88 289.36,20.88 v2(289.71,21.24)
  IN5 w0.099: v2(301.76,16.57) 302.17,16.98 302.7,16.98 302.97,17.25 302.97,19.11 301.97,20.11 301.97,20.11 301.92,20.15 300.63,20.15 300.41,20.37 299.91,20.37 299.73,20.2 299.05,20.2 298.32,20.93 298.32,21.88 297.49,22.72 295.03,22.72 294.1,21.79 293.62,21.79 292.5,20.67 290.05,20.67 289.71,21.01 v2(289.71,21.24)
  IN6 w0.089: 101.98,13.63 99.35,13.63 98.71,14.27 98.64,14.27 97.67,15.24 95.63,15.24 95.03,15.84 95.03,17.19 94.54,17.68 93.71,17.68 90.03,21.36 82.65,21.36 81.35,22.66 81.35,23.67 80.36,24.66 80.2,24.66 79.62,25.24 v2(79.62,25.63)
  IN6 w0.099: 101.98,13.63 102.19,13.63 102.52,13.3 103.97,13.3 104.68,12.59 110.02,12.59 110.41,12.98 113.55,12.98 114.02,13.46 119.42,13.46 120.08,14.11 121.82,14.11 123.02,15.32 124.61,15.32 124.97,15.67 130.2,15.67 130.67,15.21 142.78,15.21 143.38,14.61 226.01,14.61 229.06,11.56 242.57,11.56 243.33,10.8 264.54,10.8 268.2,14.45 275.82,14.45 276.35,14.99 v2(276.35,15.42)
TBT_ROM_CLK: length 31.8
  TOP w0.14: v2(42.11,25.32) 42.11,24.31 v1(42.29,24.13)
  IN1 w0.089: 33.66,44.15 v2(33.28,44.53)
  IN1 w0.099: v2(42.11,25.32) 42.11,27.37 44.36,29.62 44.36,33.72 43.82,34.27 41.94,34.27 38.42,37.78 36.32,37.78 34.62,39.48 34.62,42.25 33.71,43.16 33.71,44.1 33.66,44.15
  BOTTOM w0.089: v2(33.28,44.53) 32.97,44.23 32.97,43.69 32.88,43.6 32.46,43.6 32.26,43.8 31.85,43.8 UT1.AB4
  BOTTOM w0.14: v2(42.11,25.32) 42.17,25.38 UT2.6
TBT_ROM_CS#: length 19.3
  TOP w0.14: v1(40.51,31.88) 40.09,32.3 RT18.2 39.23,32.3 38.69,32.84 v2(38.69,33.43)
  IN1 w0.089: v2(32.61,43.98) 32.49,43.86 32.49,42.58 33.59,41.48 33.59,39.24 33.66,39.18
  IN1 w0.099: v2(38.69,33.43) 38.69,35.91 37.6,37 36.36,37 34.49,38.86 33.97,38.86 33.66,39.18
  BOTTOM w0.089: UT1.AC3 32.55,44.04 v2(32.61,43.98)
  BOTTOM w0.14: v2(38.69,33.43) 38.69,32.94 39.47,32.16 UT2.1
TBT_ROM_DI: length 31.8
  TOP w0.14: v1(43.62,24.46) v2(43.62,25.3)
  IN1 w0.089: 33.66,44.83 33.42,45.06 v2(32.97,45.06)
  IN1 w0.099: v2(43.62,25.3) 43.62,27.12 44.66,28.16 44.66,34.08 43.93,34.81 41.9,34.81 38.63,38.08 36.45,38.08 34.93,39.6 34.93,42.71 34.18,43.46 34.18,44.31 33.66,44.83
  BOTTOM w0.076: v2(32.97,45.06) 32.91,45 32.91,44.43 32.81,44.33 32.31,44.33 32.23,44.26 31.85,44.26 UT1.AB3
  BOTTOM w0.14: v2(43.62,25.3) 43.69,25.38 43.69,26 UT2.5
TBT_ROM_DO: length 25.7
  TOP w0.14: RT16.2 38.94,27.77 v2(39.02,27.85)
  IN1 w0.089: 33.66,42.78 33.42,43.02 33.42,43.71 33.34,43.79 v2(33.34,43.81)
  IN1 w0.099: v2(41.37,32.88) 41.37,33.94 37.84,37.48 36.2,37.48 34.06,39.62 34.06,42.38 33.66,42.78
  IN2 w0.099: v2(39.02,27.85) 42.04,30.86 42.04,32.21 v2(41.37,32.88)
  BOTTOM w0.089: v2(33.34,43.81) 33.34,43.79 32.95,43.4 32.41,43.4 32.23,43.58 UT1.AC4
  BOTTOM w0.14: UT2.2 40.9,32.63 41.15,32.88 v2(41.37,32.88) v1(41.37,33.53)
TBT_ROM_HOLD#: length 1.7
  TOP w0.14: v2(40.9,25.25) 41.05,25.1 RT15.2
  BOTTOM w0.14: v2(40.9,25.25) UT2.7
TBT_ROM_WP#: length 25.8
  TOP w0.14: RT17.2 42.66,32.78 v2(42.76,32.88)
  IN1 w0.089: 33.66,38.74 32.96,39.43 32.96,40.72 32.21,41.47 32.21,43.17 29.98,45.4 v2(29.98,45.66)
  IN1 w0.099: 33.66,38.74 33.81,38.58 34.46,38.58 36.26,36.77 37.46,36.77 38.28,35.95 38.28,32.97 38.79,32.46 42.34,32.46 v2(42.76,32.88)
  BOTTOM w0.076: v2(29.98,45.66) 29.79,45.47 UT1.V1
  BOTTOM w0.14: UT2.3 42.17,32.6 42.44,32.88 v2(42.76,32.88) v1(42.76,33.49)
TBT_RSENSE: length 1.3
  TOP w0.508: v2(25.41,42.17) 25.93,41.65 RT10.2
  BOTTOM w0.203: UT1.J6 25.73,42.49 v2(25.41,42.17)
TBT_SRC_CFG1: length 5.5
  TOP w0.14: v1(33.34,47.66) 33.61,47.39 RT107.2 33.82,46.62 v2(34.18,46.27)
  BOTTOM w0.089: 33.66,46.11 33.45,45.91 33.06,45.91 32.84,45.69 32.02,45.69 31.75,45.43 31.47,45.43 31.17,45.13 UT1.AA1
  BOTTOM w0.14: 33.66,46.11 34.04,46.11 34.18,46.26 v2(34.18,46.27)
TBT_TEST_EN: length 4.6
  TOP w0.14: v2(25.07,46.25) 25.28,46.46 25.28,48.01 25.09,48.19 RT3.2
  BOTTOM w0.102: UT1.E1 23.81,45.28 23.75,45.34 23.75,45.7 24.02,45.96 24.19,45.96 24.39,46.15 24.97,46.15 v2(25.07,46.25)
TBT_TEST_PWRG: length 3.2
  BOTTOM w0.089: 33.66,43.14 33.62,43.1 v1(33.62,43.02) 33.5,42.9 31.85,42.9 31.64,43.12 UT1.AB5
  BOTTOM w0.14: RT4.2 34.21,43.69 33.66,43.14
TBT_TMU_CLK_OUT: length 3
  BOTTOM w0.089: UT1.V2 30.02,44.73 30.02,45.19 30.35,45.52 30.35,45.85 30.1,46.1 29.72,46.1 29.47,46.36
  BOTTOM w0.14: 29.47,46.36 RT37.2
TBT_USB2_D+: length 35.6
  IN2 w0.099: 22.52,36.4 23.32,35.6 23.81,35.6 23.91,35.71 v4(24.11,35.71)
  IN2 w0.107: v2(21.87,64.1) 22.23,64.1 22.34,63.99 22.34,63.51 21.41,62.57 20.17,62.57 17.88,60.29 17.88,55.52 18.37,55.03 18.37,48.23 19,47.59 19,42.15 21.07,40.08 21.07,37.85 22.52,36.4
  BOTTOM w0.089: v4(24.11,35.71) 23.82,36 UT1.E20
  BOTTOM w0.152: RT1141.1 21.92,64.15 v2(21.87,64.1)
TBT_USB2_D-: length 35.6
  IN2 w0.099: v2(23.46,36.32) 23.59,36.32 23.82,36.1 23.82,35.91 23.7,35.8 23.41,35.8 22.67,36.55
  IN2 w0.107: 22.67,36.55 21.27,37.94 21.27,40.17 19.2,42.24 19.2,47.68 18.57,48.31 18.57,55.12 18.09,55.6 18.09,60.2 20.25,62.37 21.49,62.37 22.54,63.42 22.54,63.99 22.65,64.1 v2(23.01,64.1)
  BOTTOM w0.089: v2(23.46,36.32) UT1.D20
  BOTTOM w0.152: v2(23.01,64.1) 22.96,64.15 RT1142.1
TBT_USB3_RX0_N: length 48.3
  TOP w0.097: v2(10.19,70.47) 10.32,70.59 arc(10.46,70.69) 10.63,70.72 10.7,70.72 10.89,70.72 arc(11.57,70.59) 12.15,70.2 12.97,69.38 arc(13.63,68.94) 14.41,68.78 14.5,68.78 arc(15.33,68.62) 16.03,68.15 17.22,66.96 arc(17.53,66.5) 17.64,65.95 17.64,63.74 arc(17.67,63.55) 17.78,63.4 17.87,63.3 arc(18.19,62.82) 18.31,62.26 18.31,58.64 arc(18.4,58.15) 18.68,57.74 arc(18.8,57.56) 18.84,57.35 18.84,52.56 arc(18.87,52.39) 18.97,52.25 19.03,52.19 arc(19.1,52.09) 19.12,51.97 19.12,48.68 arc(19.16,48.46) 19.29,48.28 arc(19.3,48.26) 19.31,48.23 19.31,42.45 arc(19.31,42.32) 19.34,42.2 19.7,41.03 arc(19.78,40.67) 19.8,40.31 19.8,36.11 arc(19.78,35.99) 19.71,35.89 19.56,35.74 arc(19.49,35.69) 19.42,35.68 19.25,35.68 arc(19.18,35.69) 19.11,35.71 arc(19.02,35.78) 18.99,35.89 v2(18.99,35.95)
  BOTTOM w0.097: JUSBC1.B10 6.35,68.41 arc(6.41,68.45) 6.48,68.46 6.88,68.46 arc(7.1,68.51) 7.29,68.63 8.17,69.51 arc(8.31,69.72) 8.36,69.97 8.36,70.25 8.36,70.25 arc(8.39,70.37) 8.46,70.47 8.61,70.62 arc(8.7,70.69) 8.81,70.71 9.1,70.71 arc(9.17,70.69) 9.23,70.65 DT21.1 9.56,70.65 arc(9.63,70.69) 9.71,70.71 9.91,70.71 arc(9.94,70.7) 9.97,70.68 v2(10.19,70.47) ; v2(18.99,35.95) 18.99,35.85 arc(19.03,35.75) 19.13,35.71 19.58,35.71 arc(19.68,35.74) 19.71,35.84 RT5835.1
TBT_USB3_RX0_N_R: length 2.4
  BOTTOM w0.089: UT1.A21 22.06,35.76 arc(22.11,35.77) 22.16,35.8 22.16,35.8 arc(22.18,35.83) 22.19,35.87 22.19,35.89 arc(22.18,35.93) 22.16,35.96 22.15,35.96 arc(22.11,35.99) 22.07,36 21.91,36 arc(21.81,35.98) 21.72,35.92 arc(21.66,35.88) 21.59,35.87 21.53,35.87 arc(21.35,35.83) 21.2,35.73 arc(21.19,35.73) 21.18,35.72 20.74,35.72 arc(20.53,35.76) 20.35,35.88 RT5835.2
TBT_USB3_RX0_P: length 48.4
  TOP w0.097: v2(18.99,35.32) 19.08,35.41 arc(19.17,35.47) 19.28,35.49 19.42,35.49 arc(19.57,35.52) 19.69,35.61 19.75,35.66 19.84,35.76 arc(19.95,35.92) 19.99,36.11 19.99,40.31 arc(19.96,40.7) 19.88,41.09 19.52,42.26 arc(19.5,42.35) 19.49,42.45 19.49,48.23 arc(19.47,48.33) 19.42,48.41 arc(19.33,48.53) 19.31,48.68 19.31,51.97 arc(19.27,52.16) 19.16,52.32 19.1,52.38 arc(19.04,52.46) 19.03,52.56 19.03,57.35 arc(18.97,57.63) 18.81,57.87 18.81,57.87 arc(18.57,58.22) 18.49,58.64 18.49,62.26 arc(18.37,62.89) 18,63.43 17.91,63.53 arc(17.85,63.63) 17.82,63.74 17.82,65.95 arc(17.7,66.57) 17.35,67.09 16.16,68.28 arc(15.4,68.79) 14.5,68.97 14.41,68.97 arc(13.7,69.11) 13.1,69.51 12.28,70.33 arc(11.64,70.76) 10.89,70.91 10.7,70.91 10.63,70.91 arc(10.44,70.94) 10.28,71.05 v2(10.19,71.14)
  BOTTOM w0.097: JUSBC1.B11 6.11,68.65 arc(6.12,68.65) 6.12,68.65 6.88,68.65 arc(7.03,68.68) 7.16,68.76 8.04,69.65 arc(8.14,69.8) 8.18,69.97 8.18,70.25 arc(8.22,70.44) 8.32,70.6 8.48,70.76 arc(8.63,70.86) 8.81,70.89 9.1,70.89 arc(9.17,70.91) 9.22,70.94 9.4,71.12 ; 9.4,71.12 DT20.1 ; 9.4,71.12 9.57,70.95 arc(9.63,70.91) 9.7,70.9 9.88,70.9 arc(9.94,70.91) 10,70.94 v2(10.19,71.14) ; v2(18.99,35.32) 19.14,35.47 arc(19.2,35.51) 19.26,35.52 19.48,35.52 arc(19.56,35.51) 19.62,35.46 RT5834.1
TBT_USB3_RX0_P_R: length 2.4
  BOTTOM w0.089: UT1.B21 22.26,35.59 arc(22.2,35.55) 22.14,35.54 21.88,35.54 arc(21.82,35.55) 21.77,35.58 21.69,35.66 arc(21.66,35.68) 21.62,35.69 21.53,35.69 arc(21.42,35.67) 21.33,35.61 arc(21.26,35.56) 21.18,35.55 20.54,35.55 arc(20.48,35.53) 20.43,35.5 RT5834.2
TBT_USB3_RX1_N: length 34.5
  TOP w0.097: JUSBC1.A10 8.29,64.56 arc(8.39,64.54) 8.47,64.49 8.51,64.44 arc(8.57,64.4) 8.64,64.39 8.66,64.39 arc(8.76,64.37) 8.85,64.31 9.06,64.1 arc(9.14,64.05) 9.24,64.03 10.1,64.03 arc(10.17,64.04) 10.23,64.08 arc(10.32,64.14) 10.43,64.16 10.77,64.16 arc(10.95,64.2) 11.11,64.3 DT18.1 11.29,64.25 arc(11.31,64.24) 11.34,64.23 11.36,64.22 11.66,64.22 arc(12.03,64.15) 12.34,63.94 12.4,63.88 arc(12.6,63.75) 12.84,63.7 13.74,63.7 arc(14.81,63.49) 15.72,62.88 16.16,62.44 arc(16.59,61.8) 16.74,61.05 16.74,54.36 arc(16.76,54.25) 16.83,54.15 17.29,53.68 arc(17.4,53.52) 17.44,53.32 17.44,51.69 arc(17.47,51.53) 17.56,51.4 17.57,51.4 arc(17.68,51.22) 17.72,51.02 17.72,48.43 arc(17.73,48.27) 17.74,48.12 17.75,48.01 arc(17.76,47.84) 17.77,47.68 17.77,41.57 arc(17.8,41.4) 17.9,41.25 17.9,41.25 arc(18.11,40.94) 18.18,40.57 18.18,40.48 arc(18.16,40.34) 18.08,40.23 18.03,40.17 arc(17.92,40.1) 17.79,40.08 arc(17.71,40.06) 17.64,40.01 v2(17.5,39.87)
  BOTTOM w0.097: v2(17.5,39.87) 18.23,39.87 arc(18.36,39.9) 18.46,39.97 arc(18.53,40.01) 18.6,40.03 RT5833.1
TBT_USB3_RX1_N_R: length 3.4
  BOTTOM w0.097: UT1.B15 22.32,38.41 arc(22.19,38.32) 22.05,38.29 21.91,38.29 arc(21.81,38.31) 21.73,38.37 20.1,40 arc(20.08,40.01) 20.05,40.02 20.05,40.02 arc(20.04,40.03) 20.03,40.03 RT5833.2
TBT_USB3_RX1_P: length 34.5
  TOP w0.097: v2(17.5,40.51) 17.5,40.4 arc(17.54,40.3) 17.64,40.26 17.79,40.26 arc(17.85,40.27) 17.9,40.31 17.95,40.36 arc(17.98,40.41) 18,40.48 18,40.57 arc(17.94,40.87) 17.77,41.12 arc(17.63,41.33) 17.58,41.57 17.58,47.68 arc(17.58,47.83) 17.57,47.99 17.55,48.1 arc(17.54,48.27) 17.54,48.43 17.54,51.02 arc(17.51,51.15) 17.43,51.27 arc(17.3,51.46) 17.26,51.69 17.26,53.32 arc(17.23,53.45) 17.16,53.55 16.69,54.02 arc(16.59,54.18) 16.55,54.36 16.55,61.05 arc(16.42,61.73) 16.03,62.3 15.59,62.75 arc(14.74,63.32) 13.74,63.52 12.84,63.52 arc(12.53,63.58) 12.27,63.75 12.21,63.81 arc(11.96,63.98) 11.66,64.04 11.56,64.04 11.46,63.97 arc(11.45,63.96) 11.44,63.95 DT19.1 11,63.86 arc(10.88,63.95) 10.73,63.98 10.43,63.98 arc(10.39,63.97) 10.36,63.95 10.36,63.95 arc(10.24,63.87) 10.1,63.84 9.24,63.84 arc(9.07,63.87) 8.93,63.97 8.72,64.18 arc(8.69,64.2) 8.66,64.21 8.59,64.21 arc(8.55,64.2) 8.52,64.18 8.45,64.1 arc(8.4,64.07) 8.35,64.06 JUSBC1.A11
  BOTTOM w0.097: v2(17.5,40.51) 17.92,40.09 arc(17.95,40.07) 17.99,40.06 18.23,40.06 arc(18.29,40.07) 18.33,40.1 18.33,40.1 arc(18.45,40.18) 18.6,40.21 18.82,40.21 arc(18.88,40.22) 18.93,40.26 RT5832.1
