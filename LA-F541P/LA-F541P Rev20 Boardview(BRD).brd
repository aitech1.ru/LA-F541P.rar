# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CFG19: length 30.1
  TOP w0.089: v2(138.43,74.95) 137.73,74.26 v5(137.73,74.03)
  TOP w0.14: JXDP.22 123.71,91.01 v2(124.12,90.6)
  IN2 w0.102: v2(138.43,74.95) 137.72,75.67 130.55,75.67 124.97,81.25 124.97,81.25 124.89,81.33 124.89,83.11 123.22,84.78 123.22,89.8 124.02,90.6 v2(124.12,90.6)
  BOTTOM w0.076: v2(138.43,74.95) 138.75,75.28 UH1.BP22
CFG_RCOMP: length 6.3
  BOTTOM w0.254: UH1.BT25 137.06,77.31 v1(133.61,77.31) 132.7,77.31 131.99,78.03 RH59.1
CHG_BGATE: length 21.5
  TOP w0.203: PC1933.1 42.67,19.18 43.31,18.54 v1(43.37,18.54) 43.92,18.54 44.69,17.77 47.39,17.77 47.51,17.64 PU1900.32
  TOP w0.381: PC1933.1 42.75,19.51 v2(43.49,19.51)
  IN4 w0.508: v2(43.49,19.51) 41.78,21.21 32.83,21.21 32.35,20.73 31.72,20.73 31.37,21.08 v2(31.37,21.34)
  BOTTOM w0.381: v2(31.37,21.34) 31.33,21.38 PQ1905.4
CHR_USB20_N1: length 3.8
  BOTTOM w0.152: UI2.11 330.07,66.22 329.9,66.39 329.9,66.64 329.6,66.94 v3(329.1,66.94) 328.18,66.94 328.01,67.11 328.01,67.52 328.09,67.6 LI2.1
CHR_USB20_N1_R: length 16.7
  IN3 w0.099: v2(328.85,71.67) 329.04,71.85 329.69,71.85 330.24,72.4 330.24,74.07 331.21,75.05 332.38,75.05 334.06,73.36 334.61,73.36 335.52,72.45 JUSB2.2
  BOTTOM w0.152: LI2.2 328.09,69.39 328.01,69.48 328.01,69.74 327.79,69.96 327.79,70.19 D124.1 328.14,70.84 327.96,71.02 327.51,71.02 327.45,71.08 327.45,71.54 327.58,71.67 327.72,71.8 328.73,71.8 v2(328.85,71.67)
CHR_USB20_N2: length 8.4
  BOTTOM w0.152: UI1.11 26.54,102.03 26.01,102.56 25.06,102.56 24.45,101.95 v3(23.99,101.95) 21.38,101.95 21.08,101.65 21.08,101.34 20.83,101.1 LI5.1
CHR_USB20_N2_R: length 12.5
  IN2 w0.107: JUSB1.2 14.68,103.94 15.88,102.74 16.89,102.74 17.48,102.16 17.48,99.42 18.08,98.82 18.94,98.82 v2(19.18,99.06)
  BOTTOM w0.152: v2(19.18,99.06) 19.44,98.8 19.62,98.8 D126.1 19.98,98.9 19.98,98.48 20.1,98.36 20.32,98.36 20.53,98.57 20.9,98.57 21,98.68 21,98.86 20.83,99.03 LI5.2
CHR_USB20_P1: length 3.8
  BOTTOM w0.152: LI2.4 327.59,67.58 327.68,67.49 327.68,66.87 v1(327.73,66.83) 327.94,66.61 329.46,66.61 329.57,66.51 UI2.10
CHR_USB20_P1_R: length 16.7
  IN3 w0.099: v2(328.85,72.25) 329.07,72.04 329.61,72.04 330.05,72.48 330.05,74.15 331.13,75.24 332.46,75.24 334.14,73.55 334.56,73.55 335.45,74.45 JUSB2.3
  BOTTOM w0.152: LI2.3 327.59,69.39 327.68,69.47 327.68,69.6 327.46,69.82 327.46,70.2 327.11,70.54 D123.1 327.12,70.56 327.12,71.67 v3(327.35,71.9) 327.58,72.13 328.73,72.13 v2(328.85,72.25)
CHR_USB20_P2: length 8.4
  BOTTOM w0.152: LI5.4 21.98,100.58 22.11,100.71 22.11,100.95 21.99,101.08 21.65,101.08 21.41,101.31 21.41,101.51 21.52,101.62 v3(21.78,101.62) 24.59,101.62 25.19,102.23 25.87,102.23 26.12,101.98 26.12,101.62 26.04,101.54 UI1.10
CHR_USB20_P2_R: length 12.5
  IN2 w0.107: v2(19.18,98.43) 19.18,98.43 18.98,98.62 18,98.62 17.27,99.34 17.27,102.08 16.81,102.54 15.8,102.54 14.96,101.7 14.77,101.7 14.68,101.79 JUSB1.3
  BOTTOM w0.152: v2(19.18,98.43) 19.37,98.43 D125.1 19.94,98.03 20.46,98.03 20.66,98.24 21.03,98.24 21.33,98.54 LI5.3
CLINK_CLK: length 334.3
  IN3 w0.089: 101.86,11.91 101.98,11.91 ; 101.79,11.84 101.77,11.82 101.77,11.82 101.61,11.66 101.61,11.66 101.44,11.48 100.62,11.48 100.3,11.17 100.3,10.96 v2(100.1,10.76)
  IN3 w0.091: 101.98,11.91 102.63,11.91 103.78,13.06 108.6,13.06 109.11,13.56 112.22,13.56 113.74,15.09 119.45,15.09 120.42,14.12 125.14,14.12 135.26,14.12 136.06,13.31 137.98,13.31 138.3,13 143.52,13 143.68,13.16 151.2,13.16 151.39,12.96 176.56,12.96 177.34,12.18 185.06,12.18 186.12,13.24 192.38,13.24 192.55,13.41 198.62,13.41 199.03,13 199.03,12.09 199.26,11.85 214.4,11.85 214.78,11.47 259.16,11.47 261.47,13.78 265.13,13.78 266.08,14.73 268.05,14.73 270.32,17.01 281.11,17.01 286.56,22.46 288.3,22.46 289.88,24.04 293.24,24.04 294.49,25.28 297.53,25.28 298.69,26.45 298.75,26.5 301.06,26.5 301.47,26.92 301.47,27.25 302.78,28.56 302.9,28.56 304.09,29.75 305.39,31.05 307.07,31.05 309.36,33.35 311.28,33.35 313.08,31.55 323.2,31.55 323.85,30.9 327.67,30.9 329.77,33 336.41,33 338.76,35.35 341.3,35.35 342,36.05 343.89,36.05 344.23,36.38 344.23,38.05 344.05,38.22 344.05,43.29 343.81,43.53 342.68,43.53 342.26,43.11 339.3,43.11 338.69,43.72 338.69,46.83 335.73,49.79 335.73,53.17 335.6,53.3 331.75,57.15 331.75,58.64 330.86,59.53 330.86,62.02 327.4,65.48 327.4,73.13 329.61,75.35 329.61,77.78 331.33,79.49 331.33,81.6 337.87,88.14 337.87,90.05 338.32,90.5 338.65,90.5 338.8,90.65 v2(338.8,90.71) ; 101.79,11.84 101.86,11.91
  BOTTOM w0.089: UH2.AR2 98.47,10.31 98.61,10.45 99.8,10.45 v2(100.1,10.76)
  BOTTOM w0.14: v2(338.8,90.71) JNGFF1.34
CLINK_DATA: length 336.9
  IN3 w0.089: v2(100.7,10.76) 100.65,10.81 100.65,11.02 100.81,11.19 101.56,11.19 101.91,11.54 101.91,11.54 101.98,11.61 101.98,11.61
  IN3 w0.091: 101.98,11.61 102.75,11.61 103.9,12.76 108.73,12.76 109.18,13.22 112.36,13.22 113.88,14.74 119.3,14.74 120.23,13.82 135,13.82 135.8,13.02 137.86,13.02 138.18,12.7 143.64,12.7 143.8,12.86 151.08,12.86 151.32,12.62 176.42,12.62 177.2,11.84 185.21,11.84 186.26,12.89 192.45,12.89 192.67,13.11 198.49,13.11 198.73,12.87 198.73,11.96 199.14,11.56 214.12,11.56 214.5,11.18 259.28,11.18 261.6,13.49 265.25,13.49 266.2,14.44 268.17,14.44 270.39,16.66 281.18,16.66 286.68,22.16 288.42,22.16 290,23.74 293.36,23.74 294.61,24.99 297.65,24.99 298.82,26.16 301.13,26.16 301.27,26.29 301.77,26.8 301.77,27.13 302.9,28.26 303.02,28.26 304.38,29.63 305.52,30.76 307.19,30.76 309.48,33.05 311.16,33.05 312.96,31.25 323.08,31.25 323.72,30.61 327.79,30.61 329.89,32.71 336.61,32.71 338.9,35 341.44,35 342.14,35.7 344.04,35.7 344.57,36.24 344.57,38.19 344.4,38.36 344.4,43.44 343.95,43.88 342.54,43.88 342.12,43.46 339.45,43.46 339.04,43.87 339.04,46.97 336.07,49.94 336.07,53.32 335.85,53.54 332.09,57.3 332.09,58.78 331.21,59.67 331.21,62.16 327.74,65.62 327.74,72.99 329.96,75.21 329.96,77.64 331.67,79.35 331.67,81.46 338.21,88 338.21,89.91 338.46,90.15 338.63,90.15 338.81,89.97 v2(338.81,89.9)
  BOTTOM w0.089: v2(100.7,10.76) 100.47,10.52 100.47,10.5 100.25,10.27 98.79,10.27 98.61,10.09 98.1,10.09 98.02,10.01 97.21,10.01 UH2.AT5
  BOTTOM w0.14: JNGFF1.32 338.3,90.41 v2(338.81,89.9)
CLINK_RST#: length 363.6
  TOP w0.14: v1(314.62,5.47) 314.36,5.47 313.72,6.12 v2(313.72,6.44)
  IN2 w0.099: v2(337.8,90.6) 338.94,91.73 341.54,91.73 342.07,91.21 342.07,88.86 342.67,88.26 342.67,86.41 340.73,84.47 338.97,84.47 334.65,80.15 334.65,67.44 337.89,64.2 339.23,64.2 341.17,62.26 341.17,51.98 345.47,47.67 345.47,40.69 344.57,39.79 344.57,35.16 342.53,33.12 340.4,33.12 339.52,32.24 330.39,32.24 327.38,29.23 327.38,27.97 318.25,18.83 316.56,18.83 315.09,17.36 315.09,14.45 316.36,13.18 316.36,9.52 313.72,6.87 v2(313.72,6.44)
  IN5 w0.089: 101.98,7.24 101.92,7.18 99.48,7.18 98.88,7.77 98.01,7.77 v2(97.52,8.26)
  IN5 w0.099: v2(313.72,6.44) 313.43,6.15 313.43,5.28 312.98,4.82 312.16,4.82 311.91,5.08 311.91,6 312.16,6.25 312.16,6.68 311.95,6.89 311.52,6.89 311.3,6.67 307.37,6.67 306.65,7.39 304.52,7.39 304.43,7.31 299.7,7.31 299.17,6.78 297.46,6.78 296.97,6.29 296.97,5.34 296.44,4.81 289.49,4.81 288.96,5.34 287.48,5.34 286.63,6.19 283.01,6.19 281.96,5.14 275.23,5.14 274.27,6.11 268.76,6.11 268.29,6.57 263.5,6.57 262.99,6.06 258.41,6.06 257.4,7.07 244.64,7.07 243.64,6.07 214.01,6.07 210.65,9.42 205.43,9.42 203.76,7.75 197.56,7.75 197.27,7.47 196.12,7.47 193.76,5.11 188.46,5.11 187.51,6.07 182.62,6.07 181.6,5.05 177.91,5.05 177.16,5.8 159.75,5.8 159.41,5.46 156.31,5.46 156.07,5.7 147.74,5.7 145.06,8.38 142.27,8.38 139.17,5.28 133.1,5.28 132.44,5.94 131.34,5.94 131.05,5.66 131.05,3.35 130.65,2.94 127.2,2.94 126.29,3.85 120.67,3.85 118.03,6.49 111.42,6.49 110.37,5.45 105.86,5.45 104.06,7.24 101.98,7.24
  BOTTOM w0.076: v2(97.52,8.26) 97.63,8.38 97.95,8.38 98.06,8.49 98.06,8.96 98.16,9.06 98.16,9.25 98.04,9.37 97.88,9.37 UH2.AU4
  BOTTOM w0.14: v2(337.8,90.6) JNGFF1.30
CLK_PCIE_N3: length 319.8
  IN2 w0.089: 101.58,21.59 101.56,21.58 101.55,21.58 100.98,21 100.45,21 99.74,20.3 99.74,19.88 98.61,18.75 98.61,17.07 97.78,16.24 96.33,16.24 96.26,16.17 96.26,15.97 v2(96.43,15.8)
  IN2 w0.107: 101.58,21.59 102.74,22.75 104.11,22.75 104.75,23.39 104.75,24.54 107.27,27.06 108.87,27.06 109.14,26.79 129.45,26.79 130.56,25.68 130.56,23.8 134.16,20.19 138.52,20.19 139.41,19.31 154.28,19.31 155.07,18.52 155.07,18.13 157.85,15.34 230.45,15.34 231.87,16.77 232.44,16.77 233.38,17.7 233.38,18.59 234.22,19.43 250.92,19.43 251,19.36 253.28,19.36 255.49,17.15 256.31,17.15 257.13,17.97 281.65,17.97 288.11,24.42 289.29,24.42 290.33,25.46 291.42,25.46 292.2,26.25 295.66,26.25 296.4,25.52 297.42,25.52 301.93,30.02 305.88,30.02 309.03,33.17 310.62,33.17 315.16,37.72 316.42,37.72 317.95,39.24 327.31,39.24 332.16,44.1 333.84,44.1 338.17,48.42 338.17,62.77 334.04,66.91 334.04,80.9 337.33,84.2 337.33,85.77 338.38,86.82 338.99,86.82 339.72,86.09 340.2,86.09 340.43,86.33 340.43,86.72 v2(340.61,86.89)
  BOTTOM w0.089: UH2.AE6 96.43,15.52 v2(96.43,15.8)
  BOTTOM w0.152: v2(340.61,86.89) 340.47,86.75 340.47,85.23 340.55,85.15 JNGFF1.41
CLK_PCIE_N4: length 261.5
  IN2 w0.089: 101.98,18.17 101.96,18.17 101.95,18.16 101.68,18.16 101.41,17.88 101.41,16.89 101.14,16.62 100.97,16.62 100.63,16.96 v2(100.63,17.02)
  IN2 w0.107: 101.98,18.17 102.42,18.17 102.92,18.67 102.92,19.44 103.62,20.14 105.26,20.14 105.32,20.2 130.77,20.2 133.65,17.32 140.67,17.32 143.39,14.6 151.17,14.6 152.35,13.42 177.89,13.42 177.93,13.47 183.64,13.47 183.96,13.15 198.53,13.15 198.89,13.5 214.25,13.5 214.59,13.16 218.05,13.16 219.63,11.57 251.77,11.57 253.94,13.74 256.25,13.74 257.22,14.71 263.3,14.71 264.05,15.46 264.05,16.68 264.86,17.5 267.17,17.5 267.79,16.88 272.1,16.88 272.45,17.23 281.61,17.23 287.37,22.99 288.87,22.99 290.26,24.39 293.65,24.39 294.37,25.1 298.17,25.1 299.8,26.72 300.88,26.72 303.32,29.16 306.24,29.16 309.01,31.93 325.4,31.93 326.75,33.28 331.01,33.28 331.2,33.08 336.17,33.08 336.36,33.28 339.4,33.28 339.78,33.66 339.78,33.98 v2(339.29,34.47)
  BOTTOM w0.089: UH2.AC2 98.27,16.51 98.27,16.59 98.32,16.65 98.51,16.65 98.71,16.46 98.8,16.46 99.18,16.83 99.72,16.83 99.85,16.7 100.38,16.7 100.63,16.95 v2(100.63,17.02)
  BOTTOM w0.152: UR1.6 339.38,35.1 339.45,35.03 339.45,34.62 339.3,34.47 v2(339.29,34.47)
CLK_PCIE_N5: length 102.6
  IN1 w0.076: 75.06,21.25 75.07,21.25 75.08,21.24 75.14,21.24 75.15,21.22 75.46,21.22 76.45,20.23 76.45,19.25 77.54,18.16 79.99,18.16 81.32,16.84 83.33,16.84 84.63,18.13 90.2,18.13 90.37,18.31 98.43,18.31 99.06,17.69 99.47,17.69 v2(99.73,17.95)
  IN1 w0.089: 33.02,33.53 33.02,33.55 33.01,33.56 33.01,33.93 32.7,34.24 32.7,34.73 32.14,35.29 32.14,36.83 31.44,37.52 29.57,37.52 28.96,36.91 28.96,36.63 v2(28.66,36.32)
  IN1 w0.107: 33.02,33.53 33.02,32.29 33.73,31.58 33.73,31.24 32.07,29.57 32.07,29.4 32.32,29.14 32.51,29.14 34.17,30.8 34.52,30.8 34.89,30.43 34.89,30.08 34.4,29.59 34.4,29.41 34.65,29.15 34.83,29.15 35.32,29.64 39.42,29.64 40.13,28.93 40.13,26.24 39.68,25.78 39.68,24.82 40.73,23.77 44.91,23.77 46.29,25.15 47.49,25.15 47.94,25.6 47.94,26.88 48.2,27.14 48.82,27.14 49.13,26.83 49.13,25.85 49.39,25.6 52.6,25.6 53.01,26.01 53.6,26.01 53.88,26.29 56.45,26.29 57.2,25.55 57.2,24.03 57.75,23.48 64.08,23.48 64.59,22.96 64.59,22.59 66.29,20.9 69.91,20.9 70.06,20.75 71.1,20.75 72.18,21.84 74.11,21.84 74.69,21.25 75.06,21.25
  BOTTOM w0.089: v2(99.73,17.95) 99.37,17.58 99.37,17.5 99.22,17.35 98.7,17.35 UH2.AB2
  BOTTOM w0.102: UT1.T19 v2(28.66,36.32)
CLK_PCIE_N6: length 181
  IN2 w0.089: v2(99.24,18.26) 99.43,18.45 100.05,18.45 100.43,18.84 101.95,20.36 101.97,20.36 101.98,20.38
  IN2 w0.107: 101.98,20.38 103.6,21.99 106.47,21.99 107.52,20.95 131.9,20.95 133.29,19.56 138.02,19.56 138.69,18.89 138.69,18.22 139.14,17.76 141.96,17.76 142.42,17.3 154.83,17.3 157.4,14.73 230.72,14.73 231.43,15.43 238.16,15.43 238.6,14.99 252.58,14.99 253.29,14.28 255.86,14.28 258.44,16.85 260.84,16.85 261.15,16.55 262.31,16.55 262.47,16.39 262.47,16.25 262.39,16.17 262.16,16.17 262.09,16.09 v2(262.09,15.87)
  BOTTOM w0.089: v2(99.24,18.26) 99.08,18.43 98.9,18.43 98.5,18.03 97.49,18.03 UH2.W4
  BOTTOM w0.152: v2(262.09,15.87) 262.22,15.74 262.22,14.82 262.68,14.36 262.68,10.97 261.68,9.97 261.28,9.97 261.2,10.04 JNGFF2.53
CLK_PCIE_N7: length 147.6
  IN6 w0.107: v2(197.44,68.15) 197.19,68.39 196.95,68.39 196.75,68.59 196.13,68.59 193.38,65.84 193.38,55.99 194.11,55.27 194.11,39.6 183.52,29.01 183.52,27.42 181.41,25.32 181.41,20.73 179.72,19.04 172.23,19.04 170.36,17.17 165.93,17.17 165.58,17.53 122.56,17.53 121.57,16.54 112.66,16.54 110.97,14.84 110.68,14.84 110.3,14.47 106.62,14.47 106.31,14.78 103.28,14.78 102.21,15.85 100.18,15.85 99.87,16.16 99.87,16.38 99.64,16.61 98.87,16.61 97.46,18.03 96.45,18.03 96.08,18.4 96.07,18.46 96.04,18.62 v2(95.83,18.76)
  BOTTOM w0.089: UH2.W7 96.01,18.4 96.01,18.58 v2(95.83,18.76)
  BOTTOM w0.102: UV18.AK13 v2(197.44,68.15)
CLK_PCIE_P3: length 319.7
  IN2 w0.089: 101.43,21.74 101.42,21.72 101.42,21.71 100.9,21.19 100.37,21.19 99.56,20.38 99.56,19.95 98.43,18.82 98.43,17.15 97.7,16.42 96.25,16.42 96.08,16.24 96.08,16.02 v2(95.85,15.79)
  IN2 w0.107: v2(339.93,86.87) 340.23,86.57 340.23,86.42 340.11,86.3 339.8,86.3 339.08,87.02 338.29,87.02 337.13,85.86 337.13,84.28 333.83,80.99 333.83,66.82 337.96,62.69 337.96,48.51 333.76,44.3 332.07,44.3 327.22,39.45 317.86,39.45 316.34,37.92 315.08,37.92 310.53,33.38 308.94,33.38 305.79,30.23 301.85,30.23 297.34,25.72 296.48,25.72 295.75,26.46 292.12,26.46 291.33,25.67 290.25,25.67 289.21,24.63 288.02,24.63 281.57,18.17 257.05,18.17 256.23,17.35 255.58,17.35 253.37,19.56 251.08,19.56 251,19.64 234.14,19.64 233.17,18.67 233.17,17.78 232.36,16.97 231.79,16.97 230.36,15.55 157.94,15.55 155.27,18.21 155.27,18.6 154.37,19.51 139.5,19.51 138.61,20.4 134.25,20.4 130.76,23.89 130.76,25.76 129.53,26.99 109.23,26.99 108.95,27.26 107.19,27.26 104.55,24.62 104.55,23.48 104.02,22.96 102.65,22.96 101.43,21.74
  BOTTOM w0.089: UH2.AE7 95.85,15.33 v2(95.85,15.79)
  BOTTOM w0.152: v2(339.93,86.87) 340.14,86.66 340.14,85.23 340.05,85.14 JNGFF1.39
CLK_PCIE_P4: length 261.6
  IN2 w0.089: 101.98,17.96 101.96,17.96 101.95,17.97 101.76,17.97 101.6,17.81 101.6,16.82 101.22,16.44 v2(100.63,16.44)
  IN2 w0.107: 101.98,17.96 102.51,17.96 103.13,18.58 103.13,19.36 103.71,19.94 105.35,19.94 105.4,20 130.69,20 133.56,17.12 140.58,17.12 143.3,14.4 151.08,14.4 152.26,13.22 177.97,13.22 178.02,13.26 183.55,13.26 183.88,12.94 198.62,12.94 198.97,13.3 214.16,13.3 214.5,12.96 217.96,12.96 219.55,11.37 251.86,11.37 254.03,13.54 256.34,13.54 257.3,14.5 263.38,14.5 264.25,15.37 264.25,16.6 264.95,17.3 267.09,17.3 267.71,16.68 272.18,16.68 272.53,17.03 281.7,17.03 287.45,22.78 288.95,22.78 290.35,24.18 293.74,24.18 294.45,24.89 298.26,24.89 299.88,26.52 300.97,26.52 303.4,28.96 306.33,28.96 309.09,31.73 325.49,31.73 326.84,33.07 330.93,33.07 331.12,32.88 336.25,32.88 336.44,33.07 339.48,33.07 339.98,33.57 339.98,34.07 339.88,34.17 v2(339.88,34.47)
  BOTTOM w0.089: UH2.AC3 97.82,16.59 98.22,16.19 98.91,16.19 99.29,16.57 99.61,16.57 99.74,16.44 v2(100.63,16.44)
  BOTTOM w0.152: UR1.5 339.78,34.57 v2(339.88,34.47)
CLK_PCIE_P5: length 102.6
  IN1 w0.076: v2(99.73,17.36) 99.58,17.51 98.98,17.51 98.36,18.14 90.45,18.14 90.27,17.96 84.7,17.96 83.4,16.66 81.25,16.66 79.92,17.99 77.47,17.99 76.28,19.18 76.28,20.16 75.39,21.05 75.06,21.05
  IN1 w0.089: v2(29.31,36.32) 29.15,36.48 29.15,36.84 29.65,37.34 31.36,37.34 31.95,36.75 31.95,35.22 32.52,34.65 32.52,34.16 32.83,33.85 32.83,33.56 32.82,33.55 32.82,33.53
  IN1 w0.107: 75.06,21.05 74.61,21.05 74.03,21.63 72.27,21.63 71.18,20.54 69.98,20.54 69.83,20.69 66.21,20.69 64.39,22.51 64.39,22.88 63.99,23.28 57.67,23.28 57,23.95 57,25.47 56.37,26.09 53.96,26.09 53.68,25.81 53.1,25.81 52.68,25.4 49.31,25.4 48.93,25.77 48.93,26.74 48.74,26.93 48.28,26.93 48.14,26.8 48.14,25.51 47.58,24.94 46.37,24.94 44.99,23.56 40.64,23.56 39.47,24.73 39.47,25.87 39.93,26.32 39.93,28.85 39.34,29.44 35.41,29.44 34.92,28.95 34.57,28.95 34.19,29.32 34.19,29.67 34.69,30.16 34.69,30.34 34.43,30.6 34.25,30.6 32.59,28.94 32.24,28.94 31.86,29.32 31.86,29.65 33.53,31.32 33.53,31.5 32.82,32.21 32.82,33.53
  BOTTOM w0.089: UH2.AB3 98.06,17.09 98.33,16.83 98.55,16.83 98.81,17.08 99.33,17.08 99.61,17.36 v2(99.73,17.36)
  BOTTOM w0.102: UT1.V19 v2(29.31,36.32)
CLK_PCIE_P6: length 181
  IN2 w0.089: v2(99.2,18.82) 99.38,18.64 99.97,18.64 101.82,20.49 101.82,20.5 101.84,20.52
  IN2 w0.107: v2(262.67,15.87) 262.67,16.47 262.39,16.75 261.23,16.75 260.93,17.06 258.36,17.06 255.78,14.48 253.37,14.48 252.66,15.19 238.68,15.19 238.24,15.63 231.34,15.63 230.64,14.93 157.49,14.93 154.92,17.5 142.5,17.5 142.04,17.96 139.23,17.96 138.89,18.3 138.89,18.97 138.1,19.76 133.38,19.76 131.98,21.15 107.6,21.15 106.56,22.2 103.52,22.2 101.84,20.52
  BOTTOM w0.089: UH2.W3 97.9,18.29 98.39,18.29 98.79,18.69 99.07,18.69 v2(99.2,18.82)
  BOTTOM w0.152: v2(262.67,15.87) 262.55,15.75 262.55,14.96 263.01,14.49 263.01,10.83 261.81,9.64 261.27,9.64 261.18,9.54 JNGFF2.55
CLK_PCIE_P7: length 147.6
  IN6 w0.107: v2(197.45,68.92) 197.45,68.71 197.34,68.6 197.04,68.6 196.84,68.79 196.05,68.79 193.18,65.93 193.18,55.91 193.9,55.18 193.9,39.69 183.31,29.1 183.31,27.51 181.2,25.4 181.2,20.81 179.64,19.24 172.14,19.24 170.27,17.37 166.02,17.37 165.66,17.73 122.47,17.73 121.48,16.74 112.58,16.74 110.89,15.05 110.59,15.05 110.22,14.67 106.71,14.67 106.39,14.99 103.36,14.99 102.29,16.05 100.26,16.05 100.07,16.24 100.07,16.46 99.72,16.82 98.96,16.82 97.54,18.23 96.53,18.23 96.27,18.49 96.25,18.67 v2(96.39,18.88)
  BOTTOM w0.089: v2(96.39,18.88) 96.32,18.81 96.32,18.61 96.45,18.49 UH2.W6
  BOTTOM w0.102: UV18.AL13 197.09,68.55 v2(197.45,68.92)
CLK_TP_SIO: length 119
  TOP w0.076: UE3.E10 v2(296.96,18.17)
  IN2 w0.099: v2(296.96,18.17) 296.58,18.54 295.94,18.54 295.76,18.72 295.76,19.25 295.63,19.38 290.68,19.38 289.67,18.37 288.75,18.37 288.11,17.73 284.8,17.73 283.23,16.16 282.86,16.16 281.96,15.26 279.92,15.26 278.79,14.13 266.35,14.13 263.74,11.52 261.97,11.52 260.8,10.35 255.08,10.35 254.32,9.59 240.48,9.59 239.84,8.95 216.61,8.95 213.24,12.32 204.46,12.32 203.7,11.56 200.41,11.56 v2(199.52,12.45)
  BOTTOM w0.14: JTP.1 193,11.83 192.74,12.09 192.74,13.03 CE77.1 193.17,13.84 193.14,13.87 RE24.2 192.99,14.5 192.99,14.89 193.08,14.98 199.73,14.98 199.83,14.88 199.83,14.26 DE4.2 199.06,12.93 199.47,12.5 v2(199.52,12.45)
CLKIN_XTAL: length 2.8
  TOP w0.089: v2(96.88,19.3) 97.39,19.81 RH5850.1 97.41,20.28 T4952.1
  BOTTOM w0.089: v2(96.88,19.3) 96.84,19.34 96.84,19.83 UH2.R6
CLKREQ_PCIE#0: length 7.3
  BOTTOM w0.089: RH548.2 88.38,2.68 88.01,3.05 85.23,3.05 85,2.81 84.28,2.81 84.05,3.05 84.05,3.53 84.19,3.67 84.19,4.77 84.52,5.1 UH2.BF31
CLKREQ_PCIE#3: length 379.8
  TOP w0.14: RP2.5 67.98,13.35 v2(68.07,13.44)
  IN6 w0.089: 73.28,8.08 75.74,8.08 76.7,7.12 77.2,7.12 77.69,6.63 77.8,6.63 78.46,5.97 81.92,5.97 82,6.06 85.05,6.06 ; 85.05,6.06 84.66,6.45 84.66,7.45 84.45,7.66 v2(84.35,7.66) ; 85.05,6.06 85.92,5.2 86.38,5.2 86.81,4.77 89.64,4.77 90.54,5.67 91.48,5.67 91.66,5.86 93.97,5.86 94.08,5.75 98.73,5.75 99.02,5.46 100.33,5.46 100.56,5.23 100.56,4.8 100.92,4.45 101.98,4.45
  IN6 w0.099: v2(68.07,13.44) 69.62,13.44 71.6,11.46 71.6,8.79 72.01,8.38 72.75,8.38 73.05,8.08 73.28,8.08 ; v2(338.63,87.5) 338.61,87.5 337.9,86.79 337.9,82.87 334.96,79.94 334.96,66.62 337.62,63.96 339.32,63.96 340.01,63.27 340.01,60.3 337.95,58.24 337.95,51.82 333.56,47.43 333.56,41.52 331.54,39.5 331.54,37.11 330.97,36.55 330.97,35.42 331.73,34.67 331.73,34.04 331.34,33.66 329.06,33.66 327.28,31.88 327.28,27.56 325.63,25.91 321.31,25.91 321.01,25.6 321.01,23.23 319.41,21.64 319.03,21.64 315.65,18.26 315.65,16.6 314.96,15.91 314.96,12.24 315.81,11.39 315.81,10.1 313.65,7.94 312.56,7.94 311.12,6.5 307.52,6.5 305.26,8.76 304.8,8.76 303.38,7.34 300.25,7.34 298.04,5.13 288.94,5.13 288.88,5.19 285.1,5.19 284.64,4.73 281.08,4.73 280.23,5.59 279.66,5.59 278.26,6.99 271.4,6.99 270.71,7.67 263.08,7.67 261.84,6.43 254.33,6.43 253.66,7.09 245.2,7.09 243.93,5.82 218.99,5.82 214.5,10.31 212.64,10.31 212.41,10.08 184.5,10.08 183.48,9.06 177.52,9.06 175.27,6.81 166.37,6.81 165.62,6.06 157.24,6.06 156.96,5.78 152.48,5.78 152.29,5.97 148.27,5.97 145.29,8.95 140.89,8.95 140.45,9.4 136.19,9.4 135.84,9.75 135.02,9.75 133.99,8.71 133.99,6.17 133.15,5.34 133.15,4.11 132.6,3.56 130.75,3.56 130.18,2.99 125.79,2.99 125.03,3.75 120.31,3.75 119.32,4.74 118.19,4.74 117.52,4.07 106.95,4.07 106.55,3.67 106.12,3.67 105.14,4.65 103.54,4.65 103.34,4.45 101.98,4.45
  BOTTOM w0.089: v2(84.35,7.66) 84.35,7.61 84.66,7.3 UH2.BB30
  BOTTOM w0.14: v2(338.63,87.5) 339.07,87.94 340.28,87.94 341.55,86.67 JNGFF1.45
CLKREQ_PCIE#4: length 316.3
  TOP w0.14: v2(68.07,14.02) 67.89,13.85 RP2.6
  IN3 w0.089: 101.98,10.13 100.22,8.37 99.57,8.37 99.45,8.24 98.42,8.24 97.74,8.92 96.18,8.92 95.3,9.79 94.82,9.79 94.38,10.24 92.51,10.24 91.9,10.85 90.42,10.85 90.17,10.6 89.34,10.6 88.76,11.17 86.63,11.17 84.87,9.4 84.87,8.54 v2(84.51,8.19)
  IN3 w0.091: 101.98,10.13 103.98,12.12 109.15,12.12 109.25,12.22 113.01,12.22 114.66,10.57 117.55,10.57 117.75,10.77 117.75,12.34 119.37,13.96 v2(119.37,14.06)
  IN5 w0.099: v2(119.37,14.06) 119.38,14.07 119.38,15.38 119.93,15.93 121.84,15.93 122.81,16.89 124.59,16.89 125.55,15.93 130.53,15.93 130.8,15.66 140.99,15.66 141.72,16.39 164.74,16.39 165.15,15.98 176.01,15.98 179.3,19.26 179.3,21.89 179.62,22.22 181.03,22.22 181.62,21.63 182.45,21.63 184.68,19.39 221.12,19.39 222.59,17.92 248.98,17.92 251.12,15.79 252.81,15.79 253.73,14.86 256.22,14.86 257.32,15.96 257.32,16.49 258.27,17.44 261.17,17.44 261.68,17.95 274.9,17.95 276.39,19.43 280.67,19.43 281.48,20.24 286.3,20.24 288.23,22.17 288.23,22.43 289.57,23.77 291.23,23.77 292.3,22.71 293.75,22.71 296.19,25.15 297.34,25.15 298.05,25.86 299.2,25.86 299.72,25.34 299.72,24 300.55,23.18 304.1,23.18 304.36,23.43 308.17,23.43 309.75,21.85 313.82,21.85 316.79,24.81 322.13,24.81 322.84,25.52 327.28,25.52 328.8,27.04 328.8,31.48 330.17,32.85 340,32.85 v2(341.76,34.61)
  IN6 w0.089: 73.28,8.59 73.51,8.36 76.38,8.36 77.14,7.59 78.15,7.59 79.38,6.36 81.02,6.36 81.46,6.81 81.46,7.2 82.05,7.79 82.24,7.79 82.25,7.8 82.54,7.8 82.54,7.79 82.9,7.79 82.98,7.87 83.41,7.87 83.73,8.19 v2(84.51,8.19)
  IN6 w0.099: v2(68.07,14.02) 69.72,14.02 72.06,11.69 72.06,9.75 72.46,9.36 72.71,9.36 72.94,9.12 72.94,8.92 73.28,8.59
  BOTTOM w0.089: UH2.BA30 84.85,7.85 84.52,8.19 v2(84.51,8.19)
  BOTTOM w0.14: v2(341.76,34.61) 341.53,34.61 340.98,35.16 UR1.2
CLKREQ_PCIE#5: length 89.7
  TOP w0.14: v2(68.04,14.61) 67.78,14.35 RP2.7 ; RT21.2 31.91,47.97 32.28,47.59 32.64,47.59 33.05,48.01 33.57,48.01 34.7,46.88 34.7,46.22 34.98,45.94 34.98,45.58 34.85,45.45 v2(34.85,45.23) 34.99,45.09 35.95,45.09 38.29,42.76 38.29,39.61 38.51,39.39 38.51,34.14 38.05,33.68 38.05,31.35 37.5,30.8 37.5,27.8 38.02,27.28 v2(38.02,26.06)
  IN1 w0.076: v2(84.56,13.95) 84.56,14.25 83.3,15.51 79.31,15.51 78.6,16.22 77.64,16.22 77.35,16.5 72.81,16.5 72.54,16.77
  IN1 w0.099: v2(38.02,26.06) 38.02,24.51 40.97,21.56 46.38,21.56 46.76,21.94 46.76,22.28 47.02,22.53 49.31,22.53 49.6,22.24 50.71,22.24 51.95,23.48 54.88,23.48 58.11,20.25 60.22,20.25 61.93,18.54 62.74,18.54 62.94,18.75 64.39,18.75 66.93,16.21 66.93,15.62 67.95,14.61 v2(68.04,14.61) 68.53,15.1 68.53,15.96 69.69,17.12 72.14,17.12 72.49,16.77 72.54,16.77
  BOTTOM w0.089: UH2.AN29 85.24,11.92 84.54,12.61 84.54,13.94 v2(84.56,13.95)
  BOTTOM w0.14: RT5845.1 34.52,44.91 v2(34.85,45.23)
CLKREQ_PCIE#5_AR: length 2.6
  BOTTOM w0.089: UT1.AC5 33.2,43.12 33.66,43.57
  BOTTOM w0.14: 33.66,43.57 33.94,43.85 RT5845.2
CLKREQ_PCIE#6: length 231.8
  TOP w0.14: RP2.8 67.68,14.85 67.96,15.13 v2(67.96,16.19)
  IN1 w0.076: 73.34,17.56 73.4,17.51 74.29,17.51 74.94,18.16 76.71,18.16 78.13,16.74 79.19,16.74 79.44,16.49 83.61,16.49 84.92,17.8 90.39,17.8 90.57,17.97 97.86,17.97 98.83,16.99 99.9,16.99 100.09,17.18 100.09,17.48 101.16,18.55 101.21,18.55 101.73,19.07 101.98,19.18
  IN1 w0.099: 101.98,19.18 102.04,19.2 102.2,19.2 102.68,19.69 106.3,19.69 106.94,19.05 129.6,19.05 129.99,18.67 129.99,17.53 131.53,15.98 138.33,15.98 140.21,14.1 144.59,14.1 145.22,13.46 147.96,13.46 148.95,12.47 151.35,12.47 152.08,11.74 153.95,11.74 154.97,10.72 158.69,10.72 160.29,9.12 163.32,9.12 163.65,9.45 175.9,9.45 176.29,9.05 183.41,9.05 183.79,8.68 184.78,8.68 185.44,9.34 186.46,9.34 186.89,8.91 187.01,8.91 187.54,8.38 188.34,8.38 189.09,9.13 205.16,9.13 206.16,10.14 210.97,10.14 214.69,6.41 226.7,6.41 228.28,8 238.7,8 240.41,9.72 251.49,9.72 252.79,8.41 253.72,8.41 254,8.13 256.47,8.13 257.03,8.68 258.18,8.68 260.63,8.68 261.37,8.68 263.47,10.78 268.05,10.78 v2(269.38,9.45) ; 73.34,17.56 73.24,17.66 71.42,17.66 71.15,17.4 69.59,17.4 68.38,16.19 v2(67.96,16.19)
  BOTTOM w0.089: 75.62,15.11 76.46,15.11 76.55,15.21 UH2.AE47
  BOTTOM w0.14: 75.62,15.11 74.97,15.76 74.51,15.76 73.44,16.83 72.7,16.83 72.61,16.93 71.97,16.93 71.5,17.4 68.3,17.4 67.84,16.94 67.84,16.31 v2(67.96,16.19) ; v2(269.38,9.45) 269.38,9.61 268.7,10.29 JNGFF2.52
CLKREQ_PCIE#7: length 184.2
  TOP w0.14: RH551.2 72.78,17.08 v2(72.94,17.24) ; v2(197.82,49.53) 198.03,49.75 QV103.1 ; v2(185.64,18.34) 185.63,18.32 v1(185.63,16.99) 185.63,9.52 v2(186.26,8.89)
  IN1 w0.076: 101.66,17.91 100.75,17.91 100.25,17.41 100.25,17.12 99.97,16.83 98.57,16.83 97.59,17.81 90.68,17.81 90.51,17.63 85.16,17.63 83.85,16.32 79.18,16.32 79.05,16.46 77.87,16.46 77.66,16.67 73.58,16.67 73.01,17.24
  IN1 w0.099: v2(186.26,8.89) 186.12,8.75 185.14,8.75 184.71,8.32 183.86,8.32 183.33,8.85 175.98,8.85 175.34,8.21 170.22,8.21 169.69,8.74 159.87,8.74 158.83,9.78 157.46,9.78 157.28,9.6 155.95,9.6 155.74,9.81 154.79,9.81 153.2,11.39 152.07,11.39 151.2,12.26 148.58,12.26 147.64,13.21 145.09,13.21 144.4,13.89 140.13,13.89 138.28,15.75 131.07,15.75 128.02,18.8 109.73,18.8 106.62,15.69 104.4,15.69 103.82,16.26 103.32,16.26 101.66,17.91 ; v2(72.94,17.24) 73.01,17.24
  BOTTOM w0.089: 73.01,17.24 73.34,17.24 74.4,16.18 75.9,16.18 UH2.AC48
  BOTTOM w0.14: v2(185.64,18.34) 185.64,18.29 185.41,18.06 184.02,18.06 183.55,18.54 183.55,21 181.5,23.05 181.5,24.42 182.68,25.59 182.68,31.81 180.75,33.73 180.75,37.58 192.7,49.53 v2(197.82,49.53) ; 73.01,17.24 v2(72.94,17.24)
CLKREQ_PCIE#7_GPU: length 27
  TOP w0.14: RV591.2 200.38,51.21 199.52,52.07 198.7,52.07 QV103.3 197.07,51.35 v1(196.39,52.02) 195.45,52.96 195.45,55.41 197.04,56.99 197.04,57.93 196.07,58.9 194.88,58.9 193.48,60.3 193.48,63.41 196.49,66.42 v2(198.24,66.42)
  BOTTOM w0.102: UV18.AK12 197.84,67.54 198.24,67.14 v2(198.24,66.42)
CLKRUN#: length 202.6
  TOP w0.089: v6(83.43,8.86) 83.95,9.37 RH85.1
  TOP w0.14: v2(266.85,8.94) 266.85,8.24 v1(266.48,7.88)
  IN2 w0.089: 101.98,10.62 101.32,9.96 101.32,9.82 100.84,9.34 99.51,9.34 98.97,8.8 98.36,8.8 98.24,8.93 96.31,8.93 95.91,8.54 92.65,8.54 91.52,9.67 90.78,9.67 90.08,10.38 89.72,10.38 89.44,10.1 89.44,9.83 88.54,8.92 87.71,8.92 86.39,10.24 85.73,10.24 85.17,9.69 84.26,9.69 v6(83.43,8.86)
  IN2 w0.099: v2(266.85,8.94) 266.81,8.9 257.86,8.9 256.78,7.82 244.93,7.82 242.38,5.27 235.14,5.27 234.44,4.57 215.57,4.57 210.37,9.78 188.16,9.78 187.64,10.3 184.16,10.3 183.4,9.54 175.02,9.54 174.65,9.17 174.65,8.64 174.32,8.31 171.64,8.31 171.43,8.53 171.43,9 171.13,9.3 170.08,9.3 169.67,8.89 164.21,8.89 164.21,8.9 163.73,8.42 160.02,8.42 159.22,7.62 157.81,7.62 156.85,8.58 155.56,8.58 153.05,11.09 139.33,11.09 136.77,13.65 123.89,13.65 122.44,15.1 121.84,15.1 120.74,16.2 116.09,16.2 115.79,15.9 114.2,15.9 113.6,15.3 113.6,15.06 113.41,14.87 112.98,14.87 111.94,13.84 110.81,13.84 109.76,12.79 106.57,12.79 106.04,12.26 103.62,12.26 101.98,10.62
  BOTTOM w0.089: v6(83.43,8.86) 83.8,9.22 UH2.AV32
CMOUT: length 26.5
  TOP w0.14: v2(58.13,17.59) v1(58.75,17.59) ; PR1928.1 v2(50.36,21.32)
  IN1 w0.099: v2(58.75,15.29) 59.02,15.56 59.02,16.79 58.49,17.32 58.4,17.32 v2(58.13,17.59)
  IN6 w0.099: v2(64.32,13.52) 63.56,13.52 61.79,15.29 v2(58.75,15.29) ; v2(50.36,21.32) 50.36,21.3 51.16,20.5 52.28,20.5 53.56,19.21 56.19,19.21 56.96,18.44 57.28,18.44 v2(58.13,17.59)
  BOTTOM w0.14: PQ220.6 57.79,17.25 v2(58.13,17.59) ; v2(64.32,13.52) 64.11,13.74 64.11,14.58 63.96,14.73 63.96,16.73 64.21,16.98 PQ224.2 ; PQ221.5 59.69,13.84 59.21,14.33 59.21,14.83 v2(58.75,15.29)
CMRSVD1: length 1.2
  TOP w0.089: T53.1 162.71,68.71 v2(163.03,69.03)
  BOTTOM w0.076: v2(163.03,69.03) 163.35,68.7 UH1.AA14
CMRSVD2: length 2.3
  TOP w0.089: T52.1 160.23,79.68 160.58,80.04 v2(160.58,80.32)
  BOTTOM w0.076: UH1.AE29 160.52,80.74 160.58,80.67 v2(160.58,80.32)
CMRSVD3: length 1.1
  TOP w0.089: v2(156.74,64.47) 157.05,64.78 T83.1
  BOTTOM w0.076: v2(156.74,64.47) 157.07,64.8 UH1.AJ8
CMRSVD4: length 1.7
  TOP w0.089: v2(154.06,69.19) 154.55,69.67 T4965.1
  BOTTOM w0.076: UH1.AP14 153.57,68.7 v2(154.06,69.19)
CMRSVD5: length 1.9
  TOP w0.089: T4966.1 154.58,80.23 v2(154.43,80.23)
  BOTTOM w0.076: UH1.AP29 154.16,80.23 v2(154.43,80.23)
CMRSVD6: length 4.9
  BOTTOM w0.076: UH1.B2 177.16,60.64 177.16,60.07 177.04,59.94 177.04,58.92 176.21,58.09 176.21,56.62 T90.1
CMRSVD7: length 4.3
  TOP w0.089: v2(179.15,82.88) 179.15,83.13 T59.1
  BOTTOM w0.076: v2(179.15,82.88) 179.48,82.56 179.48,82.3 178.98,81.8 177.51,81.8 UH1.B30
CMRSVD8: length 6.6
  BOTTOM w0.14: UH1.B38 181.33,90.67 T89.1
CMRSVD9: length 1.2
  TOP w0.089: T65.1 143.22,81.57 v2(142.8,81.99)
  BOTTOM w0.076: v2(142.8,81.99) 142.42,81.61 UH1.BH30
CMRSVD10: length 1.2
  TOP w0.089: v2(142.49,79.62) T67.1
  BOTTOM w0.076: v2(142.49,79.62) 142.46,79.62 UH1.BJ28
CMRSVD11: length 1.7
  TOP w0.089: v2(140.42,80.46) 140.56,80.6 T66.1
  BOTTOM w0.076: v2(140.42,80.46) 141.03,80.46 141.35,80.14 UH1.BK28
CMRSVD12: length 1.1
  TOP w0.089: T82.1 141.57,82.34 v2(141.23,82.68)
  BOTTOM w0.076: UH1.BL31 140.86,82.31 v2(141.23,82.68)
CMRSVD13: length 1.2
  TOP w0.089: v2(141.23,84.58) 141.1,84.46 T49.1
  BOTTOM w0.076: v2(141.23,84.58) 140.9,84.26 UH1.BL34
CMRSVD14: length 1.7
  TOP w0.089: v2(139.73,82.83) 139.09,82.83 T48.1
  BOTTOM w0.076: v2(139.73,82.83) 139.4,83.15 UH1.BN33
CMRSVD15: length 1.1
  TOP w0.089: v2(139.08,84.43) 138.72,84.79 T45.1
  BOTTOM w0.076: v2(139.08,84.43) 139.08,84.47 UH1.BN35
CMRSVD16: length 4.1
  TOP w0.089: T88.1 136.09,58.43 v2(135.75,58.77)
  BOTTOM w0.076: UH1.BP1 138.07,59.56 137.66,59.56 136.87,58.77 v2(135.75,58.77)
CMRSVD17: length 4.2
  TOP w0.089: v2(136.21,59.19) 136.04,59.35 T87.1
  BOTTOM w0.076: UH1.BR2 138.31,60.95 138.43,60.83 138.43,60.37 138.43,60.37 138.43,60.15 138,59.73 137.59,59.73 137.05,59.19 v2(136.21,59.19)
CMRSVD18: length 1.7
  TOP w0.089: T64.1 138.9,81.87 v2(139.09,82.06)
  BOTTOM w0.076: v2(139.09,82.06) 138.48,82.06 UH1.BR31
CMRSVD19: length 5.4
  BOTTOM w0.076: 134.62,86.23 135.55,86.23 136.65,85.13 137.75,85.13 UH1.BR35
  BOTTOM w0.14: 134.62,86.23 T63.1
CMRSVD20: length 5.3
  BOTTOM w0.076: UH1.C1 176.87,60.18 176.87,58.98 176.04,58.16 176.04,57.32 175.15,56.43 T86.1
CMRSVD21: length 1.1
  TOP w0.089: T60.1 176.95,82.12 v2(177.09,82.26)
  BOTTOM w0.076: UH1.C30 176.78,81.95 v2(177.09,82.26)
CMRSVD22: length 6.4
  BOTTOM w0.14: UH1.C38 176.83,86.86 179.93,89.97 T85.1
CMRSVD23: length 5.1
  BOTTOM w0.076: 179.9,81.54 179.89,81.55 179.52,81.55 179.47,81.6 175.55,81.6 175.48,81.67 UH1.E30
  BOTTOM w0.14: T58.1 180.02,81.54 179.9,81.54
CMRSVD24: length 1.2
  TOP w0.089: v2(174.54,82.29) 174.53,82.28 T57.1
  BOTTOM w0.076: v2(174.54,82.29) 174.83,82 UH1.F30
CMRSVD25: length 1.6
  TOP w0.089: T84.1 173.83,69.66 v2(173.83,68.91)
  BOTTOM w0.076: v2(173.83,68.91) 174.18,68.57 UH1.G13
CMRSVD26: length 2.3
  TOP w0.089: v2(173.76,61.23) 173.76,60.75 174.21,60.3 T61.1
  BOTTOM w0.076: UH1.G3 174.07,61.54 v2(173.76,61.23)
CMRSVD27: length 1.6
  TOP w0.089: v2(173.88,77.51) 174.22,77.17 T47.1
  BOTTOM w0.076: UH1.H24 173.52,77.15 v2(173.88,77.51)
CMRSVD28: length 2.7
  TOP w0.089: v2(172.41,75.99) 172.41,75.87 172.91,75.38 T46.1
  BOTTOM w0.076: v2(172.41,75.99) 172.41,76.48 172.83,76.9 UH1.J24
CMRSVD29: length 1.8
  TOP w0.089: T62.1 174.17,61.47 v2(173.72,61.91)
  BOTTOM w0.076: v2(173.72,61.91) 173.34,61.54 UH1.J3
CMRSVD30: length 1.8
  TOP w0.089: v2(169.59,81.98) 169.74,81.84 T50.1
  BOTTOM w0.076: v2(169.59,81.98) 169.59,81.33 UH1.N29
CMRSVD31: length 1.2
  TOP w0.089: T51.1 168.02,68.03 v2(167.66,68.39)
  BOTTOM w0.076: UH1.R14 167.97,68.7 v2(167.66,68.39)
CMRSVD_TP1: length 2.4
  TOP w0.089: T43.1 137.09,59.21 v2(136.65,59.64)
  BOTTOM w0.076: v2(136.65,59.64) 137.12,59.64 137.71,60.24 UH1.BR1
CMRSVD_TP2: length 1.2
  TOP w0.089: T44.1 137.1,60.57 v2(136.94,60.41)
  BOTTOM w0.076: UH1.BT2 137.34,60.81 v2(136.94,60.41)
CMRSVD_TP3: length 1.9
  TOP w0.089: v2(176.51,59.13) 176.51,58.56 T42.1
  BOTTOM w0.076: UH1.D1 176.11,60.24 176.51,59.83 v2(176.51,59.13)
CMRSVD_TP4: length 1.2
  TOP w0.089: v2(175.33,59.72) 175.33,59.19 T41.1
  BOTTOM w0.076: v2(175.33,59.72) 175.3,59.75 UH1.E1
CMRSVD_TP5: length 2.3
  TOP w0.089: v2(176.02,59.54) 176.34,59.86 T39.1
  BOTTOM w0.076: v2(176.02,59.54) 175.61,59.95 UH1.E2
CODE_CBN1: length 4.7
  BOTTOM w0.14: CA18.2 2.52,41.59 2.12,41.99 2.12,42.74 v1(2.19,42.81)
  BOTTOM w0.203: UA1.28 4.7,41.43 4.34,41.78 4.34,42.02 4.13,42.23 4.13,42.23 4.09,42.27 3.44,42.27 CA18.2
CODE_CBP2: length 2.7
  BOTTOM w0.203: CA15.2 3.44,40.92 4.29,40.92 4.59,40.63 UA1.26
CODE_MIC1_CAP: length 1.6
  BOTTOM w0.14: UA1.41 10.84,42.83 11.47,43.47 CA31.1
CODE_VREF: length 3.8
  BOTTOM w0.203: UA1.43 12.53,41.43 12.68,41.57 12.68,43.35 12.95,43.62 CA24.1
  BOTTOM w0.254: CA25.1 12.95,44.59 CA24.1
CODE_VREF1: length 3.3
  BOTTOM w0.14: CA29.1 2.8,37.42 2.83,37.45 CA28.1 3.24,38.1 v1(3.68,38.54) 3.86,38.72 4.49,38.72 4.59,38.63 UA1.21
COMP_ISL88738: length 4
  TOP w0.203: PC1939.1 PR1930.1 47.83,19.63 48.28,19.18 48.46,19.18 49.11,18.53 PU1900.28
CPU_24MHZ_N: length 120.6
  IN6 w0.089: 172.93,81.94 172.95,81.94 172.96,81.95 174.04,81.95 174.39,81.6 175.15,81.6 v2(175.82,82.27)
  IN6 w0.107: v2(96.68,25.97) 96.53,25.82 96.29,25.82 95.61,26.5 95.61,26.9 95.76,27.06 95.76,27.39 96.02,27.64 97.09,27.64 97.84,28.4 97.84,33.91 102.77,38.84 108.42,38.84 112.14,42.56 112.14,44.42 113.85,46.13 114.99,46.13 117.43,48.56 117.43,50.47 119.39,52.44 119.39,53.79 121.72,56.12 121.72,58.15 121.4,58.47 121.4,60.57 128.98,68.15 128.98,70.43 129.69,71.14 129.69,73.39 133.31,77.01 142.83,77.01 143.23,77.41 143.23,79.42 143.44,79.63 152.27,79.63 153.06,78.84 160.22,78.84 161.55,80.16 168.38,80.16 168.91,79.63 169.99,79.63 172.3,81.94 172.93,81.94
  BOTTOM w0.076: UH1.D31 175.82,82.35 v2(175.82,82.27)
  BOTTOM w0.089: v2(96.68,25.97) 96.63,25.97 UH2.C6
CPU_24MHZ_P: length 120.7
  IN6 w0.089: 172.93,82.14 172.95,82.14 172.96,82.14 174.12,82.14 174.47,81.78 175.07,81.78 175.17,81.88 v2(175.17,82.27)
  IN6 w0.107: 172.93,82.14 172.21,82.14 169.9,79.83 169,79.83 168.46,80.37 161.46,80.37 160.14,79.05 153.15,79.05 152.36,79.83 143.35,79.83 143.02,79.5 143.02,77.49 142.75,77.22 133.22,77.22 129.49,73.48 129.49,71.22 128.78,70.52 128.78,68.23 121.2,60.65 121.2,58.38 121.51,58.07 121.51,56.21 119.19,53.88 119.19,52.52 117.22,50.56 117.22,48.64 114.91,46.33 113.77,46.33 111.94,44.5 111.94,42.65 108.33,39.04 102.69,39.04 97.64,33.99 97.64,28.48 97,27.85 95.94,27.85 95.56,27.47 95.56,27.14 95.4,26.98 95.4,26.42 96.2,25.62 96.34,25.62 v2(96.51,25.45)
  BOTTOM w0.076: UH1.E31 175.17,82.35 v2(175.17,82.27)
  BOTTOM w0.089: UH2.D7 96.49,25.45 v2(96.51,25.45)
CPU_BPM#2: length 1.3
  TOP w0.089: T4971.1 139.91,81.49 v2(140.41,81.99)
  BOTTOM w0.076: v2(140.41,81.99) 140.41,82.05 140.05,82.4 UH1.BM31
CPU_BPM#3: length 1.4
  TOP w0.089: T4972.1 136.73,81.88 v2(136.67,81.83)
  BOTTOM w0.076: UH1.BT30 137.38,81.72 136.78,81.72 v2(136.67,81.83)
CPU_C10_GATE#: length 67.3
  TOP w0.14: RZ1953.1 109.73,44.68 109.87,44.54 v2(109.87,44.02)
  IN4 w0.089: 99.53,27.81 99.67,27.67 99.67,26.72 98.86,25.91 98.86,24.84 96.57,22.55 92.04,22.55 91.67,22.18 91.67,21.81 91.26,21.4 90.93,21.4 89.84,20.31 v2(89.84,19.74)
  IN4 w0.091: v2(109.87,44.02) 109.58,44.31 109.06,44.31 108.8,44.06 108.8,43.21 107.26,41.66 107.26,41.37 105.6,39.71 100.54,39.71 99.53,38.7 99.53,37.63 96.98,35.08 96.98,31.13 99.42,28.7 99.42,27.93 99.53,27.81
  IN6 w0.089: 101.98,10.83 101.79,10.83 101.37,11.25 99.19,11.25 98.55,11.89 97.94,11.89 97.73,12.1 95.74,12.1 93.96,13.89 92.27,13.89 90.38,15.78 90.38,19.42 90.07,19.74 v2(89.84,19.74)
  IN6 w0.099: 101.98,10.83 104.22,10.83 104.69,10.36 v2(104.69,9.68)
  BOTTOM w0.14: v2(104.69,9.68) 103.93,8.92 102.64,8.92 RH5835.1
CPU_DP1_AUXN: length 186.3
  TOP w0.152: v2(37.24,35.98) 36.94,36.28 36.94,37.63 36.55,38.02 36.55,38.72 34.84,40.43 34.1,40.43 CT26.2
  IN3 w0.089: 141.03,79.38 141.03,80.42 141.92,81.31 173.12,81.31 173.83,80.61 173.83,80.39 174.93,79.3 174.93,79.3 v2(175.13,79.09)
  IN3 w0.099: 137.86,72.4 137.86,72.38 137.85,72.38 137.85,72.32 137.85,72.31 137.85,71.94 137.02,71.12 134.54,71.12 134.01,70.59 134.01,57.93 114.91,38.83 100.61,38.83 95.23,33.46 92.15,33.46 88.19,29.49 81.26,29.49 80.93,29.82 79.95,29.82 79.42,29.29 77.41,29.29 76.55,30.14 74.12,30.14 73.83,29.86 71.18,29.86 70.36,29.04 64.97,29.04 64.43,29.57 63.94,29.57 63.43,29.06 56.31,29.06 55.82,29.55 53.11,29.55 52.47,28.91 44.99,28.91 41.62,32.28 41.12,32.28 40.72,32.68 40.72,33.55 39.69,34.58 39.21,34.58 37.13,36.67 36.92,36.67 36.8,36.55 36.8,36.42 v2(37.24,35.98)
  IN3 w0.112: 141.03,79.38 141.03,77.86 140.33,77.15 138.18,77.15 137.86,76.84 137.86,72.4
  BOTTOM w0.076: v2(175.13,79.09) 175.13,79.34 175.31,79.51 UH1.E27
CPU_DP1_AUXN_C: length 4.3
  TOP w0.089: v2(29.98,40.88) 30.41,41.31 30.79,41.31 30.94,41.16 31.55,41.16 32.13,40.58 CT26.1
  BOTTOM w0.102: UT1.W11 30.07,40.76 30.07,40.78 v2(29.98,40.88)
CPU_DP1_AUXP: length 186.3
  TOP w0.152: v2(36.61,35.98) 36.61,37.49 36.22,37.88 36.22,38.58 34.71,40.1 34.04,40.1 CT25.2
  IN3 w0.089: v2(175.78,79.09) 175.72,79.09 175.35,79.46 175.01,79.46 174.01,80.47 174.01,80.68 173.2,81.49 141.85,81.49 140.85,80.5 140.85,79.47 140.84,79.46 140.84,79.4 140.83,79.39 140.83,79.38
  IN3 w0.099: 137.66,72.4 137.66,72.02 136.94,71.31 134.46,71.31 133.82,70.67 133.82,58.01 114.84,39.03 100.53,39.03 95.15,33.65 92.07,33.65 88.11,29.68 81.34,29.68 81.01,30.01 79.87,30.01 79.34,29.48 77.49,29.48 76.63,30.34 74.04,30.34 73.75,30.05 71.1,30.05 70.29,29.23 65.05,29.23 64.51,29.76 63.86,29.76 63.35,29.25 56.39,29.25 55.89,29.74 53.03,29.74 52.39,29.1 45.07,29.1 41.7,32.47 41.2,32.47 40.91,32.76 40.91,33.63 39.77,34.77 39.29,34.77 37.21,36.86 36.84,36.86 36.61,36.63 v2(36.61,35.98)
  IN3 w0.112: 140.83,79.38 140.83,78.01 140.18,77.36 138.09,77.36 137.66,76.92 137.66,72.4
  BOTTOM w0.076: UH1.D27 175.78,79.17 v2(175.78,79.09)
CPU_DP1_AUXP_C: length 4.3
  TOP w0.089: CT25.1 33.14,40.23 v1(32.45,40.23) 32.05,40.23 31.87,40.41 31.68,40.41 31.59,40.5 31.59,40.69 31.47,40.81 31.29,40.81 31.23,40.74 31.23,40.52 31.13,40.43 31,40.43 30.9,40.52 30.9,40.81 30.83,40.87 v2(30.61,40.87)
  BOTTOM w0.102: UT1.Y11 v2(30.61,40.87)
CPU_DP1_N0: length 196.2
  IN3 w0.099: v2(171.88,87.87) 171.48,88.26 171.18,88.26 171,88.44 168.35,88.44 167.54,89.26 163,89.26 162.15,90.11 137.11,90.11 135.59,88.58 135.59,85.52 134.73,84.66 134.73,82.2 133.39,80.86 132.76,80.86 130,78.11 130,70.82 131.17,69.65 131.17,65.16 132.4,63.94 132.4,58.9 126.48,52.98 126.48,52.1 119.13,44.74 114.68,44.74 114.37,45.06 108.94,45.06 106.04,42.16 106.04,41.38 104.82,40.16 98.72,40.16 93.25,34.69 91.01,34.69 89.12,32.79 88.29,32.79 86.28,30.79 83.1,30.79 82.85,31.05 79.06,31.05 78.54,31.57 73.81,31.57 73.31,31.07 70.69,31.07 69.92,30.3 65.63,30.3 65.02,30.91 52.75,30.91 51.92,31.74 50.93,31.74 49.38,30.19 45.95,30.19 45.05,31.09 45.05,31.65 44.22,32.48 43.76,32.48 42.8,33.44 42.57,33.44 40.21,35.8 39.78,35.8 36.87,38.71 36.87,39.6 37.95,40.69 37.95,42.4 37.58,42.78 36.91,42.78 v2(36.7,42.57)
  BOTTOM w0.076: UH1.K37 172.33,85.9 172.39,85.84 172.56,85.84 172.65,85.92 172.65,86.97 172.31,87.31 172.31,87.98 172.2,88.08 172.09,88.08 v2(171.88,87.87)
  BOTTOM w0.152: v2(36.7,42.57) 36.53,42.74 36.36,42.74 36.21,42.59 35.52,42.59 CT18.2
CPU_DP1_N0_C: length 3.6
  BOTTOM w0.089: 34.05,42.32 33.95,42.32 33.75,42.12 32.56,42.12 32.4,41.96 31.96,41.96 31.89,42.03 31.89,42.08 32.01,42.2 UT1.AC7
  BOTTOM w0.152: 34.05,42.32 34.37,42.63 34.55,42.63 CT18.1
CPU_DP1_N1: length 193
  IN3 w0.099: v2(172.73,83.95) 172.36,84.32 172.36,84.44 172.36,84.44 172.36,84.74 171.88,85.22 171.72,85.22 171.13,85.8 171.13,86.97 170.27,87.83 168.01,87.83 167.22,88.62 162.69,88.62 161.9,89.41 161.04,89.41 140.39,89.41 137.44,89.41 136.09,88.06 136.09,87.84 136.09,85.06 135.2,84.16 135.2,81.48 132.14,78.42 132.14,77.21 131.48,76.54 131.48,72.59 133.19,70.88 133.19,57.96 119.35,44.11 114.34,44.11 114.02,44.44 109.16,44.44 107.57,42.85 107.57,42.07 105.05,39.55 100.09,39.55 94.61,34.06 91.87,34.06 87.98,30.17 81.47,30.17 81.19,30.45 79.73,30.45 79.16,29.88 77.66,29.88 76.78,30.76 73.87,30.76 73.56,30.45 70.91,30.45 70.16,29.7 65.25,29.7 64.64,30.31 53.03,30.31 52.3,29.58 45.45,29.58 44.2,30.84 44.2,31.38 43.82,31.76 42.99,31.76 41.9,32.86 41.9,33.23 39.93,35.2 39.51,35.2 36.27,38.44 36.27,40.77 36.55,41.05 36.76,41.05 v2(36.97,41.26)
  BOTTOM w0.076: v2(172.73,83.95) 173.05,84.26 UH1.J34
  BOTTOM w0.152: v2(36.97,41.26) 36.82,41.12 36.2,41.12 CT20.2
CPU_DP1_N1_C: length 4.1
  BOTTOM w0.089: UT1.AC9 31.98,41.28 31.91,41.35 31.91,41.44 31.99,41.52 32.27,41.52 32.56,41.23 33.73,41.23 33.76,41.26
  BOTTOM w0.152: CT20.1 35.32,41.13 35.08,41.13 34.95,41.26 v3(34.51,41.26) 33.76,41.26
CPU_DP1_N2: length 190.7
  IN3 w0.099: v2(173.76,89.13) 173.57,89.32 173.57,89.59 173.14,90.03 168.94,90.03 168.27,90.7 164.13,90.7 162.82,92.01 136.32,92.01 133.44,89.13 133.44,85.6 131.52,83.68 131.52,83.12 129.92,81.52 129.92,80.5 128.54,79.13 128.54,67.21 122.94,61.61 122.74,61.61 121.15,60.02 121.15,54.04 117.25,50.13 117.25,48.69 115.32,46.76 108.28,46.76 104.08,42.56 98.92,42.56 95.12,38.76 93.08,38.76 91.44,37.12 90.51,37.12 85.75,32.37 83.51,32.37 82.9,32.98 81.22,32.98 80.34,33.86 74.33,33.86 73.96,33.49 70.48,33.49 69.21,32.22 66.35,32.22 65.45,33.12 60.89,33.12 60.6,33.41 59.26,33.41 58.97,33.12 50.08,33.12 49.28,32.31 46.53,32.31 43.99,34.85 43.13,34.85 40.77,37.21 40.39,37.21 40.26,37.34 40.26,40.03 39.98,40.31 v2(38.94,40.31)
  BOTTOM w0.076: v2(173.76,89.13) 173.61,88.97 173.61,88.78 173.91,88.48 173.91,86.65 174.22,86.34 174.22,85.88 UH1.H36
  BOTTOM w0.152: CT22.2 34.91,40.18 38.81,40.18 v2(38.94,40.31)
CPU_DP1_N2_C: length 2.8
  BOTTOM w0.089: 33.47,40.23 33.46,40.23 33.43,40.2 32.57,40.2 32.41,40.36 32.41,40.46 32.28,40.59 32.02,40.59 31.94,40.52 31.94,40.43 32.01,40.36 UT1.AC11
  BOTTOM w0.152: CT22.1 33.97,40.23 33.47,40.23
CPU_DP1_N3: length 189.7
  IN3 w0.099: v2(38.05,39.1) 38.29,38.86 38.51,38.86 38.72,38.65 38.72,37.99 40.12,36.59 40.54,36.59 42.88,34.25 43.69,34.25 46.31,31.64 49.55,31.64 50.44,32.52 54.87,32.52 55.41,31.97 55.91,31.97 56.42,32.49 59.3,32.49 59.75,32.03 65.09,32.03 66.02,31.1 68.95,31.1 70.73,32.88 73.42,32.88 73.93,32.37 78.89,32.37 79.26,31.99 80.49,31.99 80.89,32.38 82.63,32.38 83.33,31.68 86.01,31.68 87.93,33.61 88.73,33.61 90.75,35.62 93.03,35.62 99.37,41.97 104.35,41.97 108.37,45.99 115.64,45.99 120.19,50.54 120.19,51.52 122.16,53.49 125.81,53.49 131.58,59.27 131.58,62.26 129.17,64.67 129.17,78.5 132.36,81.69 132.92,81.69 133.91,82.68 133.91,85.13 134.79,86 134.79,89.13 136.84,91.19 162.26,91.19 162.54,90.91 163.36,90.08 167.97,90.08 168.66,89.39 171.74,89.39 172.67,88.47 172.78,88.47 v2(172.93,88.62)
  BOTTOM w0.076: UH1.J38 173.27,86.86 173.22,86.91 173.22,87.4 173.39,87.57 173.39,88.08 173.21,88.26 173.21,88.44 173.04,88.62 v2(172.93,88.62)
  BOTTOM w0.152: CT24.2 36.49,39.24 37.02,39.24 37.29,38.98 37.93,38.98 v2(38.05,39.1)
CPU_DP1_N3_C: length 4.4
  BOTTOM w0.089: UT1.AC13 31.97,39.56 31.97,39.62 32.04,39.68 32.33,39.68 32.46,39.55 32.46,39.43 32.67,39.21 32.94,39.21 32.98,39.24 33.12,39.24 ; 33.63,39.24 33.66,39.24
  BOTTOM w0.152: CT24.1 35.65,39.24 33.66,39.24 ; 33.12,39.24 33.63,39.24
CPU_DP1_P0: length 196.3
  IN3 w0.099: v2(36.7,43.16) 36.7,43.15 36.89,42.97 37.66,42.97 38.14,42.48 38.14,40.61 37.06,39.52 37.06,38.79 39.86,35.99 40.29,35.99 42.65,33.63 42.88,33.63 43.84,32.67 44.3,32.67 45.24,31.73 45.24,31.17 46.03,30.38 49.3,30.38 50.85,31.93 52,31.93 52.83,31.1 65.1,31.1 65.71,30.49 69.84,30.49 70.61,31.26 73.23,31.26 73.74,31.76 78.62,31.76 79.14,31.24 82.92,31.24 83.18,30.98 86.2,30.98 88.21,32.98 89.04,32.98 90.94,34.88 93.17,34.88 98.64,40.35 104.74,40.35 105.85,41.46 105.85,42.24 108.86,45.25 114.44,45.25 114.76,44.93 119.05,44.93 126.29,52.18 126.29,53.06 132.21,58.98 132.21,63.86 130.98,65.08 130.98,69.57 129.81,70.74 129.81,78.18 132.68,81.05 133.31,81.05 134.54,82.28 134.54,84.74 135.4,85.6 135.4,88.66 137.04,90.3 162.23,90.3 163.08,89.45 167.62,89.45 168.43,88.63 171.08,88.63 171.26,88.45 v2(171.88,88.45)
  BOTTOM w0.076: UH1.K36 172.41,85.65 172.62,85.65 172.82,85.85 172.82,87.05 172.48,87.38 172.48,88.05 172.28,88.26 172.07,88.26 v2(171.88,88.45)
  BOTTOM w0.152: CT17.2 35.48,42.92 36.07,42.92 36.22,43.07 36.62,43.07 v2(36.7,43.16)
CPU_DP1_P0_C: length 3.6
  BOTTOM w0.089: UT1.AB7 31.86,42.43 32.41,42.43 32.53,42.32 33.65,42.32 33.82,42.48 33.82,42.56
  BOTTOM w0.152: 33.82,42.56 33.94,42.67 34.23,42.96 34.47,42.96 CT17.1
CPU_DP1_P1: length 192.9
  IN3 w0.099: v2(36.97,40.68) 36.79,40.86 36.63,40.86 36.46,40.69 36.46,38.52 39.59,35.39 40.01,35.39 42.09,33.31 42.09,32.94 43.07,31.95 43.9,31.95 44.39,31.46 44.39,30.92 45.53,29.77 52.22,29.77 52.96,30.5 64.72,30.5 65.33,29.89 70.08,29.89 70.84,30.64 73.48,30.64 73.79,30.95 76.86,30.95 77.74,30.07 79.08,30.07 79.65,30.64 81.27,30.64 81.55,30.36 87.9,30.36 91.79,34.25 94.53,34.25 100.01,39.74 104.97,39.74 107.38,42.15 107.38,42.93 109.08,44.63 114.09,44.63 114.42,44.3 119.27,44.3 133,58.03 133,70.8 131.29,72.51 131.29,76.62 131.95,77.29 131.95,78.5 135.01,81.56 135.01,84.24 135.9,85.13 135.9,87.84 135.9,88.14 137.36,89.6 140.39,89.6 161.23,89.6 161.98,89.6 162.04,89.54 162.03,89.54 162.77,88.81 167.3,88.81 168.09,88.02 170.35,88.02 171.32,87.05 171.32,85.88 171.79,85.41 171.96,85.41 172.73,84.63 v2(172.73,84.6)
  BOTTOM w0.076: UH1.J35 173.22,85.01 173.33,85.01 173.47,84.86 173.47,84.61 173.41,84.55 172.78,84.55 v2(172.73,84.6)
  BOTTOM w0.152: CT19.2 36.19,40.79 36.86,40.79 v2(36.97,40.68)
CPU_DP1_P1_C: length 4.1
  BOTTOM w0.089: UT1.AB9 31.86,41.05 32.36,41.05 32.44,40.97 33.73,40.97 33.76,40.93
  BOTTOM w0.152: 33.76,40.93 34.81,40.93 34.94,40.8 35.3,40.8 35.39,40.71 CT19.1
CPU_DP1_P2: length 190.7
  IN3 w0.099: v2(38.94,39.73) 39.33,40.12 39.9,40.12 40.07,39.95 40.07,37.26 40.31,37.02 40.69,37.02 43.05,34.66 43.91,34.66 46.45,32.12 49.36,32.12 50.16,32.93 59.05,32.93 59.33,33.22 60.53,33.22 60.81,32.93 65.37,32.93 66.27,32.03 69.29,32.03 70.56,33.3 74.04,33.3 74.4,33.67 80.26,33.67 81.14,32.79 82.82,32.79 83.43,32.18 85.83,32.18 90.59,36.93 91.52,36.93 93.16,38.57 95.2,38.57 99,42.37 104.16,42.37 108.36,46.57 115.4,46.57 117.44,48.61 117.44,50.05 121.34,53.96 121.34,59.94 122.81,61.42 123.01,61.42 128.73,67.13 128.73,79.05 130.11,80.43 130.11,81.44 131.71,83.04 131.71,83.6 133.63,85.52 133.63,89.05 136.4,91.82 162.74,91.82 164.05,90.51 168.19,90.51 168.86,89.84 173.06,89.84 173.38,89.52 173.38,89.32 v2(173.19,89.12)
  BOTTOM w0.076: v2(173.19,89.12) 173.35,88.95 173.35,88.68 173.66,88.37 173.66,86.44 173.51,86.29 173.51,85.89 173.56,85.83 173.78,85.83 173.9,85.95 UH1.H37
  BOTTOM w0.152: v2(38.94,39.73) 38.81,39.85 34.81,39.85 CT21.2
CPU_DP1_P2_C: length 2.7
  BOTTOM w0.089: UT1.AB11 31.86,40.13 32.26,40.13 32.45,39.94 33.44,39.94 33.47,39.9
  BOTTOM w0.152: 33.47,39.9 33.97,39.9 CT21.1
CPU_DP1_P3: length 189.7
  IN3 w0.099: v2(172.92,88.05) 172.69,88.27 172.59,88.27 171.66,89.2 168.58,89.2 167.89,89.89 163.28,89.89 162.18,91 136.92,91 134.98,89.05 134.98,85.92 134.1,85.05 134.1,82.6 133,81.5 132.44,81.5 129.36,78.42 129.36,64.74 131.77,62.34 131.77,59.19 125.89,53.3 122.24,53.3 120.38,51.44 120.38,50.46 115.72,45.8 108.45,45.8 104.43,41.77 99.45,41.77 93.11,35.43 90.83,35.43 88.81,33.42 88.01,33.42 86.08,31.49 83.25,31.49 82.55,32.19 80.96,32.19 80.57,31.8 79.19,31.8 78.81,32.18 73.85,32.18 73.34,32.69 70.81,32.69 69.03,30.91 65.94,30.91 65.01,31.84 59.67,31.84 59.22,32.29 56.5,32.29 55.99,31.78 55.34,31.78 54.79,32.33 50.52,32.33 49.63,31.45 46.23,31.45 43.62,34.06 42.8,34.06 40.46,36.4 40.04,36.4 38.53,37.91 38.53,38.57 38.43,38.67 38.21,38.67 38.21,38.67 v2(38.05,38.51)
  BOTTOM w0.076: UH1.J37 173.12,86.7 173.04,86.78 173.04,87.48 173.21,87.65 173.21,87.9 173.07,88.05 v2(172.92,88.05)
  BOTTOM w0.152: v2(38.05,38.51) 37.92,38.65 37.15,38.65 36.88,38.91 36.49,38.91 CT23.2
CPU_DP1_P3_C: length 4.4
  BOTTOM w0.089: UT1.AB13 31.85,39.22 32.29,39.22 32.56,38.95 32.87,38.95 32.9,38.91 33.03,38.91
  BOTTOM w0.152: 33.03,38.91 v3(33.68,38.91) 35.65,38.91 CT23.1
CPU_DP2_AUXN: length 184.9
  TOP w0.152: CT107.2 34.07,38.93 34.61,38.93 35.31,38.23 v3(35.31,37.29) 35.31,37.06 35.48,36.88 35.48,36.13 v2(35.35,35.99)
  IN3 w0.089: 80.71,29.08 80.72,29.06 80.73,29.06 80.97,28.82 85.67,28.82 85.68,28.82 85.73,28.82 85.74,28.81 85.76,28.81 ; 170.79,80.14 171.1,80.44 172.38,80.44 173.48,79.35 173.48,78.54 173.79,78.23 174.08,78.23 174.39,77.93 174.73,77.93 v2(175.15,78.35)
  IN3 w0.099: v2(35.35,35.99) 35.57,35.77 35.57,35.6 35.87,35.3 37.5,35.3 38.9,33.9 39.36,33.9 39.96,33.3 39.96,32.49 40.74,31.7 40.74,31.03 43.56,28.22 52.73,28.22 53.38,28.87 55.28,28.87 55.78,28.37 67.93,28.37 68.5,27.8 70.18,27.8 71.57,29.18 73.88,29.18 73.97,29.1 75.16,29.1 75.39,29.33 76.4,29.33 77.05,28.68 79.76,28.68 80.23,29.15 80.63,29.15 80.71,29.08 ; 134.82,57.34 134.81,57.35 134.53,57.35 115.03,37.85 101.07,37.85 95.98,32.76 92.45,32.76 88.51,28.81 85.76,28.81
  IN3 w0.112: 170.79,80.14 169.6,78.94 153.04,78.94 152.19,79.79 143.65,79.79 143.24,79.38 143.24,73.03 142.85,72.64 142.3,72.64 141.48,71.83 140.7,71.83 140.03,71.15 138.2,71.15 137.95,70.91 137.95,69.14 137.35,68.54 137.35,66.14 137.61,65.88 137.61,59.36 135.58,57.34 134.82,57.34
  BOTTOM w0.076: v2(175.15,78.35) 175.15,78.4 UH1.E26
CPU_DP2_AUXN_C: length 4.5
  TOP w0.089: CT107.1 33.22,38.94 v1(32.46,38.94) 31.9,38.94 31.71,39.13 31.16,39.13 30.83,39.46 30.56,39.46 29.96,40.07 v2(29.96,40.22)
  BOTTOM w0.102: UT1.W12 v2(29.96,40.22)
