# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DMI_CRX_PTX_P1: length 124.6
  IN3 w0.089: 177.12,55.7 177.12,55.7 177.05,55.77 177.05,60.75 175.29,62.51 175.29,63.47 175.52,63.7 175.52,63.87 v2(175.81,64.16)
  IN3 w0.099: v2(180.43,53.77) 180.27,53.61 179.22,53.61 177.12,55.7
  BOTTOM w0.076: v2(175.81,64.16) 175.77,64.16 175.48,63.87 UH1.E6
  BOTTOM w0.089: 84.71,29.17 84.69,29.15 84.69,29.06 84.37,28.73 84.37,27.07 84.09,26.79 84.09,26.47 84,26.38 83.89,26.38 83.81,26.45 83.81,26.54 UH2.B32
  BOTTOM w0.152: v2(180.43,53.77) 180.32,53.66 179.55,53.66 167.44,41.56 119.08,41.56 109.31,31.79 104.46,31.79 103.55,30.89 98.2,30.89 97.01,32.08 91.94,32.08 90.18,30.32 85.86,30.32 84.71,29.17
DMI_CRX_PTX_P2: length 126.2
  IN3 w0.099: v2(176.44,63.35) 176.28,63.35 176.21,63.28 176.21,63.02 177.61,61.62 177.61,56.06 178.45,55.22 179.3,54.37 180.82,54.37 180.91,54.47 180.91,54.58 180.86,54.64 180.52,54.64 180.44,54.72 180.44,54.89 v2(180.52,54.97)
  BOTTOM w0.076: UH1.D5 176.13,62.9 176.19,62.84 176.31,62.84 176.44,62.97 v2(176.44,63.35)
  BOTTOM w0.089: 86.18,29.1 86.16,29.1 86.09,29.03 85.95,29.03 84.95,28.03 84.95,26.89 84.81,26.75 84.81,26.58 84.67,26.44 84.58,26.44 UH2.B31
  BOTTOM w0.152: 86.18,29.1 88.12,29.1 88.51,29.49 90.49,29.49 92.26,31.26 v3(94.18,31.26) 96.67,31.26 97.82,30.1 103.88,30.1 104.78,31 109.84,31 119.39,40.55 167.55,40.55 179.66,52.66 180.63,52.66 180.96,52.99 181.2,52.99 181.48,53.27 181.48,53.86 181.02,54.33 180.54,54.33 180.36,54.5 180.36,54.81 v2(180.52,54.97)
DMI_CRX_PTX_P3: length 130.7
  IN3 w0.099: v2(173.86,64.95) 173.7,65.11 173.7,65.28 173.77,65.36 174.09,65.36 174.32,65.12 174.32,62.15 175.08,61.4 175.08,60.59 174.63,60.14 174.63,57.86 176.01,56.47 176.01,55.88 176.01,55.7 179.29,52.43 181.05,52.43 181.52,52.9 182.02,52.9 182.13,52.79 182.13,52.56 v2(181.74,52.17)
  BOTTOM w0.076: v2(173.86,64.95) 173.54,64.95 UH1.J8
  BOTTOM w0.089: 86.89,27.86 86.87,27.86 86.8,27.79 86.52,27.79 85.64,26.91 85.64,26.62 85.51,26.48 85.41,26.48 85.31,26.58 85.31,26.65 UH2.B29
  BOTTOM w0.152: v2(181.74,52.17) 181.93,51.98 181.93,51.84 181.79,51.7 179.82,51.7 164.26,36.15 120.5,36.15 119.05,37.59 117.57,37.59 110.19,30.21 105.11,30.21 104.21,29.31 97.49,29.31 96.36,30.44 92.59,30.44 90.48,28.34 88.96,28.34 88.48,27.86 86.89,27.86
DMI_CTX_PRX_N0: length 133.1
  IN2 w0.107: v2(103.92,33.16) 104.35,32.73 104.35,32.59 101.68,29.92 92.35,29.92 90.73,28.31 87.74,28.31 86.5,27.06 86.5,23.1 85.78,22.39 82.75,22.39 82.6,22.54 82.6,22.92 82.79,23.11 83.22,23.11 v2(83.41,22.91)
  BOTTOM w0.076: UH1.A8 178,64.47 177.78,64.47 177.71,64.54 177.71,64.78 177.83,64.9 178.24,64.9 178.38,64.75 179.84,64.75 179.93,64.66 179.93,64.66
  BOTTOM w0.152: UH2.K34 82.49,22.73 82.49,22.95 82.6,23.06 83.27,23.06 v2(83.41,22.91) ; v2(103.92,33.16) 103.94,33.16 104.07,33.29 104.07,34.19 103.69,34.57 103.69,37.3 105.78,39.38 114.55,39.38 118.93,43.77 167.25,43.77 178.07,54.59 178.07,54.91 180.1,56.94 181.94,60.81 181.94,62.42 180.54,63.81 180.54,64.28 180.51,64.32 180.16,64.66 179.93,64.66
DMI_CTX_PRX_N1: length 128.3
  IN2 w0.107: v2(102.26,35.9) 102.48,35.68 102.48,35.5 102.36,35.38 100.75,35.38 100.66,35.47 92.89,35.47 91.92,34.5 90.67,34.5 89.63,33.47 86.95,33.47 85.94,32.46 85.66,32.46 83.67,30.47 83.67,26.29 82.97,25.58 82.97,24.86 82.66,24.55 82.66,24.18 82.91,23.93 83.43,23.93 83.62,24.12 v2(83.91,24.12)
  BOTTOM w0.076: UH1.B6 177.18,63.77 177.06,63.88 177.06,63.99 177.16,64.09 179.21,64.09 179.46,63.83 179.46,63.71 179.48,63.7
  BOTTOM w0.152: v2(83.91,24.12) 83.86,24.17 83.55,24.17 UH2.G33 ; 179.48,63.7 180.52,62.65 180.52,60.66 179.15,57.91 179.15,57.1 177.28,55.23 177.28,54.92 167.2,44.84 118.9,44.84 114.39,40.34 109.91,40.34 108.87,41.38 106.32,41.38 102.62,37.68 102.62,36.67 102.42,36.47 102.42,36.05 v2(102.26,35.9)
DMI_CTX_PRX_N2: length 125.4
  IN2 w0.107: v2(84.35,22.9) 84.48,23.13 85.76,23.51 86.04,23.79 86.04,27.21 86.15,27.31 86.15,27.82 88.93,30.6 99.71,30.6 101.55,32.44 101.55,32.98 101.1,33.44 101.1,33.8 101.25,33.95 101.42,33.95 v2(101.68,33.69)
  BOTTOM w0.076: 179.45,61.79 179.45,61.81 179.52,61.88 179.52,62.68 178.89,63.31 178.04,63.31 177.91,63.19 177.91,63.09 178,63.01 UH1.A5
  BOTTOM w0.152: v2(101.68,33.69) 101.49,33.89 101.05,33.89 100.65,34.29 v3(100.65,35.42) 100.65,36.96 102.28,38.59 102.28,40.53 106.6,44.86 117.29,44.86 118.19,45.76 166.99,45.76 176.39,55.15 176.39,55.44 178.23,57.28 178.23,58.21 179.45,60.75 179.45,61.79 ; UH2.K32 84.03,22.58 v2(84.35,22.9)
DMI_CTX_PRX_N3: length 124.4
  IN2 w0.107: v2(85.47,24.06) 85.22,24.06 85.13,23.96 84.71,23.96 84.49,24.17 84.49,29.9 86.1,31.51 89.42,31.51 91.54,32.39 100,32.39 100.19,32.57 v2(100.19,32.87)
  BOTTOM w0.076: UH1.B4 177.05,62.33 176.86,62.33 176.8,62.26 176.8,62.15 176.98,61.96 177.29,61.96 177.87,62.54 178.21,62.54 178.44,62.31 178.44,60.65 178.18,60.4 178.06,60.4 178.05,60.38
  BOTTOM w0.152: v2(100.19,32.87) 100.19,33.61 99.79,34.01 99.79,37.56 101.12,38.89 101.12,40.62 106.19,45.7 114.83,45.7 116.21,47.08 120.36,47.08 120.88,46.56 166.68,46.56 177.42,57.3 177.42,58.55 177.68,59.06 177.68,60.01 178.05,60.38 ; UH2.G30 v2(85.47,24.06)
DMI_CTX_PRX_P0: length 133.1
  IN2 w0.107: v2(82.94,23.5) 82.66,23.26 82.39,23 82.39,22.46 82.67,22.18 85.86,22.18 86.7,23.02 86.7,26.97 87.83,28.1 90.82,28.1 92.43,29.72 101.77,29.72 104.56,32.51 v2(104.56,33.16)
  BOTTOM w0.076: 179.93,64.99 179.92,64.99 179.84,64.91 178.45,64.91 178.3,65.06 177.74,65.06 177.53,64.85 177.53,64.66 UH1.B8
  BOTTOM w0.152: UH2.J35 82.53,23.39 v2(82.94,23.5) ; v2(104.56,33.16) 104.54,33.16 104.4,33.3 104.4,34.32 104.02,34.7 104.02,37.16 105.91,39.05 114.69,39.05 119.07,43.44 167.39,43.44 178.4,54.45 178.4,54.77 180.37,56.74 182.27,60.74 182.27,62.55 180.87,63.95 180.87,64.42 180.3,64.99 179.93,64.99
DMI_CTX_PRX_P1: length 128.3
  IN2 w0.107: v2(83.59,24.59) 83.59,24.38 83.35,24.13 83,24.13 82.86,24.27 82.86,24.47 83.17,24.77 83.17,25.49 83.87,26.2 83.87,30.39 85.74,32.25 86.02,32.25 87.03,33.26 89.72,33.26 90.75,34.3 92,34.3 92.97,35.27 100.58,35.27 100.67,35.18 102.44,35.18 102.68,35.42 102.68,35.68 v2(102.9,35.9)
  BOTTOM w0.076: UH1.C6 176.88,63.87 176.88,64.04 177.09,64.25 179.27,64.25 179.58,63.94 179.7,63.94 179.71,63.93
  BOTTOM w0.152: UH2.F34 83.49,24.7 v2(83.59,24.59) ; 179.71,63.93 180.85,62.79 180.85,60.58 179.48,57.84 179.48,56.96 177.61,55.1 177.61,54.79 167.33,44.51 119.03,44.51 114.53,40.01 109.78,40.01 108.73,41.05 106.45,41.05 102.95,37.55 102.95,36.53 102.75,36.33 102.75,36.05 v2(102.9,35.9)
DMI_CTX_PRX_P2: length 125.4
  IN2 w0.107: v2(84.2,23.49) 84.47,23.34 85.66,23.69 85.84,23.88 85.84,27.29 85.94,27.4 85.94,27.9 88.84,30.8 99.62,30.8 101.35,32.53 101.35,32.9 100.89,33.35 100.89,33.88 101.17,34.16 101.56,34.16 v2(101.68,34.28)
  BOTTOM w0.076: UH1.B5 177.48,63.01 177.96,63.49 178.96,63.49 179.69,62.76 179.69,61.89 179.78,61.81 179.78,61.79
  BOTTOM w0.152: UH2.J32 84.02,23.31 v2(84.2,23.49) ; 179.78,61.79 179.78,60.68 178.56,58.13 178.56,57.14 176.72,55.3 176.72,55.02 167.13,45.43 118.32,45.43 117.43,44.53 106.74,44.53 102.61,40.4 102.61,38.45 100.98,36.82 100.98,34.43 101.19,34.22 101.62,34.22 v2(101.68,34.28)
DMI_CTX_PRX_P3: length 124.4
  IN2 w0.107: v2(100.77,32.87) 100.08,32.18 91.58,32.18 89.46,31.31 86.18,31.31 84.7,29.82 84.7,24.26 84.79,24.16 85.04,24.16 85.2,24.32 v2(85.2,24.56)
  BOTTOM w0.076: 178.28,60.15 178.3,60.16 178.3,60.28 178.6,60.58 178.6,62.38 178.27,62.7 177.8,62.7 177.67,62.57 176.87,62.57 UH1.D4
  BOTTOM w0.152: v2(85.2,24.56) 85.11,24.47 84.9,24.47 84.66,24.71 UH2.F30 ; v2(100.77,32.87) 100.52,33.23 100.52,33.75 100.12,34.15 100.12,37.42 101.45,38.75 101.45,40.48 106.33,45.37 114.96,45.37 116.35,46.75 120.22,46.75 120.74,46.23 166.82,46.23 177.75,57.16 177.75,58.47 178.01,58.99 178.01,59.87 178.28,60.15
DMIC_CLK_CODEC: length 212
  TOP w0.14: CA35.1 13.67,35.89 v2(13.97,36.2)
  IN1 w0.099: v2(63.15,1.53) 63.59,1.09 65.27,1.09 65.39,1.22 74.26,1.22 74.41,1.07 89.97,1.07 90.58,1.68 91.73,1.68 92.29,1.12 113.73,1.12 114.28,1.67 114.28,2.21 v2(114.29,2.22) ; v2(10.62,10.44) 7.79,13.27 7.79,16.73 7.7,16.82 7.7,22.36 2.28,27.78 2.28,31.36 3.29,32.36 3.29,34.45 5.08,36.25 10.8,36.25 11.49,36.93 13.12,36.93 13.86,36.2 v2(13.97,36.2)
  IN3 w0.091: v2(63.15,1.53) 62.74,1.12 62.21,1.12 61.79,1.54 61.79,1.96 59.74,4.01 59.74,4.48 59.04,5.18 59.04,7.01 57.7,8.35 56.97,8.35 56.09,9.23 56.09,10.41 56.35,10.66 56.35,12.35 55.37,13.32 54.31,13.32 53.57,14.07 53.57,14.79 52.33,16.03 50.87,16.03 46.65,20.26 44.43,20.26 44.14,19.97 44.14,19.52 43.27,18.64 33.99,18.64 30.76,15.42 30.76,14.09 28.7,12.03 12.21,12.03 v2(10.62,10.44) ; v2(148.52,6.67) 148.39,6.54 146.01,6.54 144.79,7.76 142.38,7.76 141.07,6.45 141.07,5.96 140.45,5.33 140.45,4.3 139.22,3.07 134.93,3.07 134.48,2.62 133.31,2.62 133.19,2.74 131.44,2.74 131.08,2.38 125.16,2.38 124.65,2.89 117.02,2.89 116.67,2.54 115.49,2.54 115.28,2.74 114.22,2.74 114.14,2.66 114.14,2.37 v2(114.29,2.22)
  BOTTOM w0.108: v2(13.97,36.2) 13.84,36.32 13.84,36.38 12.8,37.43 UA1.53
  BOTTOM w0.14: RE116.1 152.56,10.83 151.07,10.83 150.76,10.52 v1(150.48,10.52) 150.25,10.52 149.11,9.37 DE9.2 149.11,8.51 148.6,8 148.6,6.9 148.52,6.82 v2(148.52,6.67)
DMIC_CLK_CODEC_C: length 6.6
  TOP w0.14: v2(155.18,11.74) v5(155.77,11.74)
  BOTTOM w0.14: RE310.2 153.57,11.69 RE116.2 153.67,10.92 CE73.1 154.48,11.74 v2(155.18,11.74) 155.32,11.6 157.65,11.6 157.8,11.44 JKB.12
DMIC_DAT_CODEC: length 209.2
  IN1 w0.099: v2(8.64,13.62) 8.2,14.06 8.2,16.88 8,17.07 8,22.49 2.6,27.88 2.6,31.24 3.59,32.23 3.59,34.29 5.23,35.93 10.84,35.93 11.16,35.62 12.09,35.62 12.59,36.12 v2(13.27,36.12) ; v2(113.62,2.22) 113.65,2.19 113.65,1.67 113.41,1.42 92.48,1.42 91.92,1.98 90.43,1.98 89.84,1.4 83.76,1.4 83.19,1.97 82.68,1.97 82.23,1.53 77.41,1.53 76.91,2.02 75.61,2.02 75.11,1.52 67.78,1.52 67.19,2.11 64.29,2.11 v2(63.74,1.55)
  IN3 w0.091: v2(8.64,13.62) 8.83,13.62 9.2,13.25 9.2,12.95 9.71,12.44 28.69,12.44 30.47,14.21 30.47,15.54 33.93,19 41.1,19 42.2,20.1 43.77,20.1 44.22,20.55 46.78,20.55 48.1,19.23 52,19.23 52.62,18.61 52.62,16.15 53.86,14.91 53.86,14.19 54.44,13.62 55.5,13.62 56.64,12.47 56.64,10.54 56.39,10.29 56.39,9.35 57.09,8.65 57.88,8.65 59.34,7.19 59.34,5.3 60.05,4.6 60.05,4.12 61.97,2.2 63.09,2.2 v2(63.74,1.55) ; v2(113.62,2.22) 113.85,2.45 113.85,2.78 114.1,3.04 115.41,3.04 115.61,2.83 116.54,2.83 116.9,3.19 124.77,3.19 125.27,2.69 130.97,2.69 131.32,3.03 133.32,3.03 133.44,2.91 134.36,2.91 134.81,3.36 139.09,3.36 140.11,4.38 140.11,5.41 140.78,6.08 140.78,6.57 142.26,8.06 144.92,8.06 146.14,6.84 148.12,6.84 148.35,7.07 148.86,7.07 149.09,6.84 v2(149.09,6.79)
  BOTTOM w0.108: CA36.1 13.27,35.62 v2(13.27,36.12)
  BOTTOM w0.14: v2(149.09,6.79) 148.94,6.94 148.94,7.86 149.98,8.89 DE9.3 150.11,9.82 150.4,10.11 150.87,10.11 151.22,10.46 151.72,10.46 152.15,10.03 RE117.1 ; v2(13.27,36.12) 13.27,36.43 12.68,37.03 UA1.54
DMIC_DAT_CODEC_C: length 12.3
  TOP w0.14: v2(158.3,8.08) v5(159.19,7.19)
  BOTTOM w0.14: JKB.11 158.3,10.24 157.9,9.84 157.6,9.84 157.3,9.55 157.3,9.06 157.6,8.76 158.01,8.76 158.3,8.47 v2(158.3,8.08) 156.83,8.08 156.08,8.83 155.51,8.83 CE74.1 154.31,10.03 RE117.2 153.44,9.9 RE309.2
DOCK_TNY_SMB_CLK: length 107.5
  TOP w0.14: v2(55.68,26.85) 55.68,26.89 56.1,27.31 59.31,27.31 61.17,25.44 63.01,25.44 63.62,26.06 63.62,27.28 64.1,27.76 66.49,27.76 69.84,31.11 69.84,32.33 73.53,36.02 v3(74.92,36.02) 77.02,36.02 77.38,36.39 80.47,36.39 80.85,36 81.15,36 RE109.1
  IN2 w0.099: v2(19.29,63.88) 19.18,64 19.18,64.33 18.84,64.67 18.36,64.67 17.82,64.13 17.82,62.69 16.88,61.75 16.88,57.92 16.56,57.6 16.56,54.77 17.38,53.96 17.38,47.85 17.81,47.42 17.81,41.91 20.1,39.61 20.1,37.73 23.12,34.72 30.26,34.72 32.04,32.95 33.84,32.95 34.11,32.68 34.11,32.19 37.34,28.96 37.34,27.98 38.88,26.44 44.86,26.44 45.87,25.43 47.57,25.43 49.35,27.21 52.32,27.21 52.95,27.84 55.23,27.84 55.76,27.31 55.76,26.93 v2(55.68,26.85)
  BOTTOM w0.14: v2(19.29,63.88) 19.17,63.76 19.17,63.45 RT184.1
DOCK_TNY_SMB_DAT: length 105.4
  TOP w0.14: RE108.1 81.15,35.61 80.69,35.61 80.3,35.99 77.55,35.99 77.18,35.62 v3(76.92,35.62) 73.7,35.62 70.19,32.11 70.19,30.97 66.64,27.42 64.32,27.42 64.02,27.12 64.02,25.9 63.17,25.05 61.08,25.05 59.22,26.92 56.31,26.92 v2(56.28,26.88)
  IN2 w0.099: v2(18.71,63.88) 18.82,64 18.82,64.19 18.7,64.31 18.5,64.31 18.17,63.98 18.17,62.54 17.23,61.6 17.23,57.77 16.92,57.46 16.92,54.92 17.73,54.1 17.73,48 18.16,47.57 18.16,42.06 20.46,39.76 20.46,37.88 23.26,35.08 30.41,35.08 32.18,33.3 33.99,33.3 34.46,32.83 34.46,32.34 37.69,29.11 37.69,28.12 39.02,26.79 45.01,26.79 46.02,25.78 47.42,25.78 49.2,27.56 52.17,27.56 52.81,28.2 55.37,28.2 56.11,27.46 56.11,27.05 v2(56.28,26.88)
  BOTTOM w0.14: v2(18.71,63.88) 18.82,63.77 18.82,63.28 RT185.1
DPM_REXT: length 2.6
  TOP w0.14: UI3.7 321.48,32.68 321.06,32.26 RI23.1 v1(320.04,32.13)
DPSRC_RBIAS: length 4.2
  TOP w0.089: RT2.1 29.85,42.11 28.89,41.16 v1(28.34,41.16) 27.82,41.16 27.61,41.36 27.61,41.77 27.99,42.15 v2(27.99,42.17)
  BOTTOM w0.102: v2(27.99,42.17) 27.99,42.19 UT1.N6
DTH_CSCL: length 10.7
  TOP w0.14: v2(26.04,69.6) 26.43,69.2 RM18.1 26.58,68.21 26.91,68.54 T4936.1 27.31,68.1 27.1,67.9 RM14.2 ; UM1.E6 21.16,73.81 v2(21.57,73.39)
  IN2 w0.099: v2(26.04,69.6) 25.88,69.75 24.99,69.75 22.42,72.32 22.42,73.06 21.96,73.52 21.7,73.52 v2(21.57,73.39)
DTH_CSDA: length 11.2
  TOP w0.14: UM1.F6 v2(21.57,74.19) ; v2(25.91,70.23) 25.53,69.85 25.53,69.48 T4937.1 26.01,69 26.01,68.43 RM16.2 25.53,68.21 25.4,68.09 25.4,67.39 25.21,67.2 RM17.1
  IN2 w0.099: v2(25.91,70.23) 25.66,69.98 25.13,69.98 22.64,72.46 22.64,73.15 21.91,73.88 21.75,73.88 21.57,74.07 v2(21.57,74.19)
DTH_PDB: length 14.4
  TOP w0.14: UM1.C3 v2(23.18,72.58) ; RM27.2 26.95,76.46 RV561.1 ; RM27.2 27.81,77.37 RM5.1 ; RM27.2 v2(28.45,77.34)
  IN1 w0.099: v2(23.18,72.58) 23.31,72.58 23.88,72.01 24.36,72.01 25.4,70.96 26.47,70.96 27.2,71.69 27.2,73.14 27.4,73.34 27.4,76.29 v2(28.45,77.34)
DTH_RST#: length 7.3
  TOP w0.14: UM1.B8 19.55,71.15 18.49,70.09 v1(18.49,69.01) 18.49,68.33 19.03,67.79 19.03,67.65 19.37,67.31 19.69,67.31 20.32,66.68 CM41.1 21.2,66.68 RM6.2
DTH_SPI_CK_OUT: length 31.2
  TOP w0.14: UM1.D2 24.79,72.58 25.37,72.58 25.76,72.19 v2(26.15,72.19) 26.33,72.01 RM9.1
  IN3 w0.091: v2(26.15,72.19) 25.69,72.19 25.29,72.59 25.29,73.12 25.46,73.29 25.46,74.63 24.75,75.34 24.41,75.34 23.92,75.83 23.92,76.22 24.29,76.59 24.29,78.78 23.72,79.36 23.72,84.91 25.58,86.77 25.58,90.32 24.46,91.44 24.46,93.09 v2(25.25,93.88)
  BOTTOM w0.14: UM2.6 23.78,93.22 24.44,93.88 v2(25.25,93.88)
DTH_SPI_CS: length 32.5
  TOP w0.14: v2(26.14,94.69) v1(26.82,94.69) 27.62,94.69 RM7.2 ; v2(26.18,71.6) 25.85,71.6 25.25,72.21 UM1.C1
  IN3 w0.091: v2(26.18,71.6) 25.81,71.6 25,72.42 25,73.25 25.17,73.42 25.17,74.5 24.63,75.04 24.29,75.04 23.62,75.7 23.62,76.14 23.25,76.52 23.25,84.97 25.28,87.01 25.28,90.2 24.13,91.35 24.13,93.6 25.22,94.69 v2(26.14,94.69)
  BOTTOM w0.14: v2(26.14,94.69) 26.14,95.1 26.8,95.76 UM2.1
DTH_SPI_D_IN: length 30.5
  TOP w0.14: UM1.C2 v2(23.95,72.61)
  IN1 w0.099: v2(26.4,94.13) 26.4,94.02 25.86,93.47 24.89,93.47 24.64,93.22 24.64,91.79 25.15,91.28 25.15,83.95 27.17,81.92 27.17,73.44 26.97,73.24 26.97,71.79 26.38,71.19 25.5,71.19 24.08,72.61 v2(23.95,72.61)
  BOTTOM w0.14: v2(26.4,94.13) 26.77,94.49 UM2.2
DTH_SPI_D_OUT: length 28.6
  TOP w0.14: v2(25.81,72.98) 25.79,73.01 UM1.D1
  IN3 w0.091: v2(25.81,72.98) 25.76,73.04 25.76,75.39 24.59,76.56 24.59,79.05 24.01,79.62 24.01,84.75 25.96,86.69 25.96,88.85 27.64,90.53 27.64,92.56 26.87,93.32 25.32,93.32 v2(25.07,93.07)
  BOTTOM w0.14: UM2.5 23.39,91.95 24.57,93.13 25.01,93.13 v2(25.07,93.07)
DTH_SPI_WR_PROT: length 32.5
  TOP w0.14: v2(25.82,94.15) 25.82,93.88 v1(26.44,93.26) RM28.1 ; UM1.E2 23.94,74.22 v2(23.94,74.23)
  IN1 w0.099: v2(25.82,94.15) 25.58,94.39 25.17,94.39 24.41,93.63 24.41,91.7 24.89,91.21 24.89,79.88 26.94,77.84 26.94,73.53 25.97,72.57 25.3,72.57 23.94,73.92 v2(23.94,74.23)
  BOTTOM w0.14: v2(25.82,94.15) 25.82,93.88 26.48,93.22 UM2.3
DTH_VDD12: length 9.5
  TOP w0.203: v2(22.47,76.89) 22.35,76.78 22.35,75.01 UM1.F5
  TOP w0.254: v2(20.75,72.61) UM1.D6
  IN3 w0.508: v2(20.75,72.61) 20.75,73.08 19.86,73.97 19.86,75.54 21.22,76.89 v2(22.47,76.89)
DTH_VDD12_ON: length 23
  TOP w0.14: v2(11.46,75.28) 11.76,75.58 11.81,75.58 12.31,76.08 12.85,76.08 13.51,76.74 14.88,76.74 15.06,76.56 v1(17.7,76.56) 18.7,76.56 19.19,76.07 19.19,75.77 UM1.G8
  BOTTOM w0.14: UZ25.3 14.98,66.54 15.99,67.55 15.99,69.48 15.57,69.89 12.54,69.89 12.41,70.02 12.41,72.4 11.85,72.96 RM21.2 11.85,74.89 v2(11.46,75.28)
DTH_VDD33: length 17.1
  TOP w0.254: v2(23.14,75.78) 23.13,75.78 UM1.G4 ; v2(24.74,75.8) UM1.G2 ; UM1.B2 v2(24.77,70.99)
  IN1 w0.508: v2(24.77,70.99) 23.92,70.99 23.12,71.79 19.28,71.79 18.31,72.76 18.31,74.55 20.18,76.42 21.82,76.42 22.46,75.78 v2(23.14,75.78)
  BOTTOM w0.381: CM4.2 v2(24.77,70.99)
  vias: v1(23.85,75.65)
DTH_VDDA12: length 0.6
  TOP w0.254: UM1.F4 22.75,74.55 v2(22.39,74.19)
  vias: v1(22.25,75.07)
DTH_VDDRX12: length 1.2
  TOP w0.254: UM1.B5 21.95,71.39 v2(22.35,70.99) 22.75,71.39 UM1.B4
  vias: v1(25.1,73.5) v2(24.76,74.2)
DTH_VDDTX12: length 5.8
  TOP w0.14: UM1.G5 v2(21.57,75.79)
  TOP w0.254: UM1.G7 20.41,75.41 v2(20.81,75.01) ; v2(19.95,71.01) UM1.B7
  IN2 w0.381: v2(21.57,75.79) 20.81,75.04 v2(20.81,75.01)
  IN2 w0.508: v2(19.95,72.61) 19.95,74.51 20.45,75.01 v2(20.81,75.01)
  vias: v1(21.03,75.53)
DTH_XTLI: length 5.1
  TOP w0.152: RM103.1 17.7,73.18 RM1834.1 16.44,73.72 CM43.1 16.27,73.86 15.87,73.46 15.87,73.35 15.65,73.12 14.48,73.12 13.78,73.82 YM1.1
DTH_XTLI_R: length 1.8
  TOP w0.14: RM103.2 18.06,73.94 19.42,73.94 UM1.E8
DTH_XTLO: length 3.1
  TOP w0.152: YM1.3 16.14,74.92 CM44.1 16.42,74.63 RM1834.2 17.58,75.04 RM102.1
DTH_XTLO_R: length 1.7
  TOP w0.14: RM102.2 19.4,74.45 UM1.F8
EC_SLP_S0IX#: length 4.1
  TOP w0.089: v2(83.57,6.98) 83.52,6.98 83.36,7.14 83.36,7.68 83.68,8 83.68,8.23 v1(83.99,8.54) 84.01,8.56 84.63,8.56 85.09,9.02 RH535.1
  BOTTOM w0.089: UH2.BC33 83.45,6.87 v2(83.57,6.98)
EC_SMB_CK2_PX: length 24.5
  TOP w0.14: RV326.2 201.12,48.1 201.33,47.88 v2(201.33,47.48) 201.74,47.07 QV21.1
  IN6 w0.099: v2(201.33,47.48) 201.48,47.48 201.6,47.61 201.6,48.21 201.5,48.31 201.01,48.31 200.92,48.41 200.92,48.61 201.01,48.71 201.5,48.71 201.6,48.81 201.6,49 201.5,49.1 201.01,49.1 200.92,49.2 200.92,49.4 201.01,49.5 201.5,49.5 201.6,49.6 201.6,49.8 201.5,49.9 201.01,49.9 200.92,50 200.92,50.19 201.23,50.51 201.23,55.61 205.66,60.04 207.44,60.04 207.98,60.58 208.66,60.58 208.87,60.36 208.95,60.36 v2(209.17,60.58)
  BOTTOM w0.14: v2(209.17,60.58) UV18.T4
EC_SMB_DA2_PX: length 26.9
  TOP w0.14: RV325.2 200.14,48.45 v1(199.42,47.73) 199.21,47.52 v2(199.21,47.09) 199.91,46.4 199.91,45.09 200.44,44.55 QV21.4
  IN6 w0.099: v2(199.21,47.09) 200.94,47.09 201.17,46.86 201.55,46.86 202.09,47.4 202.09,50 201.59,50.5 201.59,55.46 205.81,59.68 207.59,59.68 208.13,60.22 208.51,60.22 208.73,60.01 208.98,60.01 v2(209.19,59.8)
  BOTTOM w0.14: UV18.T3 v2(209.19,59.8)
EDP_AUXN: length 179.2
  IN1 w0.089: 179.9,79.34 179.8,79.24 179.72,79.24 179.51,79.03 179.51,78.77 179.41,78.67 v2(179.14,78.67)
  IN1 w0.107: v2(61.96,26.89) 61.56,27.29 61.56,27.57 62.22,28.24 66.31,28.24 71.14,33.07 76.5,33.07 77.07,33.63 80.54,33.63 81.09,33.08 82.67,33.08 85.33,35.74 87.72,35.74 90.74,38.77 93.87,38.77 97.28,42.18 100.34,42.18 112.29,54.14 113.06,54.14 117.92,59 117.92,63.58 123.09,68.75 123.09,70.74 123.68,71.33 123.68,85.57 130.55,92.44 177.13,92.44 177.74,91.83 180.21,91.83 180.91,91.13 180.91,89.24 181.22,88.93 181.22,88.28 181,88.06 181,84.86 181.45,84.42 181.45,80.88 179.9,79.34
  BOTTOM w0.076: UH1.B26 177.38,78.78 177.15,78.78 177.06,78.69 177.06,78.55 177.2,78.4 178.31,78.4 178.55,78.16 178.65,78.16 178.69,78.2 179.23,78.2 179.5,78.47 179.5,78.72 179.42,78.8 179.28,78.8 v2(179.14,78.67)
  BOTTOM w0.152: v2(61.96,26.89) 61.76,27.09 61.76,27.45 61.83,27.52 CV166.1
EDP_AUXN_C: length 0.8
  BOTTOM w0.152: RV528.1 61.82,28.64 61.82,28.26 CV166.2
EDP_AUXN_R: length 7.7
  BOTTOM w0.152: JEDP1.15 60.73,35.75 60.64,35.66 60.64,34.91 60.65,34.91 60.65,34.84 60.64,34.84 60.64,34.77 60.65,34.2 60.65,31.43 61.82,30.25 61.82,29.53 RV528.2
EDP_AUXP: length 179.2
  IN1 w0.089: 180.05,79.2 180.03,79.18 180.02,79.18 179.89,79.05 179.8,79.05 179.69,78.95 179.69,78.83 v2(179.86,78.67)
  IN1 w0.107: v2(61.35,26.89) 61.35,27.65 62.14,28.44 66.22,28.44 71.06,33.27 76.42,33.27 76.98,33.84 80.63,33.84 81.17,33.29 82.59,33.29 85.24,35.94 87.63,35.94 90.66,38.97 93.78,38.97 97.2,42.39 100.25,42.39 112.21,54.34 112.98,54.34 117.72,59.09 117.72,63.66 122.89,68.84 122.89,70.83 123.48,71.42 123.48,85.66 130.47,92.65 177.21,92.65 177.82,92.04 180.29,92.04 181.12,91.21 181.12,89.32 181.42,89.02 181.42,88.19 181.2,87.98 181.2,84.95 181.65,84.5 181.65,80.8 180.05,79.2
  BOTTOM w0.076: v2(179.86,78.67) 179.75,78.56 179.75,78.37 179.41,78.02 178.83,78.02 178.79,77.98 178.73,77.98 178.71,77.97 178.67,77.97 178.65,77.99 178.47,77.99 178.24,78.22 177.13,78.22 176.88,78.47 176.88,78.63 UH1.C26
  BOTTOM w0.152: v2(61.35,26.89) 61.43,26.97 61.43,27.43 CV167.1
EDP_AUXP_C: length 0.8
  BOTTOM w0.152: CV167.2 61.49,28.26 61.49,28.64 RV529.1
EDP_AUXP_R: length 7.7
  BOTTOM w0.152: JEDP1.16 60.23,35.76 60.31,35.68 60.31,34.77 60.31,34.2 v3(60.31,31.56) 60.31,31.29 61.49,30.12 61.49,29.53 RV529.2
EDP_COMP: length 2.4
  TOP w0.089: v1(175.52,86.55) 175.72,86.34 v2(176.16,86.34)
  TOP w0.508: v2(176.16,86.34) 176.66,86.83 RH30.1
  BOTTOM w0.381: UH1.D37 176.16,85.91 v2(176.16,86.34)
EDP_DISP_UTIL: length 7.9
  BOTTOM w0.14: v1(182.41,87.5) 181.62,86.72 RH456.1 180.68,86.72 180.28,87.12 179.68,87.12 179.17,86.61 179.17,84.6 179.41,84.36 179.41,84.18 179.13,83.9 UH1.A33
EDP_HPD: length 64.7
  IN2 w0.089: 74.97,19.48 75.12,19.33 75.12,18.99 76.69,17.42 76.69,14.22 77.37,13.54 79.32,13.54 79.58,13.79 82.7,13.79 83.77,12.73 87.9,12.73 87.99,12.82 88.64,12.82 89.15,13.34 89.78,13.34 90.14,13.7 90.14,14.3 90.68,14.83 91.08,14.83 92.11,13.81 94,13.81 96.24,11.56 v2(96.24,11.19)
  IN2 w0.099: 74.97,19.48 74.47,19.98 74.47,21.24 73.66,22.05 73.66,22.71 73.89,22.93 73.89,23.89 73.02,24.75 70.97,24.75 69.79,23.57 65.39,23.57 64.39,24.58 63.65,24.58 62.29,25.93 61.13,25.93 61,26.07 56.26,26.07 55.97,25.78 50.68,25.78 v2(50.29,26.16)
  BOTTOM w0.089: UH2.AN6 96.24,11.37 v2(96.24,11.19)
  BOTTOM w0.14: v2(50.29,26.16) 50.55,26.42 RV113.1 RV114.1
EDP_HPD_S: length 14.2
  IN1 w0.107: v2(56.36,34.24) 55.75,33.63 50.94,33.63 v2(50.33,34.24)
  BOTTOM w0.152: JEDP1.23 56.73,34.61 v2(56.36,34.24) ; v2(50.33,34.24) 50.11,34.02 v1(50.11,30.56) 50.11,29.72 49.96,29.57 RV113.2
EDP_PANEL_CLK: length 11.1
  TOP w0.14: v6(59.24,35.28) 59.24,36.16 59.43,36.36 63.31,36.36 63.31,36.36 63.97,36.36 64.51,35.83 66.56,35.83 66.9,36.16 66.9,36.4 66.98,36.57 66.98,36.57 67.04,36.63 T5994.1
  BOTTOM w0.14: v6(59.24,35.28) 59.23,35.28 JEDP1.18
EDP_PANEL_DAT: length 13.7
  TOP w0.14: v6(55.25,35.53) 55.38,35.53 56,36.16 58.67,36.16 59.27,36.75 63.31,36.75 63.31,36.76 64.13,36.76 64.67,36.22 66.4,36.22 66.5,36.32 66.5,36.49 66.5,36.49 66.36,36.63 T5995.1
  BOTTOM w0.14: v6(55.25,35.53) 55.23,35.55 JEDP1.26
EDP_TXN0: length 173
  IN1 w0.107: v2(63.18,26.89) 62.8,27.28 62.8,27.45 62.97,27.61 63.52,27.61 63.75,27.39 63.75,26.2 65.57,24.38 66.75,24.38 67.67,23.46 69.16,23.46 71.26,25.57 73.44,25.57 74.93,27.07 76.29,27.07 76.68,27.46 76.68,27.83 78.1,29.25 79.08,29.25 79.7,29.87 83.8,29.87 83.94,30.02 85.59,30.02 90.47,34.89 91.84,34.89 93.08,36.14 96.57,36.14 99.58,39.15 101.03,39.15 109.83,47.96 110.33,47.96 111.35,48.99 112.46,48.99 113.27,49.8 115.8,49.8 118.55,52.55 118.55,53.82 121.01,56.28 121.01,60.9 125.86,65.75 125.86,69.22 126.22,69.58 126.22,78.96 127.32,80.05 127.32,85.64 128.75,87.07 130.3,87.07 131.73,88.5 135.56,88.5 136.73,89.66 175.21,89.66 176.86,88.02 176.86,85.81 177.11,85.56 177.11,84.68 176.91,84.49 175.56,84.49 173.96,82.89 173.96,82.03 174.42,81.58 176.1,81.58 176.3,81.37 176.3,81.12 175.88,80.7 v2(175.77,80.7)
  BOTTOM w0.076: v2(175.77,80.7) 175.77,81.01 175.69,81.09 UH1.E29
  BOTTOM w0.152: v2(63.18,26.89) 63,27.08 63,27.28 CV159.1
EDP_TXN0_C: length 0.8
  BOTTOM w0.152: CV159.2 63.09,28.27 63.09,28.63 RV521.1
EDP_TXN0_R: length 8
  BOTTOM w0.152: RV521.2 63.1,29.53 63.1,30.14 v3(62.79,30.44) 61.67,31.56 61.67,33.78 62.14,34.25 62.14,35.69 62.23,35.78 JEDP1.12
EDP_TXN1: length 170.3
  IN1 w0.089: 177.69,80.85 177.68,80.84 177.68,80.37 177.2,79.89 176.4,79.89 176.06,79.55 175.92,79.55 175.82,79.65 v2(175.82,79.89)
  IN1 w0.107: v2(65.54,26.85) 65.15,26.47 65.15,26.34 66.25,25.25 69.78,25.25 71.14,26.61 72.14,26.61 76.23,30.69 83.41,30.69 83.56,30.83 84.76,30.83 85.83,31.9 86.32,31.9 90.23,35.82 91.57,35.82 92.74,36.99 95.26,36.99 98.78,40.52 101.13,40.52 109.48,48.87 110.07,48.87 110.68,49.48 110.68,50.12 111.71,51.16 112.65,51.16 113.07,50.74 114.36,50.74 115.06,51.43 115.95,51.43 117.66,53.14 117.66,55.24 119.65,57.23 119.65,60.7 123.15,64.2 123.15,65.4 123.75,66 124.77,66 125.02,66.25 125.02,69.64 125.4,70.02 125.4,79.4 126.49,80.5 126.49,85.99 129.53,89.03 130.94,89.03 131.38,89.47 134.82,89.47 136.13,90.78 176.27,90.78 177.99,89.06 177.99,88.22 177.85,88.08 177.85,86.29 178.09,86.05 178.09,84.93 178.28,84.74 178.28,83.6 177.6,82.91 177.6,82.56 177.69,82.47 177.69,80.85
  BOTTOM w0.076: v2(175.82,79.89) 175.82,79.96 UH1.E28
  BOTTOM w0.152: v2(65.54,26.85) 65.4,26.98 65.4,27.39 CV161.1
EDP_TXN1_C: length 0.8
  BOTTOM w0.152: RV523.1 65.38,28.64 65.38,28.26 CV161.2
EDP_TXN1_R: length 8.5
  BOTTOM w0.152: JEDP1.9 63.73,35.78 63.64,35.69 63.64,35.06 64.27,34.43 64.52,34.43 65.84,33.11 65.84,30.93 65.38,30.47 65.38,29.53 RV523.2
EDP_TXN2: length 168.5
  IN1 w0.107: v2(179.27,80.42) 179.45,80.59 179.64,80.59 180.33,81.29 180.33,83.87 179.35,84.85 179.35,86.15 178.4,87.11 178.4,87.71 178.72,88.02 178.72,89.23 176.54,91.4 135.64,91.4 134.37,90.14 129.71,90.14 125.87,86.3 125.87,80.91 124.71,79.75 124.71,70.6 124.37,70.27 124.37,67.83 122.48,65.93 122.48,64.57 121.58,63.67 120.82,63.67 120.07,62.92 120.07,62.16 119.01,61.1 119.01,58.36 114.94,54.29 114.94,52.99 113.92,51.97 111.62,51.97 100.78,41.13 98.44,41.13 94.92,37.62 91.06,37.62 87.95,34.51 86.95,34.51 83.95,31.51 83.1,31.51 82.91,31.32 79.05,31.32 78.61,31.75 77.52,31.75 77.18,31.42 75.42,31.42 72.32,28.31 71.76,28.31 69.32,25.88 66.74,25.88 66.49,26.13 66.49,26.62 v2(66.7,26.83)
  BOTTOM w0.076: v2(179.27,80.42) 179.09,80.61 178.84,80.61 178.74,80.71 178.38,80.71 178.26,80.59 177.77,80.59 177.53,80.82 177.53,80.99 UH1.B29
  BOTTOM w0.152: v2(66.7,26.83) 66.58,26.95 66.58,27.3 CV163.1
EDP_TXN2_C: length 0.8
  BOTTOM w0.152: RV525.1 66.65,28.63 66.65,28.26 CV163.2
EDP_TXN2_R: length 7.9
  BOTTOM w0.152: RV525.2 66.65,29.53 66.65,33.61 65.14,35.11 65.14,35.7 65.23,35.79 JEDP1.6
EDP_TXN3: length 170.7
  IN1 w0.107: v2(178.91,79.62) 179.29,80 179.63,80 180.81,81.18 180.81,84.13 180.29,84.65 180.29,86.67 179.17,87.78 179.17,90.62 178.61,91.18 177.43,91.18 176.79,91.82 135.35,91.82 134.72,91.19 130.17,91.19 124.3,85.31 124.3,70.9 123.85,70.45 123.85,68.25 118.58,62.97 118.58,58.51 114.48,54.42 114.48,53.47 114.09,53.08 112.11,53.08 100.58,41.54 98.27,41.54 94.77,38.05 90.9,38.05 87.82,34.96 86.34,34.96 84.68,33.31 84.68,32.87 84.2,32.39 81.15,32.39 80.71,31.94 79.19,31.94 78.67,32.46 75.16,32.46 71.93,29.23 69.71,29.23 67.93,27.44 67.93,26.47 68.08,26.32 v2(68.17,26.32)
  BOTTOM w0.076: UH1.B28 177.35,80.38 177.21,80.38 177.13,80.3 177.13,80.21 177.34,79.99 178.26,79.99 178.47,79.78 178.56,79.78 178.77,80 179.11,80 179.19,79.91 179.19,79.71 179.11,79.62 v2(178.91,79.62)
  BOTTOM w0.152: CV165.1 67.97,27.29 67.97,26.52 v2(68.17,26.32)
EDP_TXN3_C: length 0.8
  BOTTOM w0.152: CV165.2 68.05,28.25 68.05,28.64 RV527.1
EDP_TXN3_R: length 7.8
  BOTTOM w0.152: JEDP1.3 66.73,35.78 66.64,35.69 66.64,34.83 67.45,34.02 67.45,31.36 68.05,30.76 68.05,29.53 RV527.2
EDP_TXP0: length 173
  IN1 w0.107: v2(176.5,80.71) 176.5,81.46 176.18,81.78 174.51,81.78 174.17,82.12 174.17,82.81 175.65,84.29 177,84.29 177.31,84.6 177.31,85.64 177.06,85.89 177.06,88.1 175.3,89.87 136.64,89.87 135.48,88.7 131.65,88.7 130.22,87.27 128.66,87.27 127.12,85.73 127.12,80.13 126.02,79.04 126.02,69.67 125.66,69.3 125.66,65.84 120.81,60.98 120.81,56.36 118.35,53.9 118.35,52.64 115.71,50 113.19,50 112.38,49.19 111.27,49.19 110.24,48.16 109.75,48.16 100.94,39.36 99.5,39.36 96.48,36.34 93,36.34 91.75,35.1 90.38,35.1 85.51,30.22 83.86,30.22 83.71,30.07 79.62,30.07 79,29.45 78.01,29.45 76.47,27.92 76.47,27.54 76.2,27.27 74.85,27.27 73.35,25.77 71.18,25.77 69.08,23.67 67.75,23.67 66.84,24.58 65.65,24.58 63.95,26.28 63.95,27.47 63.61,27.82 62.88,27.82 62.6,27.53 v2(62.6,26.89)
  BOTTOM w0.076: v2(176.5,80.71) 176.5,80.72 UH1.D29
  BOTTOM w0.152: CV158.1 62.67,27.46 62.67,26.97 v2(62.6,26.89)
EDP_TXP0_C: length 0.8
  BOTTOM w0.152: RV520.1 62.76,28.65 62.76,28.25 CV158.2
EDP_TXP0_R: length 8
  BOTTOM w0.152: RV520.2 62.77,29.53 62.77,30 v3(61.61,31.16) 61.34,31.42 61.34,33.91 61.81,34.38 61.81,35.68 61.73,35.77 JEDP1.13
EDP_TXP1: length 170.3
  IN1 w0.089: v2(175.17,79.89) 175.54,80.25 176.02,80.25 176.2,80.07 177.12,80.07 177.49,80.44 177.49,80.81 177.49,80.82 177.49,80.85
  IN1 w0.107: 177.49,80.85 177.49,82.38 177.39,82.47 177.39,83 178.08,83.68 178.08,84.66 177.89,84.85 177.89,85.97 177.65,86.21 177.65,88.16 177.79,88.3 177.79,88.98 176.19,90.58 136.22,90.58 134.91,89.27 131.47,89.27 131.02,88.82 129.62,88.82 126.7,85.9 126.7,80.42 125.6,79.32 125.6,69.93 125.22,69.56 125.22,66.17 124.85,65.8 123.84,65.8 123.36,65.32 123.36,64.12 119.85,60.61 119.85,57.15 117.86,55.15 117.86,53.06 116.03,51.23 115.14,51.23 114.45,50.53 112.99,50.53 112.57,50.95 111.8,50.95 110.88,50.04 110.88,49.39 110.16,48.66 109.57,48.66 101.22,40.31 98.87,40.31 95.34,36.79 92.83,36.79 91.65,35.61 90.32,35.61 86.41,31.7 85.91,31.7 84.84,30.63 83.64,30.63 83.5,30.49 76.31,30.49 72.23,26.4 71.22,26.4 69.86,25.04 66.16,25.04 64.95,26.26 v2(64.95,26.85)
  BOTTOM w0.076: UH1.F28 175.17,79.96 v2(175.17,79.89)
  BOTTOM w0.152: CV160.1 65.07,27.35 65.07,26.97 v2(64.95,26.85)
EDP_TXP1_C: length 0.8
  BOTTOM w0.152: CV160.2 65.05,28.26 65.05,28.64 RV522.1
EDP_TXP1_R: length 8.5
  BOTTOM w0.152: RV522.2 65.05,29.53 v3(65.05,30.3) 65.05,30.61 65.51,31.07 65.51,32.97 64.38,34.1 64.14,34.1 63.31,34.92 63.31,35.67 63.23,35.75 JEDP1.10
EDP_TXP2: length 168.4
  IN1 w0.107: v2(66.12,26.83) 66.29,26.67 66.29,26.05 66.66,25.68 69.41,25.68 71.84,28.11 72.4,28.11 75.51,31.21 77.26,31.21 77.6,31.55 78.53,31.55 78.96,31.12 83,31.12 83.19,31.31 84.03,31.31 87.03,34.3 88.03,34.3 91.14,37.42 95.01,37.42 98.52,40.93 100.87,40.93 111.71,51.77 114.01,51.77 115.15,52.91 115.15,54.2 119.22,58.27 119.22,61.02 120.27,62.08 120.27,62.84 120.9,63.47 121.67,63.47 122.68,64.49 122.68,65.85 124.58,67.74 124.58,70.18 124.91,70.52 124.91,79.66 126.07,80.82 126.07,86.21 129.79,89.93 134.46,89.93 135.73,91.2 176.45,91.2 178.51,89.14 178.51,88.11 178.19,87.79 178.19,87.02 179.15,86.07 179.15,84.77 180.13,83.79 180.13,81.37 179.55,80.79 179.31,80.79 179.24,80.86 v2(179.24,81.01)
  BOTTOM w0.076: v2(179.24,81.01) 179.24,80.89 179.14,80.78 178.92,80.78 178.81,80.88 178.3,80.88 178.19,80.77 177.84,80.77 177.71,80.9 177.71,81.13 177.78,81.2 177.97,81.2 UH1.A29
  BOTTOM w0.152: CV162.1 66.25,27.44 66.25,26.96 v2(66.12,26.83)
EDP_TXP2_C: length 0.8
  BOTTOM w0.152: RV524.1 66.32,28.64 66.32,28.25 CV162.2
EDP_TXP2_R: length 7.9
  BOTTOM w0.152: RV524.2 66.32,29.53 v3(66.32,30.33) 66.32,33.47 64.81,34.97 64.81,35.71 64.73,35.79 JEDP1.7
EDP_TXP3: length 170.8
  IN1 w0.107: v2(179.54,79.62) 179.54,79.69 179.64,79.8 179.71,79.8 181.01,81.09 181.01,84.21 180.49,84.73 180.49,86.75 179.38,87.87 179.38,90.7 178.7,91.38 177.51,91.38 176.87,92.03 135.27,92.03 134.63,91.39 130.09,91.39 124.09,85.4 124.09,70.98 123.65,70.54 123.65,68.33 118.38,63.06 118.38,58.6 114.28,54.5 114.28,53.56 114,53.28 112.03,53.28 100.5,41.75 98.18,41.75 94.69,38.25 90.82,38.25 87.73,35.17 86.25,35.17 84.48,33.4 84.48,32.96 84.11,32.59 81.07,32.59 80.63,32.14 79.27,32.14 78.76,32.66 75.08,32.66 71.85,29.43 69.63,29.43 67.73,27.53 67.73,26.46 v2(67.58,26.32)
  BOTTOM w0.076: UH1.C28 177.27,79.81 178.19,79.81 178.73,79.27 179.19,79.27 v2(179.54,79.62)
  BOTTOM w0.152: CV164.1 67.64,27.45 67.64,26.37 v2(67.58,26.32)
EDP_TXP3_C: length 0.8
  BOTTOM w0.152: CV164.2 67.72,28.26 67.72,28.63 RV526.1
EDP_TXP3_R: length 7.8
  BOTTOM w0.152: JEDP1.4 66.23,35.8 66.31,35.71 66.31,34.69 67.12,33.89 67.12,31.22 67.72,30.62 v3(67.72,30.34) 67.72,29.53 RV526.2
EN_1V: length 8.2
  TOP w0.14: v1(134.39,6.3) 135.23,5.46 PR505.1
  TOP w0.254: v2(135.38,4.82) PR505.1
  BOTTOM w0.254: PR503.2 135.58,4.61 v2(135.38,4.82) ; PR503.2 136.15,3.52 136.15,3.18 136.97,2.35 PR1950.2 ; PR503.2 135.14,4.08 135.09,4.03 PC511.1 134.7,4.76 134.44,5.02 PU500.11
EN_INVPWR: length 303.8
  TOP w0.14: v2(111.01,8.26) 110.48,8.26 v1(110.31,8.09) ; v2(33.58,32.53) 33.58,32.62 35.46,34.49 36.21,34.49 RV135.1 36.5,34.79 QV12.2 ; UE3.B2 294.51,10.92 294.51,10.33 v2(293.93,9.75)
  IN2 w0.099: v2(33.58,32.53) 33.45,32.4 33.45,32.21 36.96,28.7 36.96,26.54 38.79,24.72 44.27,24.72 44.6,25.05 45.04,25.05 45.23,24.85 48.98,24.85 49.21,25.08 52.82,25.08 53.81,24.1 58.31,24.1 58.4,24.01 62.31,24.01 63.35,22.97 63.35,22.45 65.14,20.65 65.14,18.28 64.75,17.89 64.75,15.98 67.25,13.49 67.25,12.96 69.49,10.72 70.69,10.72 71.31,10.09 71.31,8.38 72.21,7.48 73.3,7.48 73.41,7.59 74.37,7.59 75.26,6.7 75.26,6.03 75.69,5.6 78.74,5.6 79.2,6.06 79.86,6.06 79.96,6.16 85.35,6.16 85.65,5.85 87.98,5.85 88.16,5.67 88.88,5.67 89.59,6.38 91.23,6.38 91.52,6.09 93.48,6.09 93.97,5.6 96.01,5.6 96.19,5.79 100.48,5.79 101.16,6.47 101.16,6.91 101.75,7.5 103.32,7.5 104.57,8.75 105.22,8.75 106.21,9.74 109.9,9.74 111.01,8.63 v2(111.01,8.26)
  IN5 w0.099: v2(293.93,9.75) 290.98,12.7 290.36,12.7 290.35,12.69 288.15,12.69 288.02,12.56 285.22,12.56 284.73,12.07 282.88,12.07 280.64,9.83 278.81,9.83 277.5,8.51 273.43,8.51 272.12,9.82 272.12,9.83 271.8,10.15 268.41,10.15 268.35,10.21 265.8,10.21 264.99,11.03 263.66,11.03 263.13,10.5 248.45,10.5 247.52,11.43 226.32,11.43 224.92,12.83 214.49,12.83 213.36,13.96 199.12,13.96 199.11,13.97 187.15,13.97 185.9,12.73 185.9,11.1 184.23,9.42 169.9,9.42 169.53,9.05 159.25,9.05 158.57,9.73 157.53,9.73 157.25,9.45 156.26,9.45 155.83,9.88 152.64,9.88 151.94,10.58 151.18,10.58 150.95,10.81 140.93,10.81 139.38,9.26 136.57,9.26 135.97,9.85 132.85,9.85 132.05,10.66 131.06,10.66 130.14,11.57 125.64,11.57 124.73,10.66 122.76,10.66 122.13,10.02 118.54,10.02 116.84,8.31 116.02,8.31 115.52,7.82 114.88,7.82 114.59,8.1 112.33,8.1 111.79,8.64 111.26,8.64 111.01,8.4 v2(111.01,8.26)
EN_PD_HV_1: length 107.3
  TOP w0.14: v2(54.27,20.21) 54.63,20.21 v1(55.04,19.8)
  TOP w0.254: PQ212.5 30.61,22.66 31.14,23.19 32.23,23.19 32.51,22.91 32.51,20.27 30.46,18.21 30.46,15.7 v2(29.82,15.06) 29.67,14.91 28.55,14.91 27.66,14.02 PR247.1 PR248.1 24.07,14.02 23.63,13.58 22.49,13.58 22.09,13.99 PR262.2 22.09,14.91 22.4,15.22 PR250.1
  IN1 w0.254: v2(54.27,20.21) 54.03,20.21 53.21,19.39 46.62,19.39 44.37,17.14 31.29,17.14 29.82,15.67 v2(29.82,15.06) 23.8,15.06 23.06,15.8 23.06,17.72 20.42,20.36 20.42,22.33 18.81,23.94 17.36,23.94 16.22,25.08 16.22,29.92 16.81,30.5 16.81,33.27 16.39,33.68 16.39,34.4 16.53,34.54 18.91,34.54 19.57,35.21 19.57,38.82 18.51,39.89 18.51,51.27 19.57,52.33 19.57,52.8 20.05,53.29 20.05,53.93 19.38,54.6 17.87,54.6 v2(17.32,55.14)
  BOTTOM w0.14: RT178.2 17.19,55.27 v2(17.32,55.14)
  BOTTOM w0.254: PR277.1 54.38,20.33 v2(54.27,20.21)
EN_PD_HV_1#: length 2.8
  TOP w0.14: PR231.2 30.3,19.08 30.3,19.07 v1(30.3,18.63)
  TOP w0.254: PR231.2 30.61,19.99 PQ212.2 PQ212.3
ENVDD: length 8.2
  TOP w0.508: DV7.1 65.52,28.37 RZ40.1 v1(61.98,28.37) 57.86,28.37 UZ8.4
ENVDD_PCH: length 47
  TOP w0.14: v2(63.14,18.33) 63.14,19.13 v1(62.33,19.95) 61.66,20.61 61.66,23.73 59.35,26.03 55.76,26.03 55.22,26.57 55.22,27.16 57.15,29.08 61.98,29.08 63.44,30.54 DV7.3
  IN6 w0.089: 73.28,11.01 73.5,11.23 73.5,12.3 73.28,12.53 ; 73.28,9.98 73.28,9.36 73.54,9.11 74.29,9.11 74.67,8.73 v2(74.68,8.73)
  IN6 w0.099: 73.28,9.98 72.92,10.34 72.92,10.64 73.28,11.01 ; 73.28,12.53 73.14,12.67 72.87,12.67 68.35,17.18 67.5,17.18 66.36,18.33 v2(63.14,18.33)
  BOTTOM w0.089: UH2.AV44 77.67,8.81 77.25,8.39 76.5,8.39 76.39,8.5 74.9,8.5 74.66,8.74 v2(74.68,8.73)
ESPI_ALERT#: length 252.5
  TOP w0.089: RH5883.2 81.63,9.55 RH5882.2 82.54,9.3 v6(82.05,8.81)
  TOP w0.14: UE3.H7 299.36,15.76 v2(299.36,15.78) ; RH1943.1 120.93,9.48 v1(121.55,10.1) 122.68,11.23 123.62,11.23 123.97,11.57 v2(123.97,12.22)
  IN1 w0.076: v2(299.36,15.78) 299.35,15.78 298.92,15.36 298.92,14.77 299.13,14.56 299.6,14.56 299.77,14.4 299.77,12.28 299.98,12.07 299.98,11.3 ; 101.98,9.56 101.15,9.56 100.93,9.34 99.23,9.34 98.84,9.73 98.3,9.73 98.23,9.79 97,9.79 96.4,10.4 95.85,10.4 94.9,11.35 93.64,11.35 93.61,11.38 92.1,11.38 91.64,10.92 90.47,10.92 90.15,10.59 89.78,10.59 89.02,11.35 87.97,11.35 87.12,10.51 87.12,9.1 86.34,8.32 85.37,8.32 85.06,8.63 85.06,9.29 84.79,9.56 83.91,9.56 83.78,9.44 82.68,9.44 v6(82.05,8.81)
  IN1 w0.099: 299.98,11.3 299.98,10.76 299.66,10.45 298.82,10.45 298.37,10 298.37,8.81 297.56,8 296.76,8 296.53,7.77 295.08,7.77 294.82,7.51 293.27,7.51 292.56,6.8 291.64,6.8 291.08,6.24 287.92,6.24 287,7.15 282.56,7.15 281.18,8.53 276.08,8.53 275.91,8.37 273.88,8.37 272.62,7.1 271.15,7.1 270.6,7.64 269.15,7.64 268.87,7.36 263.09,7.36 262.1,6.37 252.81,6.37 252.7,6.49 252.3,6.49 250.8,7.98 242.15,7.98 238.78,4.62 238.16,4.62 238.08,4.69 235.55,4.69 234.66,5.59 231.78,5.59 230.32,4.13 214.49,4.13 210.15,8.46 206.73,8.46 204.11,5.84 188.19,5.84 187.63,6.4 179.59,6.4 179.06,6.92 176.35,6.92 175.7,6.27 156.92,6.27 156.34,6.86 151.91,6.86 150.87,7.9 147.16,7.9 145.54,9.52 138.84,9.52 138.14,10.22 135.12,10.22 134.48,10.86 129.56,10.86 128.2,12.22 v2(123.97,12.22) 123.72,12.22 122.3,10.8 118.35,10.8 117.55,11.6 116.61,11.6 116.53,11.68 113.96,11.68 112.92,10.64 112.35,10.64 111.54,9.83 105.15,9.83 104.87,10.1 104.47,10.1 103.93,9.56 101.98,9.56
ESPI_ALERT#_R: length 3.1
  TOP w0.089: v1(82.93,7.65) 82.74,7.84 v6(82.74,8.15) 82.5,8.4 81.96,8.4 81.61,8.75 RH5883.1
  BOTTOM w0.089: UH2.BA36 82.4,8.15 v6(82.74,8.15)
ESPI_CLK: length 2.3
  TOP w0.089: RH168.1 81.44,6.61 v1(81.44,7.21) 81.44,7.56 81.31,7.69 v2(81.26,7.69)
  BOTTOM w0.089: v2(81.26,7.69) 81.63,7.32 UH2.BB36
ESPI_CLK_5105: length 274.2
  TOP w0.089: RH168.2 81.14,5.26 CH198.1 80.9,4.83 81.03,4.7 81.18,4.7 81.63,4.25 81.63,3.82 v2(82.15,3.3)
  TOP w0.14: v2(299.36,14.97) UE3.G7
  IN1 w0.076: 101.98,6.91 101.98,6.91 101.44,7.44 98.88,7.44 98.53,7.09 98.53,6.71 98.1,6.28 89.99,6.28 88.78,5.08 87.94,5.08 87.73,5.29 84.77,5.29 83.98,4.5 83.41,4.5 82.22,3.3 v2(82.15,3.3) ; 303.61,11.3 303.61,13.19 302.85,13.95 301.37,13.95 301.19,13.76 300.78,13.76 300.56,13.98 300.56,14.32 299.92,14.97 v2(299.36,14.97)
  IN1 w0.099: 101.98,6.91 104.83,6.91 106.28,5.46 109.76,5.46 110.39,4.83 117.16,4.83 117.69,5.36 117.69,6.85 120.1,9.26 124.77,9.26 125.05,9.54 131.46,9.54 132.32,8.68 134.32,8.68 135.12,7.88 138.87,7.88 139.23,8.24 145.1,8.24 147.6,5.74 150.6,5.74 151.35,4.99 156.75,4.99 157.31,4.42 159.82,4.42 160.35,4.95 167.91,4.95 168.64,4.23 177.35,4.23 178.27,5.14 183.77,5.14 184.53,4.38 188.52,4.38 188.71,4.57 204.28,4.57 206.57,2.29 242.32,2.29 246.65,6.61 250.14,6.61 252.05,4.7 252.73,4.7 253.18,5.14 262.7,5.14 263.71,6.16 266.86,6.16 267.19,5.83 270.57,5.83 270.75,5.65 274.56,5.65 275.25,4.96 278.65,4.96 278.96,5.27 283.53,5.27 283.87,4.93 294.27,4.93 294.94,5.6 294.94,5.92 295.53,6.52 297.17,6.52 297.44,6.78 298.61,6.78 299.7,7.87 302.12,7.87 303.61,9.36 303.61,9.87 303.61,11.3
  BOTTOM w0.076: 294.84,20.13 295.35,19.62 296.23,19.62 296.56,19.29 296.56,17.92 296.71,17.77 297.19,17.77 297.36,17.6 297.36,16.43 297.6,16.19 299.53,16.19 299.72,16 299.72,15.33 v2(299.36,14.97)
  BOTTOM w0.14: RE313.2 294.18,31.3 295.39,30.09 295.39,25.66 294.32,24.6 294.32,22.33 294.11,22.11 294.11,20.87 v1(294.49,20.48) 294.84,20.13
ESPI_CLK_5105_JLPDE: length 3.5
  TOP w0.14: v1(295.97,33.47) RE62.1 294.91,32.78 v2(294.89,32.77)
  BOTTOM w0.14: JLPDE1.10 295.06,32.6 v2(294.89,32.77) 294.73,32.93 RE313.1
ESPI_CS#: length 283.4
  TOP w0.14: v2(300.16,14.17) UE3.H6
  IN1 w0.076: v2(300.16,14.17) 300.56,13.77 300.56,13.07 300.65,12.97 301.12,12.97 301.37,13.22 301.37,13.61 301.52,13.76 302.72,13.76 303.3,13.18 303.3,11.3 ; v2(80.93,3.63) 80.81,3.75 80.81,4.71 81.44,5.33 84.58,5.33 84.7,5.45 87.8,5.45 88,5.25 88.72,5.25 89.92,6.45 92.17,6.45 92.34,6.62 92.34,6.77 92.64,7.07 93.26,7.07 93.37,7.18 94.52,7.18 95.25,6.45 98.04,6.45 98.36,6.78 98.36,7.16 99.39,8.18 101.09,8.18 101.98,7.29
  IN1 w0.099: 101.98,7.29 102.04,7.23 104.95,7.23 105.75,6.43 109.22,6.43 110.51,5.13 116.55,5.13 116.82,5.41 116.82,6.5 119.88,9.56 124.47,9.56 125.77,10.86 128.27,10.86 129.23,9.9 131.65,9.9 132.38,9.18 135.58,9.18 136.58,8.18 138.74,8.18 139.11,8.54 145.23,8.54 147.65,6.12 150.69,6.12 151.44,5.37 170.03,5.37 170.28,5.12 177.26,5.12 178.15,6.02 178.69,6.02 179.21,5.5 187.26,5.5 187.86,4.89 204.54,4.89 207.14,7.49 209.55,7.49 214.25,2.8 240.48,2.8 243.5,5.82 243.64,5.82 243.78,5.68 243.78,5.54 241.67,3.43 241.67,3.29 241.81,3.15 241.95,3.15 242.8,4 242.94,4 243.08,3.85 243.22,3.85 243.36,3.99 243.36,4.13 243.22,4.28 243.22,4.42 243.36,4.56 243.5,4.56 243.62,4.44 243.76,4.44 243.9,4.58 243.9,4.72 243.78,4.84 243.78,4.98 243.92,5.12 244.06,5.12 244.22,4.96 244.36,4.96 244.5,5.1 244.5,5.24 244.34,5.4 244.34,5.54 245.89,7.08 250.43,7.08 251.93,5.58 252.3,5.58 252.44,5.44 262.57,5.44 263.58,6.46 267,6.46 267.33,6.13 275.94,6.13 276.67,5.4 278.45,5.4 279.21,6.16 281.12,6.16 281.69,5.59 282.07,5.59 282.7,6.22 286.58,6.22 287.52,5.28 292.05,5.28 292.06,5.27 293.54,5.27 293.93,5.65 293.93,6.34 294.2,6.61 295.19,6.61 295.46,6.87 296.91,6.87 297.14,7.1 297.97,7.1 299.41,8.54 301.96,8.54 302.36,8.94 302.36,10.16 303.3,11.1 303.3,11.3
  BOTTOM w0.076: 299.09,16.6 299.51,16.6 299.98,16.13 300.3,16.13 300.52,15.91 300.52,14.53 v2(300.16,14.17)
  BOTTOM w0.089: UH2.BE38 80.95,5.45 80.75,5.24 80.75,4.92 80.89,4.79 80.89,3.67 v2(80.93,3.63)
  BOTTOM w0.14: 299.09,16.6 298.37,17.32 298.37,22.92 298.23,23.05 298.23,26.24 298.9,26.91 298.9,29.02 296.56,31.36 JLPDE1.7
ESPI_IO0: length 248.5
  TOP w0.14: v2(301.76,13.37) UE3.K5 ; v2(115.29,8.31) 114.32,9.27 114.3,9.27
  IN1 w0.076: v2(301.76,13.37) 301.76,13.12 301.37,12.73 301.37,12.68 301.36,12.68 301.36,11.3
  IN1 w0.099: v2(115.29,8.31) 115.6,8 115.96,8 116.07,7.89 116.07,7.66 115.99,7.57 115.18,7.57 114.47,8.28 113.92,8.28 113.74,8.46 113.74,8.75 113.84,8.85 114.86,8.85 114.96,8.95 114.96,9.14 114.86,9.24 113.84,9.24 113.74,9.34 113.74,9.53 113.84,9.63 115.27,9.63 115.37,9.73 115.37,9.92 115.27,10.02 113.61,10.02 113.51,10.13 113.51,10.33 113.6,10.42 114.91,10.42 115.01,10.52 115.01,10.72 114.91,10.82 113.82,10.82 113.72,10.92 113.72,11.11 113.82,11.21 115.3,11.21 115.4,11.11 115.4,10.52 115.5,10.42 122.44,10.42 123.66,11.63 128.46,11.63 129.49,10.61 132,10.61 132.74,9.87 135.85,9.87 136.86,8.86 138.4,8.86 138.76,9.22 145.51,9.22 147.06,7.67 150.78,7.67 151.82,6.63 156.25,6.63 156.83,6.04 170.32,6.04 170.56,5.8 176.98,5.8 177.87,6.7 178.97,6.7 179.49,6.18 187.54,6.18 188.14,5.57 204.16,5.57 206.82,8.24 209.95,8.24 214.5,3.68 232.41,3.68 233.19,4.46 237.92,4.46 238,4.39 238.87,4.39 242.24,7.76 250.71,7.76 252.21,6.26 252.61,6.26 252.72,6.15 262.19,6.15 263.19,7.14 267.55,7.14 267.88,6.81 272.65,6.81 273.98,8.14 280.91,8.14 282.12,6.93 286.91,6.93 287.82,6.01 291.17,6.01 291.73,6.57 292.65,6.57 293.36,7.28 294.91,7.28 295.18,7.55 296.63,7.55 296.86,7.77 297.66,7.77 298.6,8.72 298.6,9.89 298.84,10.13 299.73,10.13 299.98,10.38 301.14,10.38 301.36,10.6 301.36,11.3
  BOTTOM w0.076: v2(301.76,13.37) 302.16,12.97 302.93,12.97 303.14,13.17 303.47,13.17
  BOTTOM w0.14: 303.47,13.17 303.82,13.17 304.11,13.46 304.11,15.32 303.53,15.9 303.53,19.72 304.14,20.34 304.14,20.95 302.07,23.03 302.07,24.96 301.61,25.41 301.61,27.6 302.38,28.36 302.38,30.95 302.14,31.19 298.71,31.19 298.56,31.34 JLPDE1.3
ESPI_IO0_R: length 38.9
  TOP w0.14: RC5831.1 113.41,9.27 113.33,9.35 112.69,9.35 v2(112.49,9.16)
  IN1 w0.076: v6(79.84,7.24) 79.91,7.24 80.37,6.79 80.37,6.6 80.45,6.52 84.33,6.52 84.42,6.61 86.67,6.61 86.82,6.75 86.82,8.05 87.67,8.9 89.28,8.9 89.9,8.28 90.46,8.28 90.77,8.58 90.77,8.94 91.81,9.98 94.8,9.98 94.94,9.84 95.69,9.84 96.28,9.25 97.94,9.25 98.4,8.79 98.71,8.79 98.92,9.01 101.16,9.01 101.27,9.11 101.98,9.11
  IN1 w0.099: 101.98,9.11 103.7,9.11 103.97,8.84 105.51,8.84 105.95,9.28 108.84,9.28 108.89,9.34 112.32,9.34 v2(112.49,9.16)
  BOTTOM w0.089: UH2.BB39 80.05,7.1 79.91,7.24 v6(79.84,7.24)
ESPI_IO1: length 252.7
  TOP w0.14: v2(302.56,12.57) UE3.L4 ; RC5832.2 114.5,11.18 115.04,11.18 v1(115.1,11.11) 115.18,11.04 115.18,10.65 116.15,9.68 v2(116.15,8.83)
  IN1 w0.099: v2(302.56,12.57) 302.56,11.15 301.48,10.06 300.3,10.06 297.79,7.55 296.95,7.55 296.72,7.32 295.27,7.32 295.01,7.06 293.45,7.06 292.74,6.35 291.83,6.35 291.27,5.79 287.73,5.79 286.81,6.7 274.06,6.7 273.7,7.06 273.7,7.26 273.8,7.36 278.93,7.36 279.03,7.46 279.03,7.65 278.93,7.75 273.91,7.75 272.74,6.58 267.79,6.58 267.46,6.91 263.28,6.91 262.29,5.92 252.61,5.92 252.49,6.03 252.11,6.03 250.62,7.53 243.46,7.53 240.11,4.19 239.97,4.19 239.83,4.33 239.83,4.47 241.54,6.17 241.54,6.32 241.4,6.46 241.26,6.46 238.97,4.16 237.74,4.16 237.66,4.24 233.28,4.24 232.5,3.46 214.26,3.46 209.71,8.01 206.91,8.01 204.25,5.35 188.05,5.35 187.45,5.95 179.4,5.95 178.88,6.47 177.97,6.47 177.07,5.57 170.47,5.57 170.22,5.82 152.31,5.82 150.68,7.44 146.97,7.44 145.42,8.99 138.91,8.99 138.55,8.63 136.77,8.63 135.77,9.63 132.62,9.63 131.88,10.38 129.4,10.38 128.39,11.38 123.83,11.38 123.26,10.81 123.26,10.81 122.59,10.14 117.33,10.14 116.15,8.97 v2(116.15,8.83)
  BOTTOM w0.076: 303.47,12.58 302.57,12.58 v2(302.56,12.57)
  BOTTOM w0.14: 303.47,12.58 303.96,12.58 304.44,13.06 304.44,14.17 305,14.73 305,15.26 304.71,15.55 304.26,15.55 303.81,16 303.81,16.55 303.96,16.7 303.96,19.64 304.44,20.12 304.44,21.95 303.96,22.43 303.71,22.43 302.83,23.31 302.83,24.19 303.02,24.39 303.02,25.05 302.64,25.43 302.25,25.43 301.88,25.8 301.88,27.46 302.71,28.28 302.71,32.31 302.1,32.92 298.62,32.92 298.06,32.36 JLPDE1.4
ESPI_IO1_R: length 37.7
  TOP w0.14: v2(112.41,11.43) 112.41,11.08 v1(112.73,10.76) 113.5,10.76 RC5832.1
  IN1 w0.076: v2(80.78,8.92) 81.33,8.92 82.28,9.86 85.31,9.86 85.68,10.23 86.48,10.23 87.77,11.52 89.28,11.52 90.01,12.25 93.19,12.25 93.85,11.58 95,11.58 96.02,10.56 96.47,10.56 97.07,9.96 98.3,9.96 98.41,10.07 100.81,10.07 100.88,10 101.85,10 101.86,10.01 101.98,10.01
  IN1 w0.099: v2(112.41,11.43) 112.24,11.6 111.76,11.6 111.17,11.02 110.99,11.02 110.38,10.41 108.83,10.41 108.32,10.92 104.89,10.92 103.99,10.01 101.98,10.01
  BOTTOM w0.089: UH2.AW37 81.18,8.41 80.78,8.81 v2(80.78,8.92)
ESPI_IO2: length 251.8
  TOP w0.14: UE3.G6 298.96,14.52 299.31,14.17 v2(299.36,14.17) ; 114.3,11.69 115.06,11.69 115.46,11.29 115.46,10.75 115.75,10.46 116.77,10.46 116.92,10.61 116.92,11.69 117.24,12.02 v2(117.24,12.05)
  IN1 w0.076: 298.92,11.3 298.97,11.35 298.97,13.77 v2(299.36,14.17)
  IN1 w0.099: v2(117.24,12.05) 118.06,12.05 118.44,11.67 118.44,11.23 118.62,11.05 118.82,11.05 118.94,11.17 118.94,11.57 119.05,11.69 119.22,11.69 119.33,11.57 119.33,11.17 119.45,11.05 119.61,11.05 119.73,11.17 119.73,11.57 119.84,11.69 120.01,11.69 120.12,11.57 120.12,11.17 120.24,11.05 120.4,11.05 120.52,11.17 120.52,11.57 120.64,11.69 120.8,11.69 120.92,11.57 120.92,11.17 121.03,11.05 121.2,11.05 121.31,11.17 121.31,11.57 121.43,11.69 121.59,11.69 121.71,11.57 121.71,11.17 121.83,11.05 122.18,11.05 123.75,12.62 128.43,12.62 129.23,11.82 129.23,11.62 129.33,11.52 129.53,11.52 129.63,11.62 129.63,11.82 129.72,11.92 129.92,11.92 130.02,11.82 130.02,11.62 130.12,11.52 130.32,11.52 130.42,11.62 130.42,11.82 130.52,11.92 130.72,11.92 130.81,11.82 130.81,11.62 130.91,11.52 131.11,11.52 131.21,11.62 131.21,11.82 131.31,11.92 131.51,11.92 131.61,11.82 131.61,11.62 131.71,11.52 132.09,11.52 132.35,11.26 134.4,11.26 135.22,10.44 138.24,10.44 138.94,9.74 145.63,9.74 147.25,8.12 150.96,8.12 152,7.08 156.43,7.08 157.02,6.5 171.09,6.5 171.2,6.61 175.71,6.61 176.25,7.15 179.16,7.15 179.6,6.71 181.69,6.71 181.79,6.81 181.79,7.26 181.88,7.36 182.08,7.36 182.18,7.26 182.18,6.81 182.28,6.71 182.48,6.71 182.58,6.81 182.58,7.26 182.68,7.36 182.87,7.36 182.97,7.26 182.97,6.81 183.07,6.71 185.44,6.71 185.5,6.77 185.5,7.26 185.6,7.36 185.8,7.36 185.9,7.26 185.9,6.74 185.99,6.64 186.19,6.64 186.29,6.74 186.29,7.26 186.39,7.36 186.58,7.36 186.67,7.27 186.67,6.92 186.89,6.7 187.66,6.7 188.26,6.1 204.04,6.1 206.63,8.69 210.25,8.69 214.36,4.57 230.38,4.57 231.65,5.84 234.72,5.84 235.65,4.92 237.64,4.92 239.68,6.96 239.82,6.96 239.96,6.82 239.96,6.68 238.41,5.13 238.41,4.99 238.55,4.85 238.69,4.85 242.08,8.23 250.87,8.23 252.36,6.74 252.78,6.74 252.93,6.6 261.93,6.6 262.92,7.59 268.78,7.59 269.05,7.87 270.7,7.87 271.24,7.33 272.52,7.33 274.09,8.89 281.14,8.89 282.39,7.65 284.77,7.65 285.15,8.02 286.45,8.02 288.01,6.47 290.98,6.47 291.55,7.03 292.46,7.03 293.17,7.74 294.73,7.74 294.99,8 296.44,8 296.67,8.23 297.47,8.23 298.15,8.9 298.15,10.31 298.92,11.09 298.92,11.3
  BOTTOM w0.076: 297.42,15.52 297.92,15.52 299.27,14.17 v2(299.36,14.17)
  BOTTOM w0.14: JLPDE1.5 297.56,33.22 297.28,33.49 294.09,33.49 293.75,33.15 293.75,31.24 295.04,29.95 295.04,25.87 292.69,23.52 292.69,20.1 293.43,19.35 293.43,17.42 295.07,15.79 296.57,15.79 296.84,15.52 297.42,15.52
ESPI_IO2_R: length 39.7
  TOP w0.14: v1(113.29,12.57) 113.72,12.14 RC5833.1 113.26,11.69 v2(112.99,11.42)
  IN1 w0.076: v6(80.72,9.86) 81.57,9.86 81.96,10.26 84.11,10.26 84.17,10.2 85.36,10.2 85.6,10.44 86.21,10.44 87.48,11.71 89.08,11.71 89.94,12.57 94.84,12.57 95.66,11.76 95.66,11.18 96.1,10.73 96.53,10.73 97.14,10.12 98.23,10.12 98.34,10.23 101.98,10.23
  IN1 w0.099: 101.98,10.23 102.86,10.23 103.45,10.82 104.48,10.82 105.1,11.45 108.26,11.45 108.52,11.71 109.5,11.71 109.74,11.47 109.74,11.25 110.12,10.86 110.51,10.86 110.89,11.25 111.08,11.25 111.7,11.86 112.8,11.86 112.99,11.67 v2(112.99,11.42)
  BOTTOM w0.089: UH2.AV37 81.5,9.21 80.85,9.86 v6(80.72,9.86)
