# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_MA3_BA3_H: length 33
  TOP w0.102: v2(208.35,103.28) 207.95,102.87 207.95,102.3 207.71,102.06 207.39,102.06 207.14,101.8 207.14,101.52 206.91,101.3 204.9,101.3 ; v2(205.83,81.54) 205.42,81.95 205.42,82.57 205.68,82.83 205.68,83.6 204.04,85.24 204.04,86.49 202.79,87.73 202.79,89.51 202.76,89.55 202.76,89.71
  TOP w0.221: 202.76,89.71 202.76,94.27 203.11,94.62 203.11,94.91 202.76,95.25 202.76,95.55 202.98,95.77 204.15,95.77 204.89,96.5 204.89,97.08 204.56,97.4 204.21,97.4 203.46,96.65 202.98,96.65 202.76,96.87 202.76,97.31 203.33,97.87 v1(203.33,98.51) 203.33,100.1 204.52,101.3 204.9,101.3
  BOTTOM w0.102: UV24.K10 v2(208.35,103.28) ; v2(205.83,81.54) 205.44,81.94 UV18.AA29
FBA_MA3_BA3_L: length 38.7
  TOP w0.102: 214.09,87.57 212.98,87.57 212.68,87.26 212.68,86.41 211.21,84.94 211.21,84.62 211.23,84.6 211.23,83.89 210.98,83.63 210.37,83.63 v2(210.04,83.95)
  TOP w0.221: v2(235.21,103.28) 233.02,101.08 233.02,96.09 226,89.08 218.22,89.08 216.71,87.57 214.09,87.57
  BOTTOM w0.107: UV23.H10 v2(235.21,103.28)
  BOTTOM w0.17: UV18.T31 209.94,83.95 210.04,83.95 v2(210.04,83.95)
FBA_MA4_BA2_H: length 23.9
  BOTTOM w0.102: 203.74,88.91 203.74,88.87 204.43,88.18 204.65,88.18 205.04,87.79 205.04,87.08 204.52,86.56 204.3,86.56 UV18.AC34 ; UV24.H11 207.59,104.84 208.27,104.84 208.54,104.57
  BOTTOM w0.221: 208.54,104.57 208.94,104.17 208.94,96.37 v1(208.04,95.47) 203.74,91.17 203.74,89.92 203.74,89.91 203.74,88.91
FBA_MA4_BA2_L: length 38.7
  BOTTOM w0.102: UV23.K11 235.18,104.84 234.39,104.84 ; 212.62,88.07 212.08,88.07 211.58,87.58 211.58,87.14 UV18.R34
  BOTTOM w0.221: 212.62,88.07 214.34,88.07 214.56,88.29 226.58,88.29 v1(230.19,91.9) 233.55,95.26 233.55,104.2 234.19,104.84 234.39,104.84
FBA_MA5_BA1_H: length 24.8
  BOTTOM w0.102: UV18.AC33 203.74,85.63 203.78,85.67 203.87,85.67 204.07,85.86 204.07,85.96 204.41,86.3 204.83,86.3 205.06,86.53 205.06,86.79 205.23,86.97 205.23,86.98 205.25,87 205.25,88.03 204.47,88.8 204.47,88.91
  BOTTOM w0.221: 204.47,88.91 204.47,90.83 206.06,92.42 v1(207,93.36) 209.88,96.24 209.88,101.3 209.57,101.61 209.57,104.46 208.79,105.24 208.17,105.24 208.13,105.28 UV24.H10
FBA_MA5_BA1_L: length 39.5
  BOTTOM w0.102: 233.81,105.49 233.83,105.51 234.09,105.51 234.33,105.28 UV23.K10 ; UV18.R33 210.44,85.54 210.31,85.67 210.3,85.67 210.11,85.86 210.11,86.2 211.19,87.28 211.19,87.57 212.64,89.02 213.19,89.02
  BOTTOM w0.221: 213.19,89.02 226.28,89.02 v1(231.4,94.13) 232.82,95.56 232.82,104.68 233.64,105.49 233.81,105.49
FBA_MA6_MA11_H: length 28.4
  TOP w0.102: v2(211.55,104.88) 211.76,104.67 211.76,100.88 211.45,100.57 ; 205.68,90.04 205.45,89.82 205.45,87.57 206.07,86.95 206.07,86.5 206.42,86.15 206.42,83.53 206.25,83.36 206.25,81.93 v2(206.62,81.56)
  TOP w0.221: 211.45,100.57 211.08,100.19 211.08,98.1 v1(210.53,97.55) 207.92,94.94 207.92,94.49 205.68,92.25 205.68,90.04
  BOTTOM w0.102: UV24.H5 211.98,105.26 211.98,104.92 211.85,104.8 211.63,104.8 v2(211.55,104.88) ; v2(206.62,81.56) 206.55,81.63 206.41,81.63 206.19,81.41 206.19,81.15 UV18.Y28
FBA_MA6_MA11_L: length 42.2
  TOP w0.102: 231.68,97.53 231.97,97.82 231.97,105.03 231.73,105.26 230.86,105.26 v2(230.43,105.69) ; 214,88.12 213.83,87.95 212.28,87.95 210.38,86.04 210.38,84.68 210.15,84.46 210.01,84.46 209.61,84.06 209.61,83.5 208.66,82.55 208.66,82.02 v2(209.16,81.52)
  TOP w0.221: 214,88.12 214.35,88.46 v1(215.66,88.46) 216.57,88.46 217.91,89.8 223.95,89.8 231.68,97.53
  BOTTOM w0.102: UV18.U28 208.74,81.1 v2(209.16,81.52)
  BOTTOM w0.13: UV23.K5 230.81,105.31 v2(230.43,105.69)
FBA_MA7_MA8_H: length 24.9
  BOTTOM w0.102: 205.2,88.91 205.2,88.6 205.45,88.36 205.45,86.91 205.44,86.9 205.44,86.89 205.26,86.71 205.26,86.42 205.08,86.24 205.08,85.56 UV18.AA33 ; 211.46,105.67 212.37,105.67 UV24.H4
  BOTTOM w0.221: 211.46,105.67 210.72,104.93 210.72,95.99 v1(206.01,91.28) 205.2,90.47 205.2,88.91
FBA_MA7_MA8_L: length 39.2
  BOTTOM w0.102: 211.4,89.67 211.06,89.33 211.06,88.87 210.41,88.22 210.41,87.38 209.11,86.08 209.11,85.85 208.74,85.48 UV18.U33 ; UV23.K4 230.39,104.9 231.22,104.9
  BOTTOM w0.221: 231.22,104.9 231.33,104.9 231.92,104.31 231.92,103.6 232.06,103.46 232.06,96.54 226.8,91.28 v1(221.84,91.28) 213.01,91.28 211.4,89.67
FBA_MA12_RFU_H: length 27.9
  TOP w0.102: 211.97,97.79 211.97,102.63 212.23,102.9 212.51,102.9 212.73,103.12 212.73,104.5 v2(212.35,104.88) ; 206.41,90.04 205.77,89.4 205.77,87.89 206.45,87.2 206.45,86.41 206.63,86.23 206.63,83.14 v2(206.63,83.14)
  TOP w0.221: 206.41,90.04 206.41,91.95 206.47,92.01 v1(207.29,92.83) 208.71,94.25 208.71,94.54 211.97,97.79
  BOTTOM w0.102: v2(212.35,104.88) 212.43,104.8 212.43,104.4 212.33,104.3 212.05,104.3 211.95,104.4 UV24.J5 ; v2(206.63,83.14) 206.57,83.2 206.57,83.66 206.83,83.92 207.02,83.92 207.12,83.82 207.12,83.63 UV18.W31
FBA_MA12_RFU_L: length 42.7
  TOP w0.102: 226.77,100.73 226.77,100.98 v1(227.06,101.26) 227.89,102.1 228.17,102.1 228.43,102.35 228.43,102.6 228.65,102.83 229.42,102.83 229.47,102.87 230.06,102.87 v2(230.44,103.25) ; v2(208.34,81.52) 208.34,82.64 208.8,83.11 208.8,85.37 209.55,86.11
  TOP w0.17: 212.02,88.58 209.55,86.11 209.55,86.11
  TOP w0.221: 212.02,88.58 213.47,88.58 214.08,89.19 216.27,89.19 217.61,90.53 223.64,90.53 228.17,95.06 228.17,95.8 226.61,97.36 225.39,97.36 225.13,97.62 225.13,99.08 226.77,100.73
  BOTTOM w0.102: UV23.J5 230.44,104.11 v2(230.44,103.25) ; v2(208.34,81.52) 207.94,81.92 UV18.V29
FBA_RAS#_H: length 29.4
  BOTTOM w0.102: 215.85,103.32 213.99,103.32 UV24.L3 ; 208.15,88.91 206.85,87.61 206.85,86.59 206.86,86.58 206.86,85.73 206.57,85.44 206.57,83.95 206.24,83.62 UV18.Y31
  BOTTOM w0.221: 215.85,103.32 216.68,103.32 216.9,103.1 v1(216.9,95.58) 216.9,94.42 215.29,92.81 212.05,92.81 208.86,89.62 208.15,88.91
FBA_RAS#_L: length 41.2
  TOP w0.102: v2(208.34,83.19) 208.6,83.44 208.6,85.92 209.07,86.39 ; v2(228.81,103.23) 228.51,103.23 228.17,102.9 227.86,102.9 227.39,102.43
  TOP w0.221: 227.39,102.43 227.39,102.38 224.16,99.15 v1(224.16,97.8) 224.16,97.56 225.12,96.6 226.34,96.6 227.25,95.69 227.25,95.17 225.08,93 224.7,93 224.22,93.48 223.91,93.48 223.6,93.17 223.6,92.85 224.08,92.38 224.08,92.06 223.81,91.8 223.35,91.8 222.87,92.28 222.59,92.28 222.35,92.04 222.35,91.56 222.05,91.26 217.31,91.26 215.97,89.92 213.75,89.92 212.9,89.08 211.76,89.08 210.58,87.9 209.07,86.39
  BOTTOM w0.102: UV23.G3 228.86,103.23 v2(228.81,103.23) ; UV18.U31 208.34,83.21 v2(208.34,83.19)
FBA_RST#_H: length 29.4
  TOP w0.102: v2(206.44,88.65) 206.44,88.95 206.87,89.38 207.29,89.38 207.86,89.96 207.86,90.04
  TOP w0.221: v2(213.95,104.08) 215.58,102.45 215.98,102.45 216.34,102.09 216.34,97.45 215.99,97.09 213.64,97.09 207.86,91.31 207.86,90.04
  BOTTOM w0.102: UV18.Y34 206.42,86.18 206.42,86.41 206.44,86.43 206.44,88.64 v2(206.44,88.65) ; v2(213.95,104.08) UV24.J2 214.49,104.48 214.89,104.08 215.46,104.08 215.85,104.47
  BOTTOM w0.221: 215.85,104.47 216.08,104.7 217.23,104.7 RV613.1
FBA_RST#_L: length 39.6
  TOP w0.102: 226.77,102.79 226.77,102.84 v2(228.01,104.08) ; v2(209.04,87) 211.58,89.54 212.38,89.54
  TOP w0.221: 212.38,89.54 213.49,90.65 215.67,90.65 217.01,91.99 221.27,91.99 223.56,94.28 224.45,94.28 224.74,93.99 225.04,93.99 226.35,95.3 226.35,95.56 226.06,95.85 225.64,95.85 225.12,95.33 224.4,95.33 224.22,95.51 224.22,96.37 223.43,97.16 223.43,99.45 226.77,102.79
  BOTTOM w0.102: v2(209.04,87) 208.93,87 UV18.V34 ; UV23.J2 v2(228.01,104.08) 226.65,104.08
  BOTTOM w0.221: 226.65,104.08 226.11,104.08 225.58,103.54 RV614.1
FBA_WCK0: length 36.8
  IN6 w0.097: v2(214.18,83.2) 214.08,83.1 214.08,82.94 214.19,82.83 214.41,82.83 214.64,83.07 214.64,83.92 215.28,84.55 215.28,85.77 215.7,86.18 215.7,86.54 221.91,92.75 223.27,92.75 223.4,92.88 223.4,94.08 223.63,94.31 224.2,94.31 224.39,94.11 224.39,92.75 224.49,92.66 224.78,92.66 224.88,92.75 224.88,94.11 225.07,94.31 225.51,94.31 225.7,94.11 225.7,92.75 225.8,92.66 226.09,92.66 226.19,92.75 226.19,94.11 226.38,94.31 228.57,94.31 231.04,96.78 231.04,100.28 230.79,100.53 230.61,100.53 230.41,100.34 v2(230.41,100.08)
  BOTTOM w0.114: v2(214.18,83.2) 214.58,83.6 UV18.K31 ; UV23.D4 v2(230.41,100.08)
FBA_WCK0_N: length 36.9
  IN6 w0.097: v2(230.41,100.88) 230.58,100.7 230.86,100.7 231.22,100.35 231.22,96.71 228.64,94.13 226.46,94.13 226.36,94.04 226.36,92.68 226.16,92.48 225.73,92.48 225.53,92.68 225.53,94.04 225.43,94.13 225.14,94.13 225.05,94.04 225.05,92.68 224.85,92.48 224.42,92.48 224.22,92.68 224.22,94.04 224.12,94.13 223.7,94.13 223.57,94.01 223.57,92.8 223.34,92.58 221.98,92.58 217.19,87.79 217.19,87.79 217.16,87.75 217.16,87.75 215.87,86.46 215.87,86.11 215.46,85.69 215.46,84.48 214.82,83.84 214.82,83 214.21,82.38 v2(214.18,82.38)
  BOTTOM w0.114: v2(214.18,82.38) 213.76,82.8 UV18.L30 ; UV23.D5 v2(230.41,100.88)
FBA_WCK1: length 38.8
  IN1 w0.097: v2(230.38,108.84) 230.96,108.26 231.78,108.26 232.17,107.87 232.17,98.68 226.27,92.79 224.06,92.79 219.86,88.58 215.78,88.58 214.21,87.01 213.95,87.01 213.94,87.02 v2(213.74,87.12)
  BOTTOM w0.102: v2(213.74,87.12) 213.96,86.91 214.08,86.91 214.49,87.32 215.26,87.32 215.97,86.61 215.97,86.1 216.07,86 UV18.H34 ; UV23.P4 230.38,108.84 v2(230.38,108.84)
FBA_WCK1_N: length 38.6
  IN1 w0.097: v2(213.93,86.52) 213.9,86.63 214.01,86.84 214.28,86.84 215.85,88.41 219.93,88.41 224.14,92.61 226.35,92.61 232.34,98.61 232.34,107.95 231.86,108.43 231.03,108.43 230.86,108.61 230.86,108.76 230.97,108.87 v2(231.16,108.87)
  BOTTOM w0.102: v2(231.16,108.87) 231.15,108.87 231.09,108.81 231.09,108.76 UV23.P5 ; UV18.J34 215.6,86 215.71,86.1 215.71,86.5 215.15,87.06 214.6,87.06 214.07,86.52 v2(213.93,86.52)
FBA_WCK2: length 26.1
  IN6 w0.097: v2(212.35,100.88) 212.35,100.87 211.43,100.87 201.11,90.56 201.11,89.36 201.11,89.36 201.11,89.32 200.86,89.07 200.86,87.75 201.16,87.45 201.16,86.52 200.94,86.3 200.7,86.3 200.17,85.77 200.17,84.43 199.58,83.84 199.58,83.2 199.58,82.68 v2(199.9,82.36)
  BOTTOM w0.102: UV24.P4 v2(212.35,100.88)
  BOTTOM w0.114: v2(199.9,82.36) 199.95,82.36 200.38,82.8 UV18.AG30
FBA_WCK2_N: length 26.1
  IN6 w0.097: v2(200,83.17) 199.86,83.17 199.76,83.27 199.76,83.77 200.34,84.35 200.34,85.69 200.77,86.12 201.01,86.12 201.34,86.45 201.34,87.52 201.04,87.82 201.04,88.99 201.29,89.24 201.29,90.49 211.5,100.7 212,100.7 212.35,100.34 v2(212.35,100.11)
  BOTTOM w0.102: UV24.P5 212,100.53 212.2,100.53 212.41,100.31 212.41,100.17 v2(212.35,100.11) ; 200.16,83.17 200.47,83.17 200.61,83.31 200.61,83.49 200.5,83.6 UV18.AG31
  BOTTOM w0.114: 200.16,83.17 v2(200,83.17)
FBA_WCK3: length 33.6
  IN1 w0.097: v2(198.47,90.18) 199.03,90.18 205.46,96.61 207.08,96.61 207.86,97.39 207.86,97.4 209.02,98.56 209.02,107.44 210.87,109.28 211.72,109.28 211.97,109.03 211.97,108.55 v2(212.4,108.12)
  BOTTOM w0.102: 198.5,87.13 198.5,87.1 198.47,87.07 198.47,86.1 198.57,86 UV18.AJ34 ; UV24.D4 v2(212.4,108.12)
  BOTTOM w0.17: 198.5,87.13 198.5,87.39 199.33,88.22 199.33,89.67 198.96,90.03 198.61,90.03 v2(198.47,90.18)
FBA_WCK3_N: length 33.4
  IN1 w0.097: v2(211.36,108.62) 211.36,108.37 211.46,108.27 211.69,108.27 211.8,108.38 211.8,108.96 211.65,109.11 210.94,109.11 209.2,107.37 209.2,98.48 207.99,97.27 207.98,97.27 207.15,96.44 205.53,96.44 199.1,90 198.88,90 v2(198.47,89.59)
  BOTTOM w0.102: UV18.AK34 198.1,86 198.21,86.1 198.21,87.07 198.17,87.1 198.17,87.13 ; v2(211.36,108.62) 211.5,108.48 UV24.D5
  BOTTOM w0.17: 198.17,87.13 198.17,87.53 199,88.35 199,89.53 198.83,89.7 198.58,89.7 198.47,89.59 v2(198.47,89.59)
FBA_WE#_H: length 30.9
  TOP w0.102: v2(206.78,105.7) 207.31,106.24 208.66,106.24 208.98,105.92 208.98,102.56 208.51,102.1 208.2,102.1 207.93,101.83 207.93,101.52 207.67,101.26 207.39,101.26 207.13,101 207.13,100.72 206.91,100.5 205.78,100.5 205.55,100.27 205.55,98.31 205.9,97.95 ; 203.49,88.93 203.49,88.68 203.19,88.38 203.19,87.62 205.84,84.98 v2(205.84,84)
  TOP w0.221: 205.9,97.95 206.44,97.42 206.44,96.88 203.49,93.92 203.49,88.93
  BOTTOM w0.102: v2(206.78,105.7) 206.73,105.7 UV24.G12 ; UV18.AA32 v2(205.84,84)
FBA_WE#_L: length 41.5
  TOP w0.102: v2(236.03,106.43) 236.03,105.73 232.29,101.98 232.29,97.42
  TOP w0.221: v2(226.38,90.49) 232.29,96.4 232.29,97.42
  BOTTOM w0.102: UV23.L12 236.06,106.43 v2(236.03,106.43) ; 212.53,89.67 210.76,87.91 210.76,87.45 209.31,85.99 209.31,85.77 209.23,85.69 209.23,84.96 208.74,84.47 UV18.U32
  BOTTOM w0.221: 212.53,89.67 213.01,90.14 213.41,90.54 v1(215.19,90.54) 226.32,90.54 v2(226.38,90.49)
FBC_ABI#_H: length 33.2
  TOP w0.102: 223.54,74.06 223.54,73.54 222.17,72.17 218.26,72.17 v2(217.56,71.47)
  TOP w0.147: 223.54,74.06 225.72,76.24 226.04,76.24 ; 237.19,84.65 v1(241.14,84.65) 242.13,84.65 242.52,84.25 v2(242.52,83.13)
  TOP w0.221: 237.19,84.65 228.78,76.24 226.04,76.24
  BOTTOM w0.102: UV18.G17 v2(217.56,71.47) ; UV26.J4 v2(242.52,83.13)
FBC_ABI#_L: length 33.8
  TOP w0.102: v2(243.32,64.61) 243.7,64.99 243.7,65.56 243.56,65.7 243.56,66.64 243.77,66.84 243.77,67.38 ; v2(217.56,70.62) 217.94,71 219.43,71 219.54,70.89 220.34,70.89 220.51,71.06 222.57,71.06 223.1,71.59 225.06,71.59 225.53,71.12 225.83,71.12
  TOP w0.221: 225.83,71.12 v1(229.54,71.12) 241.97,71.12 243.77,69.33 243.77,67.38
  BOTTOM w0.102: UV25.J4 v2(243.32,64.61) ; UV18.F15 v2(217.56,70.62)
FBC_CAS#_H: length 36.1
  TOP w0.102: v2(244.12,82.33) 244.5,81.95 244.5,81.41 244.76,81.15 245.5,81.15 246.11,80.54 246.11,79.51 ; v2(219.24,71.52) 219.67,71.09 220.25,71.09 220.51,71.35 222.58,71.35 223.08,71.85 225.58,71.85
  TOP w0.221: 246.11,79.51 246.11,78.88 239.07,71.85 225.58,71.85
  BOTTOM w0.102: v2(219.24,71.52) 218.86,71.9 218.84,71.9 UV18.E17 ; UV26.G3 v2(244.12,82.33)
FBC_CAS#_L: length 28.3
  BOTTOM w0.102: UV18.C17 220.77,71.57 221.46,71.57 221.76,71.26 224.99,71.26 ; UV25.L3 244.52,65.29 244.83,65.6 244.83,65.93 244.47,66.29 244.39,66.29 244.09,66.59 244.09,66.96
  BOTTOM w0.221: 224.99,71.26 228.69,71.26 232.06,67.9 v1(233.12,67.9) 243.36,67.9 244.09,67.16 244.09,66.96
FBC_CKE_H: length 33
  TOP w0.102: RV608.2 244.54,80.25 244.54,80.96 244.41,81.09 243.84,81.09 243.4,81.53 v2(243.32,81.53) 243.32,80.15 243.47,80
  TOP w0.221: 243.47,80 244.48,79 244.48,78.28 238.79,72.6 225.04,72.6 v2(224.98,72.66)
  BOTTOM w0.102: UV18.B17 221.41,71.9 221.8,71.51 223.84,71.51 v2(224.98,72.66) ; UV26.J3 v2(243.32,81.53)
FBC_CKE_L: length 31
  TOP w0.102: v2(223.21,70.7) 223.59,71.08 224.71,71.08 ; RV606.2 243.63,64.2 242.89,64.2 242.57,63.88 v2(242.5,63.88) 242.5,64.52 242.83,64.84 242.83,65.66 243.08,65.91 243.08,66.42 242.63,66.87 241.78,66.87 241.5,67.15 241.5,67.38
  TOP w0.221: 224.71,71.08 225.49,70.3 v1(225.86,70.3) 237.49,70.3 239.02,68.77 240.86,68.77 241.43,68.2 241.43,67.45 241.5,67.38
  BOTTOM w0.102: UV18.B15 221.61,70.57 222.19,70.57 222.47,70.29 222.8,70.29 v2(223.21,70.7) ; v2(242.5,63.88) 242.5,63.88 242.5,64.59 UV25.J3
FBC_CLK0: length 39.8
  TOP w0.102: RV629.1 243.76,56.78 243.45,57.09 243.45,57.26 v2(243.32,57.4)
  IN6 w0.097: v2(243.32,57.4) 243.32,57.67 242.9,58.1 242.9,58.25 242.89,58.26 242.89,58.55 242.53,58.92 242.53,59.81 241.81,60.52 241.81,64.09 242.1,64.37 242.1,65.25 242.9,66.05 242.9,66.36 242.63,66.63 242.63,67.4 242.63,67.41 242.63,67.63 240.49,69.77 239.31,69.77 239.08,70 221.11,70 220.71,69.6 219.38,69.6 218.91,69.13 218.91,68.43 v2(219.25,68.09)
  BOTTOM w0.102: v2(243.32,57.4) 242.92,57.8 UV25.J12
  BOTTOM w0.114: v2(219.25,68.09) 219.64,67.71 UV18.D12
FBC_CLK0#: length 40.9
  TOP w0.102: v2(243.32,58.21) 243.71,57.82 243.71,57.2 244.34,56.58 RV628.1
  IN6 w0.097: v2(243.32,58.21) 243.18,58.21 243.07,58.33 243.07,58.62 242.7,58.99 242.7,59.88 241.99,60.59 241.99,64.01 242.28,64.3 242.28,65.17 243.07,65.97 243.07,66.44 242.81,66.71 242.81,67.7 240.57,69.94 239.38,69.94 239.15,70.17 221.04,70.17 220.64,69.77 219.31,69.77 218.74,69.2 218.74,68.4 218.6,68.26 v2(218.31,68.26)
  BOTTOM w0.102: v2(243.32,58.21) 242.93,58.6 UV25.J11
  BOTTOM w0.114: UV18.E12 218.83,67.7 218.38,68.15 218.38,68.2 v2(218.31,68.26)
FBC_CLK1: length 42.9
  TOP w0.102: RV638.1 242.66,88.87 242.52,88.73 v2(242.52,88.71)
  IN6 w0.097: v2(242.52,88.71) 242.8,88.71 243.14,88.37 243.14,87.86 242.33,87.06 242.33,83.89 241.12,82.67 241.12,81.97 241.7,81.39 241.7,78.37 237.49,74.16 237.49,72.51 236.62,71.63 221.74,71.63 221.11,72.26 219.45,72.26 218.71,73 218.71,73.48 v2(219.22,73.99)
  BOTTOM w0.102: v2(242.52,88.71) 242.52,88.74 UV26.J12
  BOTTOM w0.114: UV18.E20 218.84,74.37 v2(219.22,73.99)
FBC_CLK1#: length 43.2
  TOP w0.102: v2(243.31,88.73) 242.92,89.12 242.92,89.68 243.23,89.99 RV637.1
  IN6 w0.097: v2(243.31,88.73) 243.31,88.73 243.31,87.79 242.51,86.99 242.51,83.82 241.29,82.6 241.29,82.05 241.88,81.46 241.88,79.49 241.88,79.48 241.88,79.44 241.87,79.43 241.87,78.3 237.66,74.09 237.66,72.44 236.69,71.46 221.67,71.46 221.04,72.09 219.38,72.09 218.54,72.93 218.54,73.79 v2(218.36,73.97)
  BOTTOM w0.102: v2(243.31,88.73) UV26.J11
  BOTTOM w0.114: UV18.F20 217.99,74.35 v2(218.36,73.97)
FBC_CS#_H: length 31.6
  TOP w0.102: v2(220.13,73.12) 220.42,73.41 220.42,74.4 222.54,76.52 224.09,76.52 224.32,76.74 224.32,77.4 ; v2(241.72,88.74) 241.72,88.52 242.09,88.15 242.09,87.78 241.87,87.56 241.55,87.56 241.55,87.55 235.92,87.55
  TOP w0.221: 224.32,77.4 224.32,77.72 v1(226.32,79.72) 234.15,87.55 235.92,87.55
  BOTTOM w0.102: UV18.D18 219.64,72.75 220.01,73.12 v2(220.13,73.12) ; UV26.L12 v2(241.72,88.74)
FBC_CS#_L: length 26.5
  TOP w0.102: v2(240.95,58.21) 240.59,58.57 240.59,59.07 240.19,59.47 ; 225.14,65.47 223.2,65.47 221.01,67.67 220.5,67.67 v2(220.03,68.14)
  TOP w0.221: 240.19,59.47 235.75,59.47 v1(235.28,59.94) 230.17,65.06 226.48,65.06 226.12,65.42 225.19,65.42 225.14,65.47
  BOTTOM w0.107: v2(240.95,58.21) 241.32,57.84 UV25.G12
  BOTTOM w0.17: UV18.D13 220.03,68.16 v2(220.03,68.14)
FBC_D0: length 22.7
  IN6 w0.102: v2(216.75,65.62) 217.3,65.06 218.97,65.06 218.98,65.06 219.81,65.06 220.03,65.28 220.98,65.28 221.9,64.36 ; v2(236.92,64.61) 235.94,63.63
  IN6 w0.117: 221.9,64.36 222.61,64.36 222.76,64.22 225.47,64.22 226.06,63.63 235.94,63.63
  BOTTOM w0.102: UV18.G9 217.14,65.22 216.75,65.61 v2(216.75,65.62) ; UV25.A4 v2(236.92,64.61)
FBC_D1: length 19.5
  IN6 w0.102: v2(219.22,65.64) 219.31,65.74 221.79,65.74 222.12,65.41
  IN6 w0.117: v2(236.92,66.21) 235.98,65.26 223.21,65.26 223.07,65.41 222.12,65.41
  BOTTOM w0.102: UV18.E9 218.84,65.26 218.84,65.26 v2(219.22,65.64) ; UV25.A2 v2(236.92,66.21)
FBC_D2: length 22.1
  IN6 w0.102: v2(236.92,63.81) 236.22,63.1 235.92,63.1 ; v2(217.57,63.94) 218.5,64.86 218.89,64.86 218.89,64.86 220.29,64.86 220.88,64.27 221,64.27 221.24,64.04 221.24,63.82 221.6,63.45 222.12,63.45
  IN6 w0.117: 222.12,63.45 222.36,63.45 222.44,63.36 224.3,63.36 224.55,63.1 235.92,63.1
  BOTTOM w0.102: UV25.B4 v2(236.92,63.81) ; UV18.G8 217.14,64.37 v2(217.57,63.94)
FBC_D3: length 22.8
  IN6 w0.102: 236.73,65.02 237.08,65.02 237.3,65.25 237.3,65.79 v2(237.72,66.21) ; 222.12,64.88 221.47,65.53 219.77,65.53 219.5,65.26 219.06,65.26 219.05,65.27 218.07,65.27 v2(217.66,65.67)
  IN6 w0.117: 222.12,64.88 222.85,64.88 223,64.74 236.44,64.74 236.73,65.02
  BOTTOM w0.102: UV18.F9 217.99,65.35 v2(217.66,65.67) ; UV25.B2 v2(237.72,66.21)
FBC_D4: length 25.4
  IN6 w0.102: 222.12,67.1 219.32,67.1 218.69,66.47 v2(218.41,66.47) ; v2(239.32,64.61) 238.9,65.02 238.9,67.24 238.76,67.38
  IN6 w0.117: 222.12,67.1 222.17,67.05 222.72,67.05 223.04,67.37 235.84,67.37 236.38,67.92 238.22,67.92 238.76,67.38
  BOTTOM w0.102: UV18.F11 v2(218.41,66.47) ; UV25.E4 v2(239.32,64.61)
FBC_D5: length 26.6
  IN6 w0.102: 222.12,67.95 221.48,67.3 219.07,67.3 218.62,66.85 217.94,66.85 v2(217.56,66.47) ; v2(239.32,65.41) 239.7,65.79 239.7,67.18 239.5,67.38
  IN6 w0.117: 222.12,67.95 235.67,67.95 236.17,68.44 238.44,68.44 239.5,67.38
  BOTTOM w0.102: UV25.E2 v2(239.32,65.41) ; UV18.G11 v2(217.56,66.47)
FBC_D6: length 29.8
  IN6 w0.102: 222.12,69.37 221.55,69.37 220.47,68.29 220.47,68.04 220.14,67.71 218.8,67.71 218.68,67.83 218.05,67.83 v2(217.57,67.34) ; v2(240.92,64.61) 240.54,64.99 240.54,67.16 240.76,67.38
  IN6 w0.117: 240.76,67.38 240.76,67.6 238.87,69.49 235.73,69.49 235.24,68.99 223.06,68.99 222.68,69.37 222.12,69.37
  BOTTOM w0.102: v2(217.57,67.34) 217.92,67.7 UV18.F12 ; UV25.F4 v2(240.92,64.61)
FBC_D7: length 27.9
  IN6 w0.102: 220.9,67.64 220.78,67.51 218.72,67.51 218.6,67.63 218.28,67.63 218.06,67.41 218.06,67.3 217.72,66.96 217.06,66.96 v2(216.75,67.28) ; 240.23,67.15 240.23,66.32 v2(240.12,66.21)
  IN6 w0.117: 220.9,67.64 222.12,68.85 222.47,68.85 222.85,68.47 235.45,68.47 235.95,68.96 238.65,68.96 240.23,67.38 240.23,67.15
  BOTTOM w0.102: UV18.G12 217.14,67.67 v2(216.75,67.28) ; UV25.F2 v2(240.12,66.21)
FBC_D8: length 21.8
  IN6 w0.102: 222.12,60.4 221.86,60.4 220.91,61.35 220.66,61.35 219.32,62.69 217.95,62.69 v2(217.56,63.07) ; 235.92,58.46 v2(236.15,58.22)
  IN6 w0.117: 235.92,58.46 235.1,59.27 224.39,59.27 223.26,60.4 222.12,60.4
  BOTTOM w0.102: v2(217.56,63.07) 217.14,62.65 UV18.G6
  BOTTOM w0.107: UV25.A11 236.15,58.24 v2(236.15,58.22)
FBC_D9: length 21.7
  IN6 w0.102: 222.12,58.52 221.62,58.52 221.21,58.93 221.21,59.94 220.98,60.17 220.73,60.17 220.41,60.49 220.41,60.74 220.13,61.02 218.72,61.02 v2(218.36,61.37)
  IN6 w0.117: v2(234.7,56.66) 233.13,58.23 222.57,58.23 222.28,58.52 222.12,58.52
  BOTTOM w0.102: UV25.A13 235.79,57 ; UV18.F5 v2(218.36,61.37)
  BOTTOM w0.221: 235.79,57 235.65,57 235.56,57.1 235.14,57.1 v2(234.7,56.66)
FBC_D10: length 21.9
  IN6 w0.102: v2(219.24,63.1) 220.74,61.6 222.12,61.6 ; v2(236.93,58.24) 237.3,58.6 237.3,59.16 236.66,59.8 235.92,59.8
  IN6 w0.117: 235.92,59.8 225.65,59.8 225.05,60.4 224.09,60.4 222.89,61.6 222.12,61.6
  BOTTOM w0.102: UV18.E6 v2(219.24,63.1) ; v2(236.93,58.24) 236.93,58.22 UV25.B11
FBC_D11: length 21.7
  IN6 w0.102: v2(236.89,57.4) 236.51,57.78 235.92,57.78 ; 222.12,59.88 222.12,59.91 221.84,60.2 221.77,60.2 220.83,61.14 220.42,61.14 219.32,62.24 v2(218.41,62.24)
  IN6 w0.117: 222.12,59.88 223.25,58.75 234.34,58.75 235.31,57.78 235.92,57.78
  BOTTOM w0.102: v2(218.41,62.24) 218,62.65 UV18.F6 ; v2(236.89,57.4) 236.92,57.4 UV25.B13
FBC_D12: length 26.8
  IN6 w0.102: 221.07,57.79 218.92,59.93 218.92,60.04 218.37,60.59 v2(218.34,60.59) ; 235.92,55.69 238.15,55.69 238.9,56.45 238.9,58.59 v2(239.32,59)
  IN6 w0.117: 221.07,57.79 221.67,57.18 232.66,57.18 234.14,55.69 235.92,55.69
  BOTTOM w0.102: UV18.F4 v2(218.34,60.59) ; UV25.E11 v2(239.32,59)
FBC_D13: length 27
  IN6 w0.102: 220.33,57.79 220.33,58.1 218.72,59.71 218.72,59.96 218.49,60.18 218.22,60.18 217.51,60.89 v2(217.51,61.41) ; v2(239.32,56.6) 239.32,56.22 238.41,55.32
  IN6 w0.117: 238.41,55.32 238.26,55.17 233.93,55.17 232.44,56.66 221.45,56.66 220.33,57.79
  BOTTOM w0.102: UV25.E13 v2(239.32,56.6) ; v2(217.51,61.41) 217.09,61 UV18.G4
FBC_D14: length 29.2
  IN6 w0.102: 240.52,55.57 240.52,57.81 v2(240.1,58.22) ; 218.82,57.79 218.34,58.27 v2(218.34,58.93)
  IN6 w0.117: 240.52,55.57 239.06,54.11 233.42,54.11 232.01,55.52 221.09,55.52 218.82,57.79
  BOTTOM w0.102: v2(240.1,58.22) 240.48,58.6 UV25.F11
  BOTTOM w0.127: UV18.E2 218.74,59.4 218.34,58.99 v2(218.34,58.93)
FBC_D15: length 27.3
  IN6 w0.102: 239.15,55.32 239.71,55.88 239.71,57 v2(240.09,57.38) ; v2(218.34,59.8) 219.59,58.55 219.59,57.79
  IN6 w0.117: 239.15,55.32 238.48,54.65 233.71,54.65 232.22,56.14 221.24,56.14 219.59,57.79
  BOTTOM w0.102: UV25.F13 240.11,57.41 240.11,57.38 v2(240.09,57.38) ; UV18.F3 v2(218.34,59.8)
FBC_D16: length 37.5
  IN1 w0.102: 249.11,55.32 249.11,56.23 249.32,56.44 249.32,57.17 249.83,57.67 v2(249.83,58.75)
  IN1 w0.117: 249.11,55.32 249.11,54.86 247.36,53.1 243.63,53.1 243.45,52.93 238.64,52.93 238.21,53.36 232.16,53.36 230.37,55.15 223.85,55.15 220.71,58.29 220.71,58.91 v2(220.79,58.99)
  BOTTOM w0.102: v2(249.83,58.75) 249.8,58.75 249.79,58.76 249.47,58.76 UV25.U11 ; UV18.C2 220.44,59.28 220.73,58.99 v2(220.79,58.99)
FBC_D17: length 41.3
  IN1 w0.117: v2(250.28,55.37) 250.28,54.41 249.52,53.65 249.52,53.06 248.53,52.06 244.06,52.06 243.88,51.88 238.2,51.88 237.77,52.31 231.73,52.31 229.93,54.1 222.95,54.1 219.53,57.52 219.53,60.09 v2(220.03,60.58)
  BOTTOM w0.102: v2(220.03,60.58) 219.64,60.97 UV18.D4 ; UV25.U13 249.64,56.69
  BOTTOM w0.221: 249.64,56.69 249.68,56.64 249.68,56.36 249.69,56.36 249.69,55.96 v2(250.28,55.37)
FBC_D18: length 42
  IN1 w0.102: 249.89,57.17 249.75,57.02 249.75,55.32 ; v2(248.92,58.99) 249.07,59.14 249.89,59.14
  IN1 w0.117: 249.89,59.14 250.11,59.14 250.51,58.74 250.51,57.79 249.89,57.17 ; 249.75,55.32 249.75,54.61 247.72,52.58 243.84,52.58 243.67,52.4 238.42,52.4 237.99,52.83 231.94,52.83 230.15,54.63 223.63,54.63 220.07,58.19 220.07,59.65 v2(220,59.72)
  BOTTOM w0.102: v2(220,59.72) 219.59,60.13 UV18.D3 ; v2(248.92,58.99) 248.91,58.99 UV25.T11
FBC_D19: length 33.3
  IN1 w0.117: v2(222.12,58.1) 222.12,57.79 224.24,55.67 230.59,55.67 232.38,53.88 238.42,53.88 238.42,53.88 239.63,53.88 239.98,53.53 243.31,53.53 243.41,53.63 247.14,53.63 v2(248.55,55.04)
  BOTTOM w0.102: v2(222.12,58.1) 222.06,58.17 220.87,58.17 UV18.C1 ; UV25.T13 248.52,56.81 248.16,56.45 248.16,55.79 248.17,55.78 248.17,55.5 248.23,55.44
  BOTTOM w0.221: v2(248.55,55.04) 248.51,55.08 248.23,55.36 248.23,55.44
FBC_D20: length 30.5
  IN1 w0.102: 235.92,55.61 244.33,55.61 244.92,56.2 246.51,56.2 246.94,56.63 246.94,57.75 246.57,58.11 v2(246.57,58.23)
  IN1 w0.117: 235.92,55.61 232.89,55.61 231.26,57.24 226.19,57.24 223.49,59.95 221.81,59.95 v2(221.68,59.82)
  BOTTOM w0.102: UV25.N11 246.49,58.23 v2(246.57,58.23) ; UV18.B3 221.3,60.2 v2(221.68,59.82)
FBC_D21: length 29.9
  IN1 w0.102: 235.92,60.19 244.52,60.19 245.16,59.55 245.76,59.55 246.1,59.21 246.1,57.88 v2(246.54,57.44)
  IN1 w0.117: v2(220.79,60.64) 221.68,61.53 222.53,61.53 222.68,61.69 226.69,61.69 228.2,60.19 235.92,60.19
  BOTTOM w0.102: v2(220.79,60.64) 220.79,60.77 220.51,61.05 UV18.C4 ; v2(246.54,57.44) 246.54,57.43 UV25.N13
FBC_D22: length 26.6
  IN1 w0.102: v2(245.68,59.06) 245.24,58.62 236.78,58.62 236.77,58.61 235.92,58.61
  IN1 w0.117: v2(222.76,61.02) 222.77,61.04 225.25,61.04 227.67,58.61 235.92,58.61
  BOTTOM w0.102: v2(222.76,61.02) 222.25,61.53 221.84,61.53 221.47,61.9 UV18.B5 ; UV25.M11 245.32,58.69 v2(245.68,59.06)
FBC_D23: length 28.4
  IN1 w0.102: v2(245.68,56.64) 244.78,56.64 244.27,56.14 235.92,56.14
  IN1 w0.117: 235.92,56.14 233.24,56.14 231.31,58.07 226.95,58.07 224.5,60.52 222.31,60.52 v2(221.81,61.02)
  BOTTOM w0.102: UV25.M13 245.32,57 v2(245.68,56.64) ; v2(221.81,61.02) 221.73,61.02 221.37,61.38 221.29,61.38 220.91,61.76 220.91,61.8 220.81,61.9 UV18.C5
FBC_D24: length 31.2
  IN1 w0.102: 247.65,67.38 247.84,67.18 247.84,67.02 248.5,66.36 248.5,65.55 249.53,64.52 v2(249.75,64.52)
  IN1 w0.117: v2(224.91,66.42) 226.07,67.58 241.08,67.58 241.6,68.1 246.74,68.1 247.27,67.57 247.46,67.57 247.65,67.38
  BOTTOM w0.102: UV25.U4 249.38,64.21 ; UV18.A11 224.43,66.9 v2(224.91,66.42)
  BOTTOM w0.221: 249.38,64.21 249.43,64.21 v2(249.75,64.52)
FBC_D25: length 32.9
  IN1 w0.102: v2(249.66,66.21) 249.66,67.31 249.59,67.38
  IN1 w0.117: v2(220.82,66.52) 221.31,67.01 222.68,67.01 224.29,68.63 240.64,68.63 241.16,69.14 247.83,69.14 249.59,67.38
  BOTTOM w0.102: UV25.U2 249.38,65.87 ; v2(220.82,66.52) UV18.C11
  BOTTOM w0.221: 249.38,65.87 249.66,66.15 v2(249.66,66.21)
FBC_D26: length 43.5
  IN1 w0.102: 249.89,62.95 249.55,62.61 v2(248.6,62.61)
  IN1 w0.117: 249.89,62.95 250.51,63.57 250.51,67.2 247.74,69.97 241.25,69.97 240.43,69.15 222.42,69.15 221.69,68.42 221.69,68.39 220.55,67.25 v2(218.44,67.25)
  BOTTOM w0.102: UV25.T4 248.53,64.21 248.92,63.82 248.92,62.93 v2(248.6,62.61) ; v2(218.44,67.25) 219.29,67.25 UV18.D11
FBC_D27: length 30.9
  IN1 w0.102: v2(248.92,66.17) 248.85,66.24 248.85,66.8 248.71,66.95 248.71,67.38
  IN1 w0.117: v2(221.62,66.49) 222.95,66.49 224.57,68.1 240.86,68.1 241.38,68.62 247.47,68.62 248.71,67.38
  BOTTOM w0.102: v2(221.62,66.49) 221.24,66.86 UV18.B11 ; v2(248.92,66.17) 248.88,66.17 UV25.T2
FBC_D28: length 27.7
  IN1 w0.098: 235.92,64.24 235.93,64.23 241.88,64.23 241.91,64.26 242.66,64.26 242.72,64.2 245.36,64.2 v2(245.75,63.82)
  IN1 w0.117: v2(220.85,64.83) 221.33,65.31 223.83,65.31 224.21,64.93 235.22,64.93 235.92,64.24
  BOTTOM w0.102: UV25.N4 246.12,64.19 v2(245.75,63.82) ; UV18.D8 219.91,64.4 220.35,64.83 v2(220.85,64.83)
FBC_D29: length 31
  IN1 w0.102: 235.92,61.67 236.12,61.47 245.39,61.47 246.5,62.58 246.5,63.37 246.64,63.51 246.64,65.28 245.75,66.17 v2(245.75,66.23)
  IN1 w0.117: 235.92,61.67 234.22,63.36 222.92,63.36 222.89,63.38 222.75,63.38 222.57,63.56 v2(222.57,63.82)
  BOTTOM w0.102: UV25.N2 245.75,66.18 v2(245.75,66.23) ; v2(222.57,63.82) 222.04,64.35 UV18.A8
FBC_D30: length 26.4
  IN1 w0.098: 244.74,63.63 v2(244.89,63.78) ; 235.92,63.42 239.42,63.42
  IN1 w0.102: 244.74,63.63 244.54,63.42 239.42,63.42
  IN1 w0.117: v2(220.84,63.89) 221.74,64.79 223.61,64.79 223.99,64.41 234.93,64.41 235.92,63.42
  BOTTOM w0.102: v2(220.84,63.89) 220.85,63.9 220.85,63.98 UV18.C8 ; v2(244.89,63.78) UV25.M4
FBC_D31: length 30.7
  IN1 w0.098: 236.36,62.43 243.19,62.43
  IN1 w0.102: 243.19,62.43 245.18,62.43 246.25,63.51 246.25,64.7 245.93,65.02 245.43,65.02 v2(244.98,64.58) ; 236.15,62.43 236.36,62.43
  IN1 w0.117: 236.15,62.43 234.7,63.88 223.77,63.88 223.39,64.26 222.12,64.26 v2(221.74,63.88)
  BOTTOM w0.102: UV25.M2 245.32,65.8 244.98,65.47 v2(244.98,64.58) ; v2(221.74,63.88) 221.74,63.89 UV18.B8
FBC_D32: length 22.9
  IN6 w0.102: 236.32,82.72 236.52,82.72 v2(236.91,82.33) ; 225.37,77.9 222.27,77.9 221.9,77.53 217.75,77.53 v2(217.56,77.35)
  IN6 w0.117: 236.32,82.72 235.96,82.72 231.14,77.9 225.37,77.9
  BOTTOM w0.102: UV26.U4 236.91,82.34 v2(236.91,82.33) ; UV18.F24 217.91,77.7 v2(217.56,77.35)
FBC_D33: length 22.9
  IN6 w0.102: 235.92,80.78 236.12,80.97 v2(236.12,81.53) ; 224.54,76.9 223.97,77.47 222.5,77.47 222.1,77.07 218.33,77.07 217.74,76.47 v2(217.56,76.47)
  IN6 w0.117: 235.92,80.78 231.65,76.5 224.93,76.5 224.54,76.9
  BOTTOM w0.102: UV18.G23 v2(217.56,76.47) ; UV26.U2 v2(236.12,81.53)
FBC_D34: length 22.4
  IN6 w0.102: v2(218.42,78.19) 218.87,77.74 221.82,77.74 222.19,78.11 224.81,78.11 224.97,78.27 ; 236.05,83.48 236.57,83.48 v2(236.92,83.13)
  IN6 w0.117: 224.97,78.27 225.51,78.8 231.3,78.8 235.97,83.48 236.05,83.48
  BOTTOM w0.102: v2(218.42,78.19) 218.84,77.77 UV18.E24 ; UV26.T4 v2(236.92,83.13)
FBC_D35: length 24.8
  IN6 w0.102: 235.99,81.92 236.53,81.92 v2(236.92,81.53) ; 225,77.39 224.69,77.7 222.44,77.7 222.02,77.27 218.12,77.27 217.81,76.97 217.4,76.97 216.74,77.63 v2(216.74,78.12)
  IN6 w0.117: 235.99,81.92 235.96,81.92 235.73,81.7 235.73,81.33 231.78,77.38 225.01,77.38 225,77.39
  BOTTOM w0.102: UV18.G24 217.14,77.72 v2(216.74,78.12) ; UV26.T2 v2(236.92,81.53)
FBC_D36: length 25.4
  IN6 w0.102: v2(240.12,82.33) 239.94,82.33 239.52,81.92 239.16,81.92 238.9,81.65 238.9,80.45 237.96,79.51 ; 223.34,74.75 222.51,74.75 221.64,75.62 v2(220.04,75.62)
  IN6 w0.117: 237.96,79.51 233.21,74.75 223.34,74.75
  BOTTOM w0.102: UV18.D21 219.64,75.22 v2(220.04,75.62) ; UV26.N4 v2(240.12,82.33)
FBC_D37: length 27.3
  IN6 w0.102: 239.44,79.51 240.5,80.57 240.5,81.15 v2(240.12,81.53) ; v2(219.24,74.81) 220.97,74.81 221.99,73.79
  IN6 w0.117: 239.44,79.51 233.02,73.09 223.36,73.09 222.72,73.72 222.06,73.72 221.99,73.79
  BOTTOM w0.102: UV18.E21 219.22,74.81 v2(219.24,74.81) ; UV26.N2 v2(240.12,81.53)
FBC_D38: length 30.5
  IN6 w0.102: v2(240.15,83.08) 240.5,82.73 240.5,82.18 240.28,81.95 240,81.95 239.71,81.67 239.71,80.52 238.7,79.51 ; 223.12,74.22 222.79,74.55 222.42,74.55 221.73,75.24 217.12,75.24 v2(216.74,75.62)
  IN6 w0.117: 223.12,74.22 233.41,74.22 238.7,79.51
  BOTTOM w0.102: v2(216.74,75.62) 216.74,75.6 UV18.G21 ; v2(240.15,83.08) 240.17,83.08 UV26.M4
FBC_D39: length 30.9
  IN6 w0.102: v2(240.92,80.74) 241.43,80.23 241.43,79.75 241.19,79.51 ; v2(217.57,74.82) 218.03,74.37 220.19,74.37 220.45,74.1 220.45,73.83 220.49,73.79
  IN6 w0.117: 241.19,79.51 241.19,78.86 234.57,72.24 222.46,72.24 221.17,73.54 220.75,73.54 220.49,73.79
  BOTTOM w0.102: v2(240.92,80.74) 240.92,80.73 UV26.M2 ; UV18.F21 217.94,75.2 217.57,74.84 v2(217.57,74.82)
FBC_D40: length 26.1
  IN6 w0.102: v2(236.92,87.94) 237.34,87.52 237.34,86.84 237.11,86.62 236.32,86.62 ; 223.97,80.21 223.78,80.02 223.78,79.6 223.12,78.95 222.26,78.95 221.95,79.26 219.77,79.26 219.5,79.54 219.01,79.54 219,79.53 217.83,79.53 v2(217.56,79.8)
  IN6 w0.117: 223.97,80.21 224.29,80.53 230.23,80.53 236.32,86.62
  BOTTOM w0.102: UV18.G27 217.16,80.2 v2(217.56,79.8) ; UV26.U11 v2(236.92,87.94)
FBC_D41: length 23.5
  IN6 w0.102: 223.92,81.61 223.17,80.86 222.64,80.86 222.47,81.03 222.03,81.03 221.52,80.52 220.64,80.52 220.2,80.96 219.57,80.96 v2(219.19,80.58) ; v2(236.92,89.54) 236.5,89.12 236.5,88.42 235.92,87.84
  IN6 w0.117: 223.92,81.61 229.7,81.61 235.92,87.84
  BOTTOM w0.102: v2(219.19,80.58) 219.25,80.58 UV18.D27 ; UV26.U13 v2(236.92,89.54)
FBC_D42: length 26.8
  IN6 w0.102: v2(217.54,78.94) 217.92,78.94 218.02,79.04 218.02,79.04 218.24,79.27 219.03,79.27 219.1,79.34 219.41,79.34 219.71,79.04 221.88,79.04 222.17,78.75 223.38,78.75 224.1,79.46 ; 235.92,85.48 236.04,85.6 236.81,85.6 238.12,86.92 238.12,87.53 v2(237.72,87.94)
  IN6 w0.117: 224.1,79.46 224.64,80 230.44,80 235.92,85.48
  BOTTOM w0.102: v2(217.54,78.94) 217.54,79 UV18.G26 ; UV26.T11 v2(237.72,87.94)
FBC_D43: length 25
  IN6 w0.102: 236.54,87.58 236.54,87.78 236.54,87.78 236.54,88.09 236.78,88.34 237.02,88.34 237.34,88.66 237.34,89.15 v2(237.72,89.54) ; v2(218.48,80.61) 218.89,80.2 223.22,80.2
  IN6 w0.117: 236.54,87.58 230.05,81.09 224.11,81.09 223.22,80.2
  BOTTOM w0.102: v2(218.48,80.61) 218.5,80.59 218.5,80.58 218.84,80.25 UV18.E27 ; UV26.T13 v2(237.72,89.54)
FBC_D44: length 28.1
  IN6 w0.102: v2(240.12,87.94) 239.7,88.35 239.7,89.69 239.48,89.92 239.2,89.92 238.94,90.18 238.94,90.75 238.74,90.95 ; 223.68,82.45 223.35,82.13 220.43,82.13 220.26,82.3 v2(219.24,82.3)
  IN6 w0.117: 223.68,82.45 224.46,83.23 228.83,83.23 236.55,90.95 238.74,90.95
  BOTTOM w0.102: UV18.E29 v2(219.24,82.3) ; UV26.N11 v2(240.12,87.94)
FBC_D45: length 27.8
  IN6 w0.102: v2(240.12,89.54) 240.12,89.8 239.72,90.2 239.72,90.55 239.1,91.16 236.04,91.16 235.92,91.04 ; 225.06,83.75 224.47,83.75 223.04,82.33 220.52,82.33 220.32,82.53 219.55,82.53 219.4,82.68 218.72,82.68 v2(218.41,82.37)
  IN6 w0.117: 225.06,83.75 228.61,83.75 235.9,91.04 235.92,91.04
  BOTTOM w0.102: v2(218.41,82.37) 217.99,81.95 UV18.F29 ; UV26.N13 v2(240.12,89.54)
FBC_D46: length 31.1
  IN6 w0.102: v2(240.92,87.94) 241.3,88.32 241.3,90.49 240.22,91.57 240.22,91.57 ; v2(219.24,83.2) 219.64,83.2 219.87,83.43 220.18,83.43 220.44,83.17 220.44,82.98 220.69,82.73 221.82,82.73 222.04,82.96 222.04,83.24 222.26,83.46 222.58,83.46 222.6,83.44 223.23,83.44 223.85,84.06
  IN6 w0.117: 223.85,84.06 224.64,84.85 227.92,84.85 235.16,92.1 239.69,92.1 240.22,91.57
  BOTTOM w0.102: UV26.M11 v2(240.92,87.94) ; UV18.E30 v2(219.24,83.2)
FBC_D47: length 27.1
  IN6 w0.102: 235.92,91.57 239.42,91.57 240.5,90.49 240.5,89.95 v2(240.92,89.54) ; 224.67,84.14 224.57,84.14 222.96,82.53 220.6,82.53 220.09,83.05 v2(220.03,83.05)
  IN6 w0.117: 235.92,91.57 235.37,91.57 228.13,84.33 224.85,84.33 224.67,84.14
  BOTTOM w0.102: UV18.D30 219.64,82.72 219.96,83.05 v2(220.03,83.05) ; UV26.M13 v2(240.92,89.54)
FBC_D48: length 38.7
  IN1 w0.102: v2(223.02,83.82) 224.09,83.82 224.49,84.22 225.43,84.22
  IN1 w0.117: 225.43,84.22 228.55,84.22 235.84,91.5 239.92,91.5 240.61,92.2 244.47,92.2 244.85,92.59 245.63,92.59 245.86,92.36 249.18,92.36 249.6,91.93 249.6,90.54 249.11,90.04 249.09,90.04 249.08,90.04 248.69,90.04 248.51,89.86 248.51,88.13 248.52,88.13 248.52,87.8 248.76,87.56 249.27,87.56 v2(249.68,87.97)
  BOTTOM w0.102: UV18.A32 222.85,84.4 223.02,84.23 v2(223.02,83.82) ; v2(249.68,87.97) UV26.A11
FBC_D49: length 38.1
  IN1 w0.102: 224.65,84.77 224.14,84.27 222.22,84.27 222.16,84.2 221.16,84.2 v2(220.85,83.89) ; v2(248.96,89.58) 249.28,89.58 249.62,89.92
  IN1 w0.117: 224.65,84.77 228.37,84.77 236.75,93.15 245.61,93.15 245.8,93.35 246.35,93.35 246.72,92.97 249.44,92.97 250.13,92.29 250.13,90.43 249.62,89.92
  BOTTOM w0.102: UV18.C31 220.5,83.55 v2(220.85,83.89) ; UV26.A13 v2(248.96,89.58)
FBC_D50: length 41.2
  IN1 w0.102: 225.43,85.35 224.73,85.35 223.85,84.47 222.3,84.47 222.14,84.47 222.07,84.41 220.94,84.41 220.84,84.51 v2(220.84,84.86) ; v2(248.92,87.95) 249.3,88.33 249.3,88.82 249.89,89.41
  IN1 w0.117: 225.43,85.35 228.2,85.35 236.53,93.67 245.38,93.67 245.58,93.87 246.56,93.87 246.94,93.5 249.66,93.5 250.7,92.46 250.7,90.22 249.89,89.41
  BOTTOM w0.102: UV26.B11 248.91,87.95 v2(248.92,87.95) ; UV18.C32 220.44,84.46 v2(220.84,84.86)
FBC_D51: length 34
  IN1 w0.102: 249.09,91.35 249.09,90.53 248.98,90.43 v2(248.92,90.43) ; 225.43,83.69 224.85,83.69 224.6,83.44 222.82,83.44 v2(222.38,83.88)
  IN1 w0.117: 249.09,91.35 249.08,91.36 249.08,91.71 248.96,91.82 245.66,91.82 245.41,92.06 245.07,92.06 244.68,91.68 243.8,91.68 243.12,91 236.09,91 228.79,83.69 225.43,83.69
  BOTTOM w0.102: UV18.B32 221.24,84.39 221.74,83.88 v2(222.38,83.88) ; UV26.B13 248.92,90.34 v2(248.92,90.43)
FBC_D52: length 31.5
  IN1 w0.098: 242.15,86.62 243.05,87.52 243.96,87.52
  IN1 w0.102: v2(246.47,88.69) 246.11,88.33 245.17,88.33 244.36,87.52 243.96,87.52 ; 225.43,81.98 225.05,81.98 224.9,82.12 224.74,82.12 224.73,82.12 221.98,82.12 221.77,81.91 219.64,81.91 v2(219.2,81.47) ; 242.15,86.62 236.08,86.62
  IN1 w0.117: 225.43,81.98 230.65,81.98 235.28,86.62 236.08,86.62
  BOTTOM w0.102: UV18.D29 219.63,81.9 v2(219.2,81.47) ; v2(246.47,88.69) UV26.E11
FBC_D53: length 33.8
  IN1 w0.102: v2(246.53,90.34) 246.92,89.95 247.48,89.95 247.73,89.7 247.73,87.8 247.36,87.44 246.38,87.44 246.06,87.76 245.17,87.76 244.86,87.44 244.86,86.55 244.21,85.9 243,85.9 242.94,85.95 236.68,85.95 236.14,85.41 235.92,85.41 ; 225.43,80.85 224.97,80.85 224.37,81.45 v2(222.88,81.45)
  IN1 w0.117: 235.92,85.41 235.67,85.41 231.11,80.85 225.43,80.85
  BOTTOM w0.102: v2(246.53,90.34) UV26.E13 ; v2(222.88,81.45) 222.49,81.45 UV18.A29
FBC_D54: length 30.6
  IN1 w0.102: 225.43,80.33 224.85,80.33 224.16,81.03 221.17,81.03 220.84,81.36 v2(220.84,81.53) ; v2(245.36,86.42) 244.63,85.69 242.92,85.69 242.76,85.54 236.87,85.54 235.92,84.58
  IN1 w0.117: 225.43,80.33 231.33,80.33 235.59,84.58 235.92,84.58
  BOTTOM w0.102: v2(220.84,81.53) 220.8,81.53 UV18.C29 ; v2(245.36,86.42) 245.18,86.42 244.86,86.74 244.86,87.87 UV26.F11
FBC_D55: length 32.7
  IN1 w0.102: 225.43,81.37 225.12,81.37 224.58,81.92 222.06,81.92 221.61,81.47 v2(221.55,81.47) ; v2(245.68,90.29) 246.94,89.03 246.94,88.51 246.7,88.27 246.41,88.27 246.1,87.96 245.26,87.96 245.09,87.96 244.65,87.52 244.65,86.67 244.09,86.1 243.08,86.1 243.03,86.16 236.36,86.16 236.14,85.93 235.92,85.93
  IN1 w0.117: 225.43,81.37 230.9,81.37 235.45,85.93 235.92,85.93
  BOTTOM w0.102: v2(245.68,90.29) 245.32,89.94 UV26.F13 ; UV18.B29 221.24,81.78 v2(221.55,81.47)
FBC_D56: length 39.1
  IN1 w0.102: 225.62,72.26 223.06,72.26 222.12,73.2 222.12,74.61 222.64,75.13 v2(222.7,75.13) ; v2(249.64,82.32) 249.64,82.1 249.89,81.85
  IN1 w0.117: 249.89,81.85 250.19,81.55 250.19,79.4 248.07,77.28 247.73,77.28 247.71,77.28 246.57,77.28 241.56,72.26 225.62,72.26
  BOTTOM w0.102: v2(222.7,75.13) 222.7,75.19 222.35,75.53 221.77,75.53 221.44,75.2 UV18.B21 ; UV26.A4 249.64,82.41 v2(249.64,82.32)
FBC_D57: length 34.2
  IN1 w0.102: 225.49,74.69 224.46,74.69 223.46,75.69 222.44,75.69 221.68,76.46 v2(221.68,76.47) ; 247.69,79.51 247.8,79.61 247.8,80.6 247.78,80.62 247.78,80.97 247.98,81.17 248.48,81.17 v2(248.92,80.74)
  IN1 w0.117: 247.69,79.51 247.15,78.97 246.04,78.97 241.76,74.69 225.49,74.69
  BOTTOM w0.102: UV26.A2 v2(248.92,80.74) ; UV18.C23 220.47,76.9 220.8,77.23 221.37,77.23 221.57,77.04 221.57,76.58 v2(221.68,76.47)
FBC_D58: length 35.8
  IN1 w0.102: v2(222.63,74.17) 223.39,73.41 226,73.41 226.24,73.65 ; v2(248.91,83.12) 248.54,82.76 248.54,82.5 248.54,82.49 248.54,82.18 248.76,81.95 249.2,81.95 249.35,81.8 249.35,80.09 249.3,80.04 249.3,79.51
  IN1 w0.117: 226.24,73.65 242.2,73.65 246.35,77.8 247.66,77.8 247.68,77.81 249.3,79.43 249.3,79.51
  BOTTOM w0.102: UV26.B4 v2(248.91,83.12) ; v2(222.63,74.17) 222.37,74.43 222.37,74.54 222.04,74.87 UV18.A21
FBC_D59: length 32.8
  IN1 w0.102: v2(248.16,80.77) 248.22,80.71 248.22,79.51 ; v2(223.39,75.19) 224.41,74.17 226.01,74.17 226.01,74.17
  IN1 w0.117: 248.22,79.51 248.22,79.26 247.29,78.33 246.14,78.33 241.98,74.17 226.01,74.17
  BOTTOM w0.102: v2(223.39,75.19) 222.95,75.63 222.57,75.63 222.51,75.69 222.48,75.69 222.44,75.73 221.53,75.73 221.43,75.63 220.98,75.63 220.55,75.2 UV18.C21 ; v2(248.16,80.77) UV26.B2
FBC_D60: length 28.6
  IN1 w0.102: v2(221.64,78.12) 224.27,78.12 224.71,77.68 225.43,77.68 ; 241.88,79.51 242.9,80.52 242.9,81.74 243.08,81.92 244.24,81.92 244.5,82.18 244.5,82.51 244.73,82.74 245.38,82.74 v2(245.75,83.11)
  IN1 w0.117: 225.43,77.68 240.16,77.68 241.77,79.29 241.77,79.39 241.88,79.51
  BOTTOM w0.102: UV18.B24 221.64,78.11 v2(221.64,78.12) ; UV26.E4 v2(245.75,83.11)
FBC_D61: length 29.9
  IN1 w0.102: 225.43,77.16 224.79,77.16 224.22,77.73 221.33,77.73 v2(220.9,78.15) ; 242.83,79.51 243.71,80.39 243.71,80.55 243.71,80.87 243.96,81.12 244.37,81.12 244.54,81.28 244.54,81.28 244.54,81.69 244.76,81.92 246.13,81.92 v2(246.51,81.54)
  IN1 w0.117: 225.43,77.16 240.48,77.16 242.83,79.51
  BOTTOM w0.102: UV26.E2 246.12,81.15 v2(246.51,81.54) ; v2(220.9,78.15) 220.45,77.7 UV18.C24
FBC_D62: length 28.3
  IN1 w0.102: 225.43,78.2 224.47,78.2 224.19,78.49 223.53,78.49 v2(222.64,79.38) ; v2(244.89,83.15) 244.73,83 244.52,83 244.28,82.75 242.4,82.75 242.13,82.48 242.13,80.39 241.24,79.51
  IN1 w0.117: 225.43,78.2 239.94,78.2 241.24,79.51
  BOTTOM w0.102: v2(222.64,79.38) 222.64,79.38 222.31,79.06 221.74,79.06 221.4,79.4 UV18.B26 ; v2(244.89,83.15) 245.31,82.73 UV26.F4
FBC_D63: length 29.9
  IN1 w0.102: v2(244.94,80.73) 244.94,80.73 243.72,79.51 ; v2(220.03,79.82) 220.03,78.59 220.35,78.28 220.35,78.17 221.17,77.34 222.44,77.34 222.49,77.39 224.23,77.39 224.99,76.63 225.43,76.63
  IN1 w0.117: 225.43,76.63 240.85,76.63 243.72,79.51
  BOTTOM w0.102: UV18.C26 220.44,79.41 v2(220.03,79.82) ; UV26.F2 244.94,80.75 v2(244.94,80.73)
FBC_DBI0#: length 21.9
  IN6 w0.102: 222.12,66.53 221.76,66.9 219.65,66.9 v2(219.24,66.48) ; v2(238.52,66.21) 238.52,66.35 238.12,66.74 238.12,67.14 237.88,67.38
  IN6 w0.117: 222.12,66.53 223,66.53 223.29,66.83 236.06,66.83 236.62,67.39 237.87,67.39 237.88,67.38
  BOTTOM w0.102: UV18.E11 218.84,66.88 v2(219.24,66.48) ; UV25.D2 v2(238.52,66.21)
FBC_DBI1#: length 23.4
  IN6 w0.102: 235.92,56.22 237.87,56.22 238.13,56.47 238.13,56.98 v2(238.52,57.38) ; v2(219.2,60.58) 219.2,59.98 221.39,57.79 221.81,57.79
  IN6 w0.117: 235.92,56.22 234.36,56.22 232.87,57.7 221.89,57.7 221.81,57.79
  BOTTOM w0.102: UV18.E3 218.81,60.2 v2(219.2,60.58) ; v2(238.52,57.38) 238.53,57.38 238.53,57.39 UV25.D13
FBC_DBI2#: length 31
  IN1 w0.102: 247.21,55.32 247.32,55.42 v2(247.32,57.4)
  IN1 w0.117: v2(223.14,59.5) 223.14,58.46 224.88,56.72 231.04,56.72 232.84,54.93 237.99,54.93 237.99,54.93 240.07,54.93 240.32,54.67 246.57,54.67 247.21,55.32
  BOTTOM w0.102: UV25.P13 v2(247.32,57.4) ; UV18.A3 222.74,59.5 v2(223.14,59.5)
FBC_DBI3#: length 29.6
  IN1 w0.098: 242.14,65.02 243.73,66.61 245.11,66.61
  IN1 w0.102: 245.11,66.61 246.06,66.61 v2(247.27,65.41) ; 242.14,65.02 236.41,65.02 235.98,65.45 235.92,65.45
  IN1 w0.117: 235.92,65.45 224.42,65.45 224.04,65.83 223.98,65.83 v2(223.46,66.36)
  BOTTOM w0.102: UV18.C9 220.58,65.2 220.92,65.53 221.3,65.53 221.55,65.79 222.89,65.79 v2(223.46,66.36) ; UV25.P2 246.92,65.76 v2(247.27,65.41)
FBC_DBI4#: length 25.1
  IN6 w0.102: v2(218.02,76.11) 218.13,76 221.86,76 222.27,75.6 223.34,75.6 ; v2(238.52,81.53) 238.14,81.15 238.14,80.42 237.22,79.51
  IN6 w0.117: 237.22,79.51 233.17,75.46 223.71,75.46 223.57,75.6 223.34,75.6
  BOTTOM w0.102: UV26.P2 v2(238.52,81.53) ; v2(218.02,76.11) 217.99,76.15 UV18.F23
FBC_DBI5#: length 28.4
  IN6 w0.102: v2(239.32,89.54) 239.06,89.54 238.67,89.93 238.39,89.93 238.12,90.19 238.12,90.47 237.85,90.74 236.79,90.74 235.97,89.92 235.97,89.66 ; v2(217.59,80.66) 217.94,81.01 217.94,81.68 218.18,81.92 219.4,81.92 219.53,82.06 220.22,82.06 220.35,81.92 223.46,81.92 223.96,82.42
  IN6 w0.117: 235.97,89.66 235.97,89.63 229.05,82.71 224.25,82.71 223.96,82.42
  BOTTOM w0.102: UV26.P13 v2(239.32,89.54) ; UV18.F27 217.99,80.23 217.59,80.63 v2(217.59,80.66)
FBC_DBI6#: length 32
  IN1 w0.102: 235.92,89.34 236.49,89.92 243.97,89.92 244.77,90.72 245.9,90.72 246.13,90.49 246.13,90.2 246.76,89.57 v2(247.32,89.57) ; v2(220.84,83.12) 221.54,82.42 225.13,82.42 225.21,82.5 225.43,82.5
  IN1 w0.117: 235.92,89.34 229.08,82.5 225.43,82.5
  BOTTOM w0.102: v2(220.84,83.12) 220.44,82.72 UV18.C30
  BOTTOM w0.13: v2(247.32,89.57) 246.96,89.94 UV26.D13
FBC_DBI7#: length 28.2
  IN1 w0.102: v2(246.55,80.77) 245.68,80.77 244.6,79.69 244.6,79.51 ; 225.43,76.11 224.53,76.11 223.93,76.71 v2(223.93,76.96)
  IN1 w0.117: 225.43,76.11 241.7,76.11 244.6,79.01 244.6,79.51
  BOTTOM w0.102: UV18.A24 222.26,77.47 223.46,77.47 223.9,77.03 223.9,76.99 v2(223.93,76.96)
  BOTTOM w0.107: v2(246.55,80.77) 246.56,80.77 UV26.D2
FBC_EDC0: length 21.1
  IN6 w0.102: v2(238.52,65.41) 238.13,65.8 238.13,66.34 237.88,66.59 236.64,66.59 236.19,66.13 ; 222.12,65.98 220.54,65.98 v2(220.04,66.48)
  IN6 w0.117: 222.12,65.98 223.24,65.98 223.43,65.79 235.84,65.79 236.19,66.13
  BOTTOM w0.102: v2(220.04,66.48) 219.64,66.08 UV18.D10 ; UV25.C2 v2(238.52,65.41)
FBC_EDC1: length 23.5
  IN6 w0.102: v2(237.72,57.4) 238.1,57.79 238.1,59.16 236.94,60.32 235.92,60.32
  IN6 w0.117: v2(223.84,62.1) 223.84,61.41 224.33,60.92 225.27,60.92 225.87,60.32 235.92,60.32
  BOTTOM w0.102: v2(223.84,62.1) 223.39,62.55 222.93,62.55 222.45,63.03 221.1,63.03 220.91,62.84 220.91,62.66 220.56,62.31 220.05,62.31 UV18.D5 ; UV25.C13 237.72,57.4 v2(237.72,57.4)
FBC_EDC2: length 34
  IN1 w0.102: v2(248.1,57.48) 248.22,57.36 248.22,55.45 248.09,55.32
  IN1 w0.117: v2(220.82,59.79) 221.24,59.38 221.24,58.68 221.39,58.52 222.34,58.52 224.67,56.2 230.8,56.2 232.13,54.87 232.16,54.87 232.62,54.4 238.2,54.4 238.2,54.41 239.85,54.41 240.15,54.1 243.15,54.1 243.19,54.15 246.92,54.15 248.09,55.32
  BOTTOM w0.102: v2(220.82,59.79) 220.82,59.81 UV18.C3 ; v2(248.1,57.48) 248.1,57.48 247.72,57.09 UV25.R13
FBC_EDC3: length 29.5
  IN1 w0.102: 246.63,67.38 246.83,67.18 246.83,66.93 247.14,66.61 247.71,66.61 v2(248.12,66.21)
  IN1 w0.117: v2(224.28,66.36) 224.66,65.98 227.52,65.98 228.16,66.62 242,66.62 242.96,67.57 246.44,67.57 246.63,67.38
  BOTTOM w0.102: v2(248.12,66.21) UV25.R2 ; v2(224.28,66.36) 224.28,66.23 223.58,65.53 221.68,65.53 221.34,65.2 UV18.B9
FBC_EDC4: length 23.7
  IN6 w0.102: 237.2,80.23 237.3,80.33 237.3,81.12 v2(237.72,81.53) ; 222.46,76.49 222.09,76.87 218.8,76.87 v2(218.45,76.52)
  IN6 w0.117: 222.46,76.49 223.67,76.49 224.18,75.98 232.95,75.98 237.2,80.23
  BOTTOM w0.102: UV18.E23 218.46,76.52 218.45,76.52 218.45,76.52 v2(218.45,76.52) ; UV26.R2 v2(237.72,81.53)
FBC_EDC5: length 27.1
  IN6 w0.102: 224.47,82.19 224.16,82.19 223.04,81.07 222.72,81.07 222.56,81.23 221.95,81.23 221.54,80.82 220.63,80.82 220.35,81.1 220.35,81.63 220.12,81.85 219.81,81.85 219.58,81.63 219.58,81.31 219.3,81.03 218.82,81.03 v2(218.38,81.47) ; 236.29,89.45 236.76,89.92 237.88,89.92 238.26,89.54 v2(238.52,89.54)
  IN6 w0.117: 236.29,89.45 236.29,88.95 229.53,82.19 224.47,82.19
  BOTTOM w0.102: UV18.E28 218.41,81.47 v2(218.38,81.47) ; UV26.R13 v2(238.52,89.54)
FBC_EDC6: length 32.6
  IN1 w0.102: v2(221.66,83.12) 221.66,83.01 222,82.68 224.9,82.68 225.25,83.03 225.43,83.03 ; 235.92,90.08 236.44,90.6 236.44,90.62 236.57,90.74 243.22,90.74 243.94,91.46 244.76,91.46 245.03,91.19 245.65,91.19 245.92,90.92 247.27,90.92 247.74,90.46 247.74,90.15 248.12,89.77 v2(248.12,89.54)
  IN1 w0.117: 225.43,83.03 228.86,83.03 235.92,90.08
  BOTTOM w0.102: UV18.B30 221.65,83.12 v2(221.66,83.12)
  BOTTOM w0.107: UV26.C13 v2(248.12,89.54)
FBC_EDC7: length 30.6
  IN1 w0.102: v2(222.75,77.01) 222.75,76.98 224.51,75.22 225.43,75.22 ; 245.84,79.51 246.06,79.73 246.06,80.07 246.38,80.39 246.76,80.39 247.14,80.77 247.14,81.28 247.42,81.55 v2(248.14,81.55)
  IN1 w0.117: 245.84,79.51 241.55,75.22 225.43,75.22
  BOTTOM w0.102: UV18.A23 222.63,76.9 v2(222.75,77.01)
  BOTTOM w0.107: UV26.C2 v2(248.14,81.55)
FBC_MA0_MA10_H: length 30.1
  TOP w0.102: 242.1,80.44 242.1,81.65 242.52,82.07 v2(242.52,82.33) ; v2(220.04,71.47) 220.2,71.64 222.58,71.64 224.09,73.15 224.54,73.15 225.44,74.06 225.73,74.06
  TOP w0.221: 225.73,74.06 v1(232.83,74.06) 235.22,74.06 235.51,74.35 237.87,74.35 242.1,78.57 242.1,80.44
  BOTTOM w0.102: UV26.K4 v2(242.52,82.33) ; v2(220.04,71.47) 219.64,71.07 UV18.D16
FBC_MA0_MA10_L: length 26.9
  BOTTOM w0.102: 224.99,70.07 224.76,69.84 219.99,69.84 UV18.D15 ; 241.18,62.68 241.81,63.31 241.81,63.89 UV25.H4
  BOTTOM w0.221: 224.99,70.07 228.63,70.07 v1(230.7,68) 236.22,62.48 240.98,62.48 241.18,62.68
FBC_MA1_MA9_H: length 27.3
  TOP w0.102: 226.09,75.51 225.9,75.51 v2(224.18,73.79) ; v2(241.87,84.04) 240.54,82.71 240.54,79.51
  TOP w0.221: 226.09,75.51 234.38,75.51 235.69,76.82 238.09,76.82 240.54,79.27 240.54,79.51
  BOTTOM w0.102: v2(224.18,73.79) 222.9,72.52 222.22,72.52 UV18.A18
  BOTTOM w0.107: UV26.K5 241.87,83.78 241.87,84.04 v2(241.87,84.04)
FBC_MA1_MA9_L: length 24.4
  BOTTOM w0.102: 224.99,69.34 223.08,69.34 223.02,69.4 UV18.A14 ; UV25.H5 242.12,62.68
  BOTTOM w0.221: 242.12,62.68 242.12,62.59 241.28,61.75 235.92,61.75 v1(231.77,65.9) 228.33,69.34 224.99,69.34
FBC_MA2_BA0_H: length 35.1
  TOP w0.102: 235.92,89.13 241.86,89.13 242.1,88.89 242.1,88.43 242.51,88.02 v2(242.51,87.95) ; 222.07,77.85 221.76,77.53 220.28,77.53 219.66,76.91 219.66,74.69 219.4,74.43 219.08,74.43 218.82,74.17 218.82,73.75 218.2,73.12 v2(217.56,73.12)
  TOP w0.221: 222.07,77.85 233.35,89.13 v1(235.18,89.13) 235.92,89.13
  BOTTOM w0.102: UV18.F18 v2(217.56,73.12) ; UV26.K11 v2(242.51,87.95)
FBC_MA2_BA0_L: length 32.6
  TOP w0.102: 235.92,57.83 242.14,57.83 v2(242.52,58.2) ; v2(217.61,69.78) 217.35,69.52 217.35,68.4 218.05,67.7 219.09,67.7
  TOP w0.119: 219.09,67.7 219.7,67.7 220.16,67.24 220.76,67.24 221.22,66.78 221.22,66.22
  TOP w0.147: 224.23,65.04 223.32,65.04 222.36,65.99 221.45,65.99 221.22,66.22
  TOP w0.221: 224.23,65.04 225.93,65.04 226.64,64.33 v1(226.98,64.33) 229.27,64.33 235.77,57.83 235.92,57.83
  BOTTOM w0.102: UV18.F14 v2(217.61,69.78) ; UV25.H11 v2(242.52,58.2)
