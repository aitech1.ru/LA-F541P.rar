# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_USB3_RX1_P_R: length 3.4
  BOTTOM w0.097: RT5832.2 20.16,40.28 arc(20.17,40.27) 20.18,40.26 arc(20.2,40.23) 20.22,40.2 20.27,40.1 21.57,38.79 arc(21.61,38.77) 21.65,38.76 22.02,38.76 arc(22.13,38.67) 22.06,38.55 UT1.A15
TBT_USB3_TX0_N: length 42
  TOP w0.097: v2(18.41,37.64) 18.41,37.49 18.47,37.41 arc(18.51,37.38) 18.55,37.37 18.8,37.37 arc(18.86,37.38) 18.92,37.42 18.94,37.45 arc(18.99,37.52) 19.01,37.6 19.01,39.81 arc(18.99,39.87) 18.94,39.92 arc(18.94,39.93) 18.93,39.93 18.92,39.93 arc(18.91,39.95) 18.9,39.96 arc(18.82,40.1) 18.79,40.25 18.79,41.15 arc(18.77,41.28) 18.7,41.38 arc(18.54,41.61) 18.49,41.89 18.49,47.83 arc(18.47,47.98) 18.43,48.12 18.38,48.24 arc(18.34,48.36) 18.33,48.49 18.33,51.37 arc(18.29,51.56) 18.18,51.72 arc(18.08,51.87) 18.05,52.05 18.05,56.93 arc(17.98,57.29) 17.77,57.59 17.61,57.76 arc(17.52,57.89) 17.49,58.03 17.49,61.98 arc(17.47,62.09) 17.41,62.19 16.97,62.63 arc(16.86,62.79) 16.82,62.97 16.82,66.01 arc(16.78,66.21) 16.67,66.38 15.57,67.48 arc(15.01,67.86) 14.34,67.99 13.69,67.99 arc(13.23,68.08) 12.85,68.34 12.42,68.76 arc(12.29,68.85) 12.14,68.88 11.52,68.88 arc(11.48,68.87) 11.44,68.85 DT13.1 11.01,68.75 arc(10.95,68.79) 10.87,68.81 10.15,68.81 arc(9.64,68.7) 9.2,68.41 9.13,68.34 arc(8.99,68.25) 8.83,68.22 8.57,68.22 arc(8.5,68.2) 8.45,68.17 8.34,68.06 JUSBC1.A3
  BOTTOM w0.097: v2(18.41,37.64) 18.41,37.58 18.7,37.29 arc(18.9,37.21) 19.09,37.29 CT40.2
TBT_USB3_TX0_N_C: length 2.7
  BOTTOM w0.097: CT40.1 20.21,37.47 arc(20.26,37.43) 20.31,37.42 20.31,37.42 arc(20.35,37.42) 20.38,37.42 arc(20.48,37.39) 20.58,37.33 arc(20.59,37.32) 20.6,37.3 20.81,37.09 arc(20.94,37.01) 21.09,36.98 21.37,36.98 arc(21.43,36.97) 21.49,36.95 arc(21.5,36.94) 21.51,36.94 arc(21.52,36.94) 21.52,36.93 arc(21.61,36.91) 21.69,36.9 22.08,36.9 arc(22.2,36.88) 22.31,36.8 UT1.B19
TBT_USB3_TX0_P: length 42.1
  TOP w0.097: JUSBC1.A2 8.35,68.56 8.46,68.45 arc(8.51,68.41) 8.57,68.4 8.83,68.4 arc(8.92,68.42) 9,68.48 9.07,68.54 arc(9.57,68.88) 10.15,68.99 10.88,68.99 arc(10.95,69) 11,69.04 11.18,69.22 DT12.1 11.29,69.17 11.38,69.13 arc(11.55,69.08) 11.73,69.06 12.14,69.06 arc(12.37,69.02) 12.55,68.89 12.98,68.47 arc(13.3,68.25) 13.69,68.17 14.34,68.17 arc(15.08,68.03) 15.71,67.61 16.8,66.51 arc(16.96,66.28) 17.01,66.01 17.01,62.97 arc(17.03,62.86) 17.1,62.76 17.54,62.32 arc(17.64,62.17) 17.68,61.98 17.68,58.03 arc(17.69,57.96) 17.74,57.89 17.91,57.72 arc(18.15,57.36) 18.23,56.93 18.23,52.05 arc(18.25,51.94) 18.32,51.85 arc(18.46,51.63) 18.51,51.37 18.51,48.49 arc(18.52,48.4) 18.55,48.31 18.6,48.19 arc(18.65,48.01) 18.67,47.83 18.67,41.89 arc(18.71,41.69) 18.83,41.51 18.83,41.51 arc(18.94,41.35) 18.98,41.16 18.98,40.25 arc(18.99,40.16) 19.04,40.08 arc(19.15,39.97) 19.19,39.81 19.19,37.6 arc(19.16,37.45) 19.08,37.31 19.07,37.32 19.05,37.29 arc(18.93,37.21) 18.8,37.19 18.61,37.19 18.55,37.14 v2(18.41,37.01)
  BOTTOM w0.097: v2(18.41,37.01) 19.38,37.01 CT39.2
TBT_USB3_TX0_P_C: length 2.7
  BOTTOM w0.097: UT1.A19 22.01,36.68 arc(22.12,36.56) 22.01,36.45 21.8,36.45 arc(21.68,36.49) 21.6,36.59 21.59,36.61 arc(21.53,36.7) 21.44,36.77 arc(21.42,36.77) 21.4,36.78 arc(21.39,36.79) 21.37,36.79 21.09,36.79 arc(20.87,36.83) 20.68,36.96 20.47,37.17 arc(20.46,37.18) 20.46,37.19 arc(20.41,37.22) 20.35,37.23 arc(20.33,37.24) 20.31,37.24 20.27,37.24 arc(20.2,37.22) 20.14,37.18 CT39.1
TBT_USB3_TX1_N: length 36.2
  TOP w0.097: v2(10.03,61.65) 9.83,61.45 arc(9.81,61.42) 9.81,61.38 9.81,61.32 arc(9.83,61.2) 9.9,61.1 10.17,60.82 arc(10.37,60.69) 10.6,60.64 14.03,60.64 arc(14.41,60.57) 14.74,60.35 15.47,59.62 arc(15.68,59.31) 15.75,58.95 15.75,51.3 arc(15.82,50.96) 16.01,50.67 16.23,50.44 arc(16.35,50.27) 16.39,50.06 16.39,45.64 arc(16.42,45.52) 16.48,45.43 16.71,45.2 arc(16.89,44.93) 16.96,44.61 16.96,41.75 arc(16.87,41.31) 16.62,40.93 16.5,40.82 arc(16.34,40.57) 16.28,40.27 16.28,39.39 arc(16.33,39.14) 16.47,38.93 16.53,38.87 arc(16.59,38.83) 16.67,38.81 16.97,38.81 arc(17,38.82) 17.03,38.84 v2(17.31,39.11)
  BOTTOM w0.097: v2(17.31,39.11) 17.47,38.95 arc(17.53,38.91) 17.61,38.89 17.83,38.89 arc(17.86,38.9) 17.89,38.91 CT38.2 ; 10.03,62.36 9.83,62.56 arc(9.8,62.61) 9.79,62.67 9.79,62.67 arc(9.76,62.83) 9.67,62.96 9.06,63.56 arc(8.91,63.67) 8.72,63.71 7.87,63.71 arc(7.69,63.74) 7.53,63.84 7,64.38 arc(6.84,64.48) 6.66,64.52 6.32,64.52 arc(6.06,64.57) JUSBC1.B3 ; 10.03,62.36 9.89,62.22 arc(9.83,62.12) 9.81,62.02 9.81,62 arc(9.83,61.89) 9.89,61.8 v2(10.03,61.65) ; 10.03,62.36 DT26.1
TBT_USB3_TX1_N_C: length 4.3
  BOTTOM w0.097: UT1.B17 22.32,37.71 arc(22.2,37.79) 22.05,37.82 21.37,37.82 arc(21.25,37.85) 21.15,37.91 20.35,38.71 arc(20.14,38.85) 19.9,38.9 18.91,38.9 arc(18.83,38.91) 18.76,38.96 CT38.1
TBT_USB3_TX1_P: length 36.1
  TOP w0.097: v2(17.31,38.48) 17.19,38.57 arc(17.1,38.61) 17.01,38.63 16.67,38.63 arc(16.52,38.66) 16.4,38.74 16.34,38.8 arc(16.16,39.07) 16.09,39.39 16.09,40.27 arc(16.16,40.64) 16.37,40.95 16.49,41.07 arc(16.7,41.38) 16.77,41.75 16.77,44.61 arc(16.72,44.86) 16.58,45.07 16.35,45.3 arc(16.25,45.45) 16.21,45.64 16.21,50.06 arc(16.18,50.2) 16.1,50.31 15.88,50.54 arc(15.65,50.89) 15.56,51.3 15.56,58.95 arc(15.51,59.24) 15.34,59.49 14.61,60.22 arc(14.34,60.4) 14.03,60.46 10.6,60.46 arc(10.3,60.52) 10.04,60.69 9.76,60.97 arc(9.66,61.13) 9.62,61.32 9.62,61.37 arc(9.61,61.43) 9.58,61.48 v2(9.4,61.65)
  BOTTOM w0.089: CT37.2 18.01,38.55
  BOTTOM w0.097: 18.01,38.55 17.91,38.66 arc(17.85,38.69) 17.79,38.71 17.61,38.71 arc(17.54,38.69) 17.48,38.65 v2(17.31,38.48) ; v2(9.4,61.65) 9.54,61.8 arc(9.6,61.89) 9.62,62 9.62,62.02 arc(9.6,62.12) 9.54,62.22 DT27.1 9.54,62.5 arc(9.59,62.57) 9.6,62.65 9.6,62.67 arc(9.59,62.76) 9.54,62.83 8.93,63.43 arc(8.84,63.5) 8.72,63.52 7.87,63.52 arc(7.61,63.57) 7.4,63.71 6.87,64.24 arc(6.77,64.31) 6.66,64.33 6.47,64.33 arc(6.29,64.29) 6.13,64.19 JUSBC1.B2
TBT_USB3_TX1_P_C: length 4.3
  BOTTOM w0.097: CT37.1 18.76,38.63 arc(18.85,38.69) 18.96,38.71 19.9,38.71 arc(20.07,38.68) 20.22,38.58 21.01,37.78 arc(21.18,37.67) 21.37,37.64 21.52,37.64 arc(21.62,37.6) 21.65,37.5 arc(21.7,37.4) 21.8,37.36 22.01,37.36 arc(22.09,37.41) 22.07,37.5 UT1.A17
TBTA_AUX_N: length 45.3
  TOP w0.152: v2(34.15,36.28) 33.77,36.28 33.66,36.39 33.66,36.64 33.8,36.79 34.13,36.79 34.32,36.97 34.32,37.48 CT42.2 ; RT432.2 19.42,60.48 v2(19.46,60.19)
  IN6 w0.107: v2(19.46,60.19) 19.65,60 20,60 20.42,59.58 20.42,58.01 19.04,56.64 19.04,54.94 20.38,53.6 20.38,53.24 20.81,52.81 20.81,48.86 23.12,46.56 23.12,44.86 22.44,44.19 22.44,38.03 23.01,37.46 23.01,36.15 24.04,35.12 31.68,35.12 32.1,35.54 34.1,35.54 34.2,35.64 34.2,35.78 34.11,35.87 33.97,35.87 33.85,35.99 33.85,36.21 33.92,36.28 v2(34.15,36.28)
  BOTTOM w0.081: UT4.J2 20.87,59.62 20.46,59.62 20.28,59.81 20.28,59.84 19.99,60.12 19.53,60.12 v2(19.46,60.19)
TBTA_AUX_N_C: length 4.8
  TOP w0.089: v2(29.96,38.92) 30.34,38.55 30.99,38.55 31.11,38.66 31.39,38.66 31.83,38.22 32.27,38.22 32.89,37.59 CT42.1
  BOTTOM w0.102: UT1.W15 v2(29.96,38.92)
TBTA_AUX_P: length 45.4
  TOP w0.152: v2(34.84,36.29) 34.75,36.29 34.65,36.39 34.65,37.92 34.41,38.16 CT41.2 ; v2(19.46,59.59) 19.74,59.59 RT431.2
  IN6 w0.107: v2(19.46,59.59) 19.66,59.8 19.92,59.8 20.21,59.5 20.21,58.1 18.84,56.73 18.84,54.85 20.18,53.52 20.18,53.15 20.61,52.73 20.61,48.78 22.91,46.47 22.91,44.94 22.24,44.27 22.24,37.95 22.81,37.38 22.81,36.07 23.96,34.92 31.77,34.92 32.19,35.34 34.18,35.34 34.4,35.56 34.4,35.95 34.74,36.29 v2(34.84,36.29)
  BOTTOM w0.081: UT4.J1 20.61,59.2 20.55,59.14 20.4,59.14 20.31,59.23 20.31,59.49 20.14,59.65 20.09,59.65 19.88,59.86 19.59,59.86 19.46,59.73 v2(19.46,59.59)
TBTA_AUX_P_C: length 4.6
  TOP w0.089: CT41.1 33.43,38.35 33.31,38.35 33.25,38.29 33.25,37.92 33.18,37.86 33,37.86 32.38,38.48 31.94,38.48 31.5,38.92 30.99,38.92 30.88,38.81 30.72,38.81 v2(30.61,38.92)
  BOTTOM w0.089: v2(30.61,38.92) 30.61,38.78 30.78,38.6 UT1.Y15
TBTA_BOT_C_N: length 11.3
  TOP w0.14: LT13.3 8.39,73.71 8.15,73.47 7.75,73.47 DT23.1 7.43,73.43 7.2,73.43 v2(6.99,73.64)
  IN2 w0.107: v2(6.99,73.64) 6.77,73.41 6.58,73.41 6.33,73.16 6.33,72.17 8,70.5 8,67.43 7.05,66.48 6.78,66.48 JUSBC1.B7
TBTA_BOT_C_P: length 11.4
  TOP w0.14: LT13.2 8.38,72.86 8.08,73.15 7.84,73.15 DT24.1 7.37,73.19 7.06,73.19 v2(6.93,73.06)
  IN2 w0.107: v2(6.93,73.06) 6.78,73.21 6.66,73.21 6.53,73.08 6.53,72.26 8.21,70.58 8.21,67.35 7.13,66.27 6.91,66.27 JUSBC1.B6
TBTA_BOT_N: length 23
  TOP w0.152: LT13.4 10.7,73.71 10.99,73.42 11.23,73.42 13.53,71.12 13.87,71.12 14.93,70.05 15.77,70.05 18.8,67.03 18.8,66.1 19.57,65.33 19.57,65.2 19.9,64.87 v3(21.82,64.87) 23.33,64.87 23.53,64.67 24.05,64.67 v2(24.11,64.73)
  BOTTOM w0.081: 23.56,62.78 23.56,62.18 23.95,61.79 23.95,61.04 23.74,60.84 23.74,60.74 23.62,60.61 UT4.L7
  BOTTOM w0.14: 23.56,62.78 23.56,64.22 24.06,64.73 v2(24.11,64.73)
TBTA_BOT_P: length 22.9
  TOP w0.152: LT13.1 10.66,72.86 10.9,73.09 11.09,73.09 13.39,70.79 13.73,70.79 14.8,69.72 15.63,69.72 18.47,66.89 18.47,65.97 19.24,65.19 19.24,65.07 19.76,64.54 23.19,64.54 23.4,64.34 23.91,64.34 v2(24.11,64.14)
  BOTTOM w0.081: UT4.K7 23.87,60.13 23.87,60.48 24.02,60.63 24.02,60.73 24.22,60.93 24.22,61.81 23.8,62.23 23.8,62.78
  BOTTOM w0.14: v2(24.11,64.14) 23.8,63.84 23.8,62.78
TBTA_CC1: length 31.3
  TOP w0.254: v2(9.54,66.93) 9.79,66.93 9.94,67.08 DT14.1 9.81,67.46 9.55,67.46
  TOP w0.305: JUSBC1.A5 8.98,67.06 9.38,67.46 9.55,67.46
  TOP w0.508: CT160.1 26.59,61.79 26.04,62.35 v2(26.04,62.5)
  IN1 w0.508: v2(26.04,62.5) 26.5,62.5 26.88,62.88 26.88,64.68 26.12,65.44 23.47,65.44 22.99,64.97 21.21,64.97 20.85,64.61 19.62,64.61 19.31,64.92 19.31,65.6 18.62,66.28 18.62,67.37 17.73,68.26 13.86,68.26 12.54,66.93 v2(9.54,66.93)
  BOTTOM w0.254: UT4.K9 UT4.L9 24.92,60.68 24.92,61.2 26.04,62.32 v2(26.04,62.5)
TBTA_CC2: length 30.7
  TOP w0.254: v2(25.48,61.02) 25.48,61.82 25.34,61.96 CT159.1
  TOP w0.508: 7.09,59.88 v1(5.65,59.88) 5.46,60.07 5.46,60.07 4.34,61.19 4.34,65.57 4.75,65.98 5.38,65.98 JUSBC1.B5
  IN1 w0.508: v2(25.48,61.02) 24.89,60.44 22.53,60.44 22.16,60.07 20.51,60.07 19.54,61.05 18.17,61.05 17.03,59.9 15.24,59.9 14.88,60.26 10.61,60.26 10.31,59.97 v2(8.37,59.97)
  BOTTOM w0.254: v2(25.48,61.02) 25.48,60.74 UT4.L10 UT4.K10
TBTA_DEBUG1: length 3.4
  BOTTOM w0.081: 20.41,61.82 20.53,61.82 21.03,61.31 21.03,60.46 UT4.L2
  BOTTOM w0.14: 20.41,61.82 20.39,61.82 20.38,61.83 19.88,61.83 19.37,62.33 RT184.2
TBTA_DEBUG2: length 4.3
  BOTTOM w0.081: 19.75,61.46 19.8,61.41 20.7,61.41 20.87,61.24 20.87,60.48 20.87,60.48 20.87,60.12 UT4.K2
  BOTTOM w0.14: 19.75,61.46 18.94,62.28 18.94,62.52 RT185.2
TBTA_DEBUG3_LSTX: length 2.9
  BOTTOM w0.081: UT4.L3 21.61,60.47 21.36,60.73 21.36,61.64 20.87,62.13 RT187.2
  BOTTOM w0.14: RT187.2 21.43,62.35 RT233.2
TBTA_DEBUG4_LSRX: length 6.4
  BOTTOM w0.081: 20.41,62.17 20.5,62.17 21.19,61.48 21.19,60.65 21.36,60.48 21.36,60.13 UT4.K3
  BOTTOM w0.14: 20.41,62.17 RT188.2 20.07,62.35 19.85,62.56 19.85,63.56 RT232.2 20.32,64.17 v1(19.6,64.9)
TBTA_HPD: length 13.9
  TOP w0.089: 27.34,46.36 27.09,46.1 26.7,46.1 26.23,45.63 26.23,44.57 26.49,44.31 26.49,43.97 26.7,43.76 v2(26.7,43.47)
  TOP w0.14: 27.34,46.36 27.7,46.71 27.7,47.6 v2(27.79,47.69) 28.26,47.69 28.7,47.25 RT43.2
  BOTTOM w0.089: UT1.M4 27.03,43.77 26.73,43.47 v2(26.7,43.47)
  BOTTOM w0.14: RT181.2 25.64,51.77 25.87,51.54 25.87,51.17 26.08,50.97 26.9,50.97 27.29,50.57 27.29,49.87 27.23,49.8 27.23,48.25 v2(27.79,47.69)
TBTA_HRESET: length 1.5
  TOP w0.14: v2(23.33,56.41) 23.33,56.85 RT429.1
  BOTTOM w0.14: v2(23.33,56.41) 23.12,56.63 UT4.D6
TBTA_I2C_INT#: length 22.9
  TOP w0.089: v4(25.41,44.13) 25.06,44.13 v1(24.7,44.49)
  IN6 w0.089: 24.08,46.36 24.08,46.21 23.74,45.86 23.74,45.13 24.47,44.39 25.15,44.39 v4(25.41,44.13)
  IN6 w0.099: v2(19.66,55.86) 20.09,55.86 21.03,54.92 21.03,54.54 23.88,51.69 23.88,48.01 24.08,47.8 24.08,46.36
  BOTTOM w0.081: 19.19,55.77 19.28,55.86 v2(19.66,55.86)
  BOTTOM w0.089: v4(25.41,44.13) 25.73,43.81 UT1.J4
  BOTTOM w0.14: RT167.2 16.6,53.72 16.09,54.23 16.09,55.52 16.68,56.11 18.07,56.11 18.63,55.55 RT5838.1 18.97,55.55 19.19,55.77
TBTA_I2C_INT#_R: length 2
  BOTTOM w0.081: UT4.C1 20.36,56.37 20.19,56.21 19.18,56.21
  BOTTOM w0.14: 19.18,56.21 18.83,56.21 RT5838.2
TBTA_LDO_BMC: length 5.5
  BOTTOM w0.081: UT4.E1 20.57,57.37 20.48,57.46 20.44,57.46 20.27,57.64 20.19,57.64 20.08,57.76 19.72,57.76 19.55,57.58 19.06,57.58 18.96,57.68
  BOTTOM w0.14: 18.96,57.68 18.42,57.68 18.39,57.72 18.11,57.72 18.08,57.68 17.25,57.68 CT144.1 v1(15.67,58.29)
TBTA_PD_SBU1: length 3
  BOTTOM w0.081: 24.93,61.85 24.93,61.84 24.55,61.46 24.55,60.78 24.37,60.6 24.37,60.13 UT4.K8
  BOTTOM w0.14: RT176.1 24.99,62.19 24.99,61.91 24.93,61.85
TBTA_PD_SBU2: length 2.3
  BOTTOM w0.081: UT4.L8 24.2,60.46 24.2,60.68 24.39,60.86 24.39,61.57 24.75,61.94 24.75,62.03
  BOTTOM w0.152: RT177.1 24.75,62.23 24.75,62.03
TBTA_RESET_N: length 33.2
  TOP w0.089: v2(25.41,42.81) 25.45,42.85 25.45,43.4 v1(25.43,43.42)
  TOP w0.14: v2(30.61,48.83) 30.42,48.83 29.81,49.44 29.09,49.44 28.93,49.59 DT29.1
  IN1 w0.089: 25.64,46.36 25.6,46.32 25.6,45.51 23.75,43.66 23.75,43.32 24.02,43.05 24.8,43.05 25.05,42.81 v2(25.41,42.81)
  IN1 w0.099: v2(26.26,57.69) 26.04,57.46 26.04,53.88 23.95,51.79 23.95,49.25 24.95,48.25 24.95,47.09 25.64,46.4 25.64,46.36
  IN3 w0.091: v2(30.61,48.83) 30.61,50.1 29.53,51.18 29.53,51.77 28.26,53.04 28.26,55.51 27.25,56.52 27.25,57.34 26.9,57.69 v2(26.26,57.69)
  BOTTOM w0.081: v2(26.26,57.69) 26.08,57.87 UT4.F11
TBTA_SBU1: length 27.8
  TOP w0.152: v2(9.84,65.71) 9.84,65.59 9.98,65.45 DT17.1 9.92,65.19 9.67,65.19 9.3,65.56 JUSBC1.A8
  IN3 w0.099: v2(9.84,65.71) 10.05,65.71 12.26,63.5 13.78,63.5 14.29,64.01 14.29,64.91 14.71,65.32 14.71,67.11 15.33,67.73 16.98,67.73 19.27,65.44 19.27,64.96 19.91,64.31 19.91,63.32 20.33,62.9 21.9,62.9 22.5,63.5 23.77,63.5 24.12,63.16 24.87,63.16 25.01,63.3 25.01,63.53 25.23,63.74 v2(25.24,63.74)
  BOTTOM w0.152: RT176.2 25.11,63.05 25.11,63.61 v2(25.24,63.74) 25.77,63.74 v1(25.91,63.88)
TBTA_SBU2: length 41
  TOP w0.152: JUSBC1.B8 4.9,67.11 4.49,67.52 4.49,72.49 DT22.1 5.33,72.52 5.57,72.76 5.69,72.76 v2(5.8,72.87)
  IN3 w0.099: v2(5.8,72.87) 5.8,72.82 5.9,72.72 5.94,72.72 8.23,70.43 8.23,67.07 8.81,66.49 9.91,66.49 10.35,66.04 10.35,65.68 12.34,63.69 13.7,63.69 14.1,64.09 14.1,64.98 14.52,65.4 14.52,67.19 15.25,67.92 17.05,67.92 19.46,65.52 19.46,65.04 20.11,64.39 20.11,63.4 20.41,63.09 21.82,63.09 22.42,63.69 23.85,63.69 24.19,63.35 24.79,63.35 24.82,63.37 24.82,63.56 v2(24.61,63.77)
  BOTTOM w0.152: v2(24.61,63.77) 24.78,63.61 24.78,63.14 RT177.2
TBTA_TOP_C_N: length 4.7
  TOP w0.14: JUSBC1.A7 8.32,66.06 8.41,66.15 v3(9.79,66.15) 10.43,66.15 10.64,66.36 DT16.1 11.23,66.36 11.54,66.67 11.77,66.67 11.93,66.51 LT12.2
TBTA_TOP_C_P: length 4.8
  TOP w0.14: JUSBC1.A6 8.31,66.56 8.39,66.48 10.29,66.48 10.71,66.89 11.01,66.89 DT15.1 11.23,67 11.7,67 12.05,67.35 LT12.3
TBTA_TOP_N: length 16.5
  TOP w0.14: v2(16.02,65) 15.98,65 15.71,65.27 15.48,65.27 15.13,65.61 15.13,66.42 14.73,66.82 14.51,66.82 14.2,66.51 LT12.1
  IN3 w0.099: v2(16.02,65) 16.24,65 16.32,65.08 16.32,65.29 16.42,65.39 16.65,65.39 17.08,64.96 17.08,63.21 18.11,62.18 19.09,62.18 19.19,62.08 22.91,62.08 23.01,62.18 23.56,62.18 23.84,61.9 23.84,61.69 23.72,61.57 23.5,61.57 v2(23.3,61.77)
  BOTTOM w0.081: UT4.L6 23.12,60.64 23.18,60.71 23.18,61.49 23.3,61.62 v2(23.3,61.77)
TBTA_TOP_P: length 16.4
  TOP w0.14: LT12.4 14.19,67.35 14.39,67.15 14.86,67.15 v3(15.2,66.82) 15.46,66.56 15.46,65.73 15.61,65.58 v2(16.02,65.58)
  IN3 w0.099: v2(16.02,65.58) 16.34,65.58 16.34,65.58 16.73,65.58 17.27,65.04 17.27,63.29 18.19,62.37 19.17,62.37 19.27,62.27 22.83,62.27 22.93,62.37 23.64,62.37 24.03,61.98 24.03,61.65 24.03,61.64 24.03,61.61 23.58,61.15 v2(23.53,61.15)
  BOTTOM w0.081: UT4.K6 23.36,60.12 23.36,60.6 23.48,60.72 23.48,61.1 v2(23.53,61.15)
TBTB_HPD: length 4.3
  BOTTOM w0.089: UT1.G2 24.97,44.74 24.97,45.14 25.11,45.28 25.39,45.28 25.72,45.61 25.72,46.29 25.66,46.36
  BOTTOM w0.14: 25.66,46.36 25.66,46.42 25.6,46.47 RT209.2 25.6,47.76 v1(25.9,48.06)
TBTB_I2C_INT#: length 3.3
  BOTTOM w0.089: UT1.E2 23.57,44.74 23.57,45.82 23.89,46.14 24.08,46.14 24.3,46.36
  BOTTOM w0.14: RT1145.2 24.89,46.79 24.54,46.43 24.38,46.43 24.3,46.36
TBTB_LSRX: length 3
  BOTTOM w0.089: UT1.B5 22.21,42.9 21.8,42.9 21.67,42.77 21.67,42.3 21.4,42.03 20.63,42.03 20.58,41.97
  BOTTOM w0.14: RT208.2 20.5,41.89 20.58,41.97
TBTB_LSTX: length 2.5
  BOTTOM w0.089: UT1.B4 22.36,43.58 22.15,43.8 21.81,43.8 21.64,43.63 21.43,43.63 21.3,43.5 20.58,43.5
  BOTTOM w0.14: 20.58,43.5 20.42,43.5 RT207.2
TESTMODE: length 9.5
  BOTTOM w0.102: 194.03,63.72 194.28,63.96 195.52,63.96 195.81,64.25 195.81,64.49 196.08,64.77 196.33,64.77 196.61,65.05 196.61,65.29 196.98,65.66 197.17,65.66 197.42,65.91 197.42,66.48 UV18.AK11
  BOTTOM w0.14: 194.03,63.72 192.37,63.72 v1(192.08,63.42) 191.17,62.52 RV592.1
THERMAL_ALERT#: length 4.2
  BOTTOM w0.14: UV18.M2 213.32,59.01 213.32,58.44 212.83,57.94 212.83,56.06 RV553.1
THERMATRIP_GPU#: length 44.1
  TOP w0.14: v2(203.26,51.94) 203.26,51.79 203.76,51.3 U33.3 ; v2(217.83,46.14) 218.25,46.56 RV1082.1 RV594.1
  IN1 w0.099: v2(212.21,57.67) 212.21,57.6 212.45,57.36 212.45,52.3 210.12,49.97 210.12,48.52 211.18,47.46 211.18,46.99 211.73,46.44 212.72,46.44 213.44,45.72 216.51,45.72 216.93,46.14 v2(217.83,46.14)
  IN6 w0.099: v2(203.26,51.94) 204.88,50.33 204.88,48.44 206.12,47.2 206.3,47.2 208.71,49.61 211.88,49.61 213.62,47.88 214.86,47.88 216.59,46.14 v2(217.83,46.14)
  BOTTOM w0.102: v2(212.21,57.67) 212.21,57.87 UV18.M1
THERMATRIP_GPU#_R: length 5.5
  TOP w0.14: RV1082.2 218.44,44.06 QV91.3 216.58,42.2 v1(215.29,42.2)
THERMDA: length 0.5
  BOTTOM w0.089: UT1.AB23 UT1.AC23
THERMTRIP1#: length 116.5
  TOP w0.14: RE25.1 291.5,22.1 v2(291.9,21.7) 292.02,21.7 292.53,21.18 293.88,21.18 294.64,20.42 294.64,19.69 UE3.B12 ; v2(203.15,51.28) 203.16,51.27 203.37,51.27 203.74,50.9 U33.4 ; v2(270.32,23.78) v1(269.67,23.78) ; v2(217.4,44.89) 217.25,45.04 RV1083.2
  IN3 w0.091: v2(217.4,44.89) 217.61,44.68 217.96,44.68 231.35,31.29 248.81,31.29 249.72,30.38 249.72,28.77 252.8,25.68 258.05,25.68 260.99,22.74 266.97,22.74 268.23,24 270.1,24 v2(270.32,23.78)
  IN6 w0.099: v2(217.4,44.89) 217.4,45.18 216.81,45.77 214.36,45.77 213.92,46.21 213.92,47.2 211.71,49.4 208.79,49.4 206.38,46.99 205.92,46.99 204.68,48.24 204.68,49.76 v2(203.15,51.28) ; v2(291.9,21.7) 291.83,21.78 288.3,21.78 287.35,20.83 281.15,20.83 280.47,20.14 278.71,20.14 277.87,20.98 273.01,20.98 270.32,23.68 v2(270.32,23.78)
THERMTRIP2#: length 11.3
  TOP w0.076: 300.53,9.53 300.53,9.99 300.1,10.42 300.1,12 299.94,12.17 UE3.H3
  TOP w0.14: QE10.1 300.76,5.46 301.69,5.46 302.09,5.86 302.09,7.06 RE66.2 ; RE66.2 CE52.1 ; RE66.2 302.3,7.9 301.26,7.9 v1(301.02,8.14) 300.84,8.32 300.84,8.86 300.53,9.17 300.53,9.53
TOUCH_SCREEN_PD#: length 334
  IN3 w0.091: v2(348.74,45.85) 348.74,46.11 348.56,46.29 v2(342.92,46.29)
  IN5 w0.089: 101.98,20.79 101.55,20.79 101.4,20.94 98.56,20.94 97.13,22.37 89.86,22.37 89.35,21.86 89.35,21.68 88.53,20.86 84.63,20.86 84.16,20.39 84.16,19.87 83.77,19.47 83.77,18.27 83.46,17.96 83.46,17.19 82.89,16.62 82.07,16.62 81.67,16.21 81.67,15.75 81.06,15.14 80.28,15.14 80.04,15.37 78.67,15.37 78.44,15.14 77.02,15.14 76.81,14.93 76.81,14.24 77.75,13.3 v2(77.75,12.66)
  IN5 w0.099: 101.98,20.79 102.38,20.79 103.19,19.98 105.98,19.98 106.85,19.11 129.65,19.11 130.81,17.95 139.75,17.95 139.96,18.16 142.03,18.16 142.24,17.95 165.98,17.95 166.19,17.74 173.85,17.74 174.8,18.7 176.25,18.7 177.23,19.67 177.23,22.61 187.03,32.41 244.19,32.41 247.96,28.64 251.96,28.64 252.92,27.67 259.04,27.67 260.63,26.07 260.63,24.43 263.6,21.46 270.25,21.46 273.35,24.56 277.1,24.56 277.91,23.76 285.24,23.76 288.02,26.54 290.6,26.54 291.1,27.05 295.23,27.05 297.51,29.34 301.88,29.34 303.64,27.58 308.34,27.58 310.39,25.53 310.39,24 310.52,23.88 314.2,23.88 316.36,26.04 327.03,26.04 328.3,27.31 328.3,33.74 331.7,37.14 331.7,39.74 333.06,41.1 333.06,41.79 333.88,42.61 336.33,42.61 338.61,44.89 339.85,44.89 341.07,43.66 344.09,43.66 344.37,43.94 344.37,44.84 v2(342.92,46.29)
  BOTTOM w0.089: v2(77.75,12.66) 77.39,12.3 UH2.AM45 77.37,12.13 76.25,12.13 76.16,12.22 75.95,12.22 75.76,12.41 75.76,12.92 75.29,13.39 74.85,13.39 74.58,13.11 74.14,13.11 73.78,13.48
  BOTTOM w0.14: v2(348.74,45.85) 348.74,46.11 348.68,46.18 DI1.1 ; v2(342.92,46.29) 342.92,46.6 v1(342.65,46.87) 341.95,47.57 JTS1.6 ; 73.78,13.48 73.78,13.64 73.17,14.25 73.17,14.47 72.77,14.86 RH510.1
TOUCHPAD_INTR#: length 4.8
  TOP w0.089: v1(82.84,3.91) v2(83.47,3.28) 83.19,3 DH1.2
  BOTTOM w0.089: RH547.1 83.47,2.53 v2(83.47,3.28) 83.47,3.73 83.83,4.1 83.83,4.92 83.86,4.94 UH2.BF32
TOUCHPAD_INTR#_EC: length 133.2
  TOP w0.14: RP19.2 285.98,11.82 v2(286.11,11.94) ; v2(299.02,9.65) 298.64,10.03 298.64,11.05 UE3.G2 ; v2(187.9,8.78) 187.15,8.04 187.15,7.43 186.48,6.76 186.48,4.74 186.86,4.35 v1(187.47,4.35) 187.81,4.35 RE138.1
  IN5 w0.099: v2(187.9,8.78) 188.19,9.08 193.77,9.08 196.36,11.67 197.81,11.67 198.43,12.29 198.43,13.04 199.15,13.76 213.15,13.76 215.86,11.05 247.47,11.05 248.22,10.3 263.22,10.3 263.74,10.83 264.9,10.83 265.72,10.01 268.26,10.01 268.33,9.95 271.68,9.95 273.37,8.26 277.65,8.26 279.02,9.63 281.54,9.63 282.5,10.59 284.01,10.59 285.3,11.87 286.04,11.87 v2(286.11,11.94)
  IN6 w0.099: v2(299.02,9.65) 297.88,10.8 292.24,10.8 290.81,9.36 290.8,8.48 290.39,8.07 287.7,8.07 286.69,9.08 286.69,10.12 287.16,10.59 287.16,10.93 286.14,11.94 v2(286.11,11.94)
TP_PWR_EN: length 120.1
  TOP w0.076: v2(300.13,16.57) 299.76,16.94 UE3.H9
  TOP w0.14: v2(199.05,8.56) 199.05,8.42 196.65,6.02 195.59,6.02 RZ32.2 193.37,5.08 192.85,5.08 192.61,5.32 UE6.3 ; v1(285.8,18.11) 285.95,18.26 v2(285.95,18.73)
  IN3 w0.091: v2(199.05,8.56) 199.65,9.16 202.71,9.16 204.41,10.86 213.68,10.86 215.08,9.46 235.4,9.46 235.71,9.15 239.78,9.15 240.29,9.65 261.88,9.65 262.51,9.02 264.42,9.02 265.44,10.03 266.45,10.03 268.99,12.57 270.77,12.57 271.96,13.77 280.87,13.77 281.15,14.05 281.15,14.92 284.16,17.92 285.14,17.92 v2(285.95,18.73)
  IN6 w0.076: v2(300.13,16.57) 299.73,16.97 299.14,16.97 298.34,16.16 295.19,16.16 293.91,17.44 293.56,17.44
  IN6 w0.099: 293.56,17.44 290.83,17.44 289.58,18.7 287.86,18.7 287.33,19.23 286.44,19.23 v2(285.95,18.73)
TPM_PIRQ#: length 93
  TOP w0.14: RE86.2 154.31,12.61 153.99,12.29 v1(153.58,12.29) 150.14,12.29 149.68,11.84 v2(149.68,11.56) 149.68,9.88 150.57,9 U32.18
  IN1 w0.076: 95.15,1.91 95.15,2.93 94.74,3.33 93.3,3.33 93.1,3.13 93.1,2.6 92.9,2.41 91.76,2.41 91.7,2.46 90.3,2.46 89.84,2.01 89.12,2.01 88.01,3.11 85.79,3.11 85.53,3.38 v2(85.01,3.38)
  IN1 w0.099: v2(147.68,2.19) 146.74,1.25 116.48,1.25 115.09,2.64 112.55,2.64 112.35,2.44 112.35,2.01 112.01,1.67 95.36,1.67 95.15,1.89 95.15,1.91
  BOTTOM w0.089: UH2.BD29 85.13,5.78 85.13,4.38 84.95,4.2 84.95,3.44 v2(85.01,3.38)
  BOTTOM w0.14: v2(149.68,11.56) 149.4,11.27 147.04,11.27 145.54,9.78 145.54,9.15 147.68,7.01 v2(147.68,2.19)
TS_DETECT#: length 337.4
  IN1 w0.076: 101.98,12.82 101.87,12.82 101.49,12.43 98.5,12.43 98.26,12.19 96.29,12.19 94.49,14 91.54,14 91.48,13.93 90.5,13.93 90.16,13.59 88.25,13.59 88.02,13.36 88.02,12.82 87.81,12.61 85.7,12.61 85.42,12.33 83.85,12.33 83.7,12.49 80.21,12.49 80.14,12.42 79.36,12.42 78.91,11.98 76.66,11.98 75.61,13.02 v2(75.08,13.02)
  IN1 w0.099: 101.98,12.82 103,12.82 103.28,13.1 104.07,13.1 104.62,12.56 107.72,12.56 108.18,13.02 112.28,13.02 112.91,13.65 128.87,13.65 129.53,13 136.89,13 139.2,10.69 148.11,10.69 148.77,10.03 149.51,10.03 150.87,8.67 154.4,8.67 154.99,8.07 155.98,8.07 157.02,7.04 158.89,7.04 159.45,7.6 165.28,7.6 165.94,6.94 175.71,6.94 176.54,7.77 182.88,7.77 183.58,7.07 184.99,7.07 185.59,7.67 186.72,7.67 187.09,7.3 204.92,7.3 206.54,8.92 210.34,8.92 214.37,4.89 230.25,4.89 231.46,6.1 238.44,6.1 240.81,8.46 250.97,8.46 252.44,6.99 252.9,6.99 253.06,6.82 261.83,6.82 262.83,7.82 268.68,7.82 268.96,8.1 270.88,8.1 271.31,7.66 272.14,7.66 273.62,9.15 281.21,9.15 282.48,7.87 284.68,7.87 285.05,8.25 286.55,8.25 288.09,6.71 290.43,6.71 v2(290.83,7.11)
  IN5 w0.099: v2(290.83,7.11) 291.28,6.67 297.05,6.67 297.36,6.98 299.06,6.98 299.67,7.6 303.84,7.6 303.86,7.62 306.77,7.62 307.52,6.88 311.22,6.88 311.44,7.09 312.03,7.09 312.36,6.76 312.36,6.16 312.15,5.95 312.15,5.13 312.25,5.03 312.9,5.03 313.23,5.36 313.23,7.54 312.08,8.69 312.08,19.73 315.92,23.57 324.78,23.57 325.55,24.33 327.58,24.33 329.11,25.87 329.11,31.1 330.66,32.65 340.84,32.65 341.43,33.23 342.7,33.23 344.88,35.42 344.88,40.13 345.63,40.88 345.63,43.44 345.97,43.77 v2(345.97,43.93)
  BOTTOM w0.089: 73.28,13.56 73.92,12.93 74.99,12.93 v2(75.08,13.02) 75.33,12.78 75.33,12.59 75.93,11.98 UH2.AM48
  BOTTOM w0.14: RC5835.2 345.7,44.91 345.97,44.63 v2(345.97,43.93) 345.97,43.86 345.87,43.75 343.23,43.75 342.95,44.03 342.95,44.6 342.86,44.69 342.86,45.7 342.44,46.11 342.44,46.42 341.15,47.72 JTS1.7 ; 73.28,13.56 72.82,14.02 72.82,14.21 72.56,14.48 RH5849.1
TS_I2C_RST#: length 304.4
  TOP w0.14: v2(263.67,9.56) 263.67,10.14 263.41,10.4 263.41,14.04 264.09,14.72 264.09,16.94 264.71,17.56 v1(264.71,18.54) 264.71,21.14 v2(266.86,23.29)
  IN3 w0.089: 101.98,8.2 101.01,7.23 100.52,7.23 99.86,6.58 98.99,6.58 98.42,6.01 95.5,6.01 95.19,5.7 94.71,5.7 94.24,6.17 91.77,6.17 91.43,6.51 88.93,6.51 88.77,6.67 87.95,6.67 87.55,6.27 86.56,6.27 85.9,6.93 v2(85.9,6.96)
  IN3 w0.091: v2(189.66,12.37) 188.57,11.27 187.71,11.27 186.52,10.09 184.07,10.09 183.63,9.65 179.92,9.65 179.19,10.37 175.29,10.37 173.7,11.97 163.7,11.97 163.12,11.39 156.08,11.39 155.91,11.22 150.98,11.22 150.78,11.02 149.25,11.02 148.71,11.56 140.53,11.56 139.89,10.92 139.45,10.92 138.81,11.56 138.3,11.56 137.54,12.32 135.33,12.32 134.24,13.41 119.6,13.41 118.14,11.94 118.14,10.53 117.78,10.18 115.27,10.18 113.61,8.52 112.38,8.52 111.51,9.39 105.95,9.39 105.21,8.65 103.52,8.65 103.2,8.97 102.75,8.97 101.98,8.2
  IN5 w0.099: v2(343.97,44.29) 343.97,44.38 343.06,45.29 338.44,45.29 336.82,43.66 334.36,43.66 332.66,41.96 332.66,41.27 331.3,39.91 331.3,37.31 327.75,33.76 327.75,27.52 326.77,26.54 315.34,26.54 313.44,28.45 309.74,28.45 309.27,27.98 306.21,27.98 303.57,30.62 296.68,30.62 294.65,28.59 294.65,28.08 294.03,27.45 290.94,27.45 290.43,26.94 287.84,26.94 287.52,26.62 286.68,26.62 286.03,25.97 278.49,25.97 277.52,24.99 270.5,24.99 268.8,23.29 v2(266.86,23.29)
  IN6 w0.099: v2(189.66,12.37) 189.66,12.88 190.87,14.08 225.61,14.08 228.9,10.8 242.19,10.8 242.95,10.03 263.19,10.03 v2(263.67,9.56)
  BOTTOM w0.089: UH2.BE29 85.35,5.63 86,6.29 86,6.83 85.9,6.93 v2(85.9,6.96)
  BOTTOM w0.14: RR44.1 343.97,44.78 v2(343.97,44.29)
UART2_RXD: length 19.9
  TOP w0.152: v2(102.99,5.46) 103.11,5.34 103.55,5.34 103.9,5.69 104.32,5.69 RH562.2
  IN1 w0.076: v2(89.66,3.91) 89.87,4.11 89.87,4.42 89.75,4.54 89.75,4.86 90.19,5.3 93.4,5.3 93.76,4.94 96.92,4.94 97.21,4.65 97.47,4.65 97.82,4.99 98.6,4.99 99.3,5.69 101.41,5.69 101.66,5.44 101.95,5.44 101.96,5.46 101.98,5.46
  IN1 w0.107: 101.98,5.46 v2(102.99,5.46)
  BOTTOM w0.089: UH2.BD20 89.39,6.17 89.39,4.85 89.66,4.58 v2(89.66,3.91)
UART2_TXD: length 19.9
  TOP w0.152: v2(102.99,4.87) 103.13,5 103.68,5 104.04,5.36 104.32,5.36 RH561.2
  IN1 w0.076: 101.98,5.25 101.96,5.25 101.95,5.27 101.58,5.27 101.33,5.52 99.37,5.52 98.68,4.82 97.89,4.82 97.54,4.47 97.14,4.47 96.84,4.77 93.69,4.77 93.33,5.13 90.26,5.13 89.92,4.79 89.92,4.61 90.04,4.49 90.04,4.08 v2(90.21,3.91)
  IN1 w0.107: 101.98,5.25 102.61,5.25 102.71,5.16 102.71,4.96 102.79,4.87 v2(102.99,4.87)
  BOTTOM w0.089: UH2.BE20 89.71,5.88 89.82,5.88 89.9,5.8 89.9,5.58 89.67,5.36 89.67,4.95 89.94,4.69 89.94,4.19 v2(90.21,3.91)
UG1_ISL88738: length 9.3
  TOP w0.14: PQ1900.4 41.66,2.16 v1(41.4,1.91)
  TOP w0.203: v2(47.02,11.41) 47.37,11.41 48.31,12.35 PU1900.11
  IN3 w0.508: v2(47.02,11.41) 47.02,11.08 v2(43.44,7.49)
  vias: v2(42.67,7.49) v2(42.96,1.49) v2(43.61,1.49)
UG2_ISL88738: length 17.9
  TOP w0.14: v2(36.46,20.19) v1(36.46,20.84)
  TOP w0.203: v6(45.25,14.1) 46.07,14.91 PU1900.5
  IN4 w0.508: v2(36.46,20.19) 36.72,20.45 41.28,20.45 45.25,16.47 v6(45.25,14.1)
  BOTTOM w0.508: PQ1901.4 38.05,18.6 v2(36.46,20.19)
UG_3V: length 11.9
  TOP w0.14: v1(341.73,23.31) v2(342.71,23.31)
  IN1 w1.016: 331.57,25.19 332.3,24.46 341.75,24.46 342.08,24.13
  vias: v2(330.33,25.53) v2(330.35,24.94) v2(343.16,22.92)
UG_5V: length 28
  TOP w0.14: v5(341.42,19.05) v2(342.49,19.05)
  IN1 w1.016: 343.92,17.91 344.17,17.65 345.57,17.65 347.83,15.39 347.83,12.1 345.63,9.91 340.18,9.91 338.15,11.94 332.53,11.94 331.41,13.06
  vias: v2(331.41,13.73) v2(331.41,13.09) v2(343.09,19.05)
UPD1_ALERT#: length 429.8
  TOP w0.076: UE3.F10 298.6,18.21 298.6,20.4 298.71,20.51 298.71,20.83
  TOP w0.14: 298.71,20.83 298.71,21.62 298.93,21.85 v2(298.93,21.91) 298.93,22.12 298.82,22.24 297.35,22.24 RE99.1 297.78,23 v1(297.78,24.56)
  IN2 w0.099: v2(317.09,22.92) 316.39,23.62 311.3,23.62 309.18,25.74 308.32,25.74 307.73,25.16 302.4,25.16 302.01,24.77 302.01,23.62 300.29,21.91 v2(298.93,21.91) ; v2(61.05,4.19) 61.23,4.37 61.23,6.46 60.8,6.89 60.8,12.27 60.77,12.3 60.77,13.71 61.41,14.36 61.41,15.83 60.61,16.64 60.61,18.27 60.47,18.4 59.46,18.4 arc(59.45,18.4) 59.44,18.41 59.02,18.84 59.02,19.65 58.43,20.23 58.43,20.94 56.27,23.1 52.64,23.1 52.08,23.67 45.24,23.67 45.01,23.45 39.55,23.45 38.23,22.12 33.91,22.12 33.46,22.58 33.46,26.88 33.83,27.26 34.95,27.26 35.46,27.76 35.46,28.7 35.12,29.04 34.1,29.04 32.29,30.86 24.98,30.86 24.05,31.79 24.05,32.31 24.25,32.51 24.25,33.1 21.54,35.81 20.71,35.81 19.73,36.79 19.73,39.5 17.5,41.73 17.5,47.3 17.02,47.78 17.02,49.15 v2(16.89,49.28)
  IN3 w0.091: v2(16.89,49.28) 16.97,49.36 16.97,50.65 17.69,51.37 17.69,54.09 16.92,54.86 16.92,60.28 17.73,61.09 19.15,61.09 19.99,60.25 21.36,60.25 22.1,59.51 22.1,59.13 22.75,58.48 v2(22.75,56.39)
  IN5 w0.099: v2(317.09,22.92) 317.09,22.23 315.22,20.35 315.22,9.7 314.8,9.29 314.8,4.73 313.83,3.76 311.82,3.76 311.28,3.21 305.97,3.21 305.47,3.71 302.33,3.71 301.69,3.07 294.57,3.07 294.12,3.52 292.81,3.52 292.16,2.87 280.56,2.87 279.72,3.71 274.18,3.71 273.34,2.87 268.92,2.87 268.53,3.25 268.53,3.66 267.3,4.9 264.37,4.9 263.75,4.28 251.78,4.28 250.67,5.39 245.34,5.39 242.24,2.29 215.1,2.29 209.65,7.74 206.29,7.74 204.63,6.08 198.85,6.08 195.39,2.62 150.13,2.62 148.58,1.07 116.65,1.07 115.09,2.63 111.07,2.63 109.99,1.55 94.02,1.55 93.35,2.22 90.45,2.22 89.77,1.55 86.85,1.55 86.06,2.33 84.26,2.33 83.68,2.91 80.24,2.91 79.95,2.61 79.11,2.61 78.68,2.18 77.61,2.18 77.24,2.55 75.15,2.55 74.39,1.79 68.1,1.79 66.99,2.9 64.64,2.9 64.29,3.25 64.29,3.68 64.52,3.92 64.98,3.92 65.09,4.03 65.09,4.56 64.82,4.83 61.68,4.83 v2(61.05,4.19)
  BOTTOM w0.081: v2(22.75,56.39) 23.12,56.02 UT4.B6
UPD_SMBCLK: length 369.5
  TOP w0.076: 295.2,9.53 295.2,9.64 295.47,9.91 295.47,11.88 UE3.C3
  TOP w0.14: 295.2,9.53 295.2,9.43 294.26,8.49 293.83,8.49 v2(293.79,8.45) 293.79,7.79 RE294.1
  IN1 w0.099: v2(26.85,50.15) 26.86,50.15 27.51,49.5 27.51,49.07 27.84,48.74 28.44,48.74 28.92,48.27 28.92,47.07 29.34,46.65 29.34,45.74 31.97,43.11 31.97,41.23 32.51,40.68 32.51,38.98 33.28,38.22 33.28,36.16 33.75,35.69 34.35,35.69 35.05,34.99 35.05,34.16 34.62,33.73 34.62,32.43 35.92,31.13 39.61,31.13 41.69,29.04 41.69,25.13 42.25,24.57 43.93,24.57 45.42,26.06 45.42,26.98 46.48,28.04 51.81,28.04 53.01,26.84 53.24,26.84 53.37,26.97 53.37,27.12 v2(53.25,27.24)
  IN3 w0.089: 75.3,27.55 75.32,27.54 75.32,27.53 75.6,27.25 76.34,27.25 79.22,27.25 79.77,27.81 80.05,27.81 80.21,27.81 ; 88.78,28.36 88.77,28.34 88.77,28.34 88.68,28.25 88.68,28.25 88.04,27.61 86.04,27.61 85.67,27.24
  IN3 w0.091: 88.78,28.36 92.67,32.24 96.17,32.24 101.27,37.34 118.2,37.34 120.71,39.86 121.62,39.86 121.8,39.68 121.95,39.68 v2(122.05,39.78) ; v2(53.25,27.24) 53.41,27.4 53.41,27.68 53.74,28.01 55.41,28.01 55.55,27.88 67.58,27.88 68.2,27.26 70.33,27.26 71.64,28.56 74.29,28.56 75.3,27.55 ; 80.21,27.81 81.14,27.81 82.31,26.64 85.07,26.64 85.67,27.24
  IN4 w0.091: v2(279.04,20.56) 279.18,20.71 279.18,20.96 278.68,21.46 262,21.46 260.1,19.56 260.1,18.35 259.55,17.8 257.26,17.8 257.14,17.68 253.64,17.68 253.39,17.42 232.16,17.42 231.1,18.48 231.1,18.49 230.76,18.83 228.82,18.83 227.61,17.61 184.57,17.61 183.2,18.99 177.48,18.99 176.68,18.18 174.97,18.18 173.97,19.18 153.29,19.18 151.38,17.27 149,17.27 148.81,17.46 121.82,17.46 119.1,14.75 113.93,14.75 113.54,15.14 113.54,16.64 114.56,17.65 116.08,17.65 116.33,17.91 116.33,18.42 115.78,18.97 115.27,18.97 113.29,20.96 113.29,26.61 113.65,26.98 113.65,30.18 112.57,31.26 112.57,31.95 120.62,40 121.64,40 121.86,39.78 v2(122.05,39.78)
  BOTTOM w0.14: RT201.1 23.88,52.64 24,52.52 24.41,52.52 25.53,51.4 25.53,51.03 25.93,50.62 26.53,50.62 26.85,50.31 v2(26.85,50.15) ; v2(293.79,8.45) 293.79,8.57 293.55,8.82 293.55,8.83 292.72,9.66 292.72,12.46 291.58,13.6 291.58,14.55 291.81,14.78 291.81,16.25 289.53,18.52 289.02,18.52 286.84,20.7 283.52,20.7 281.46,22.76 279.93,22.76 279.16,21.98 279.16,20.68 v2(279.04,20.56)
UPD_SMBCLK_R: length 2.8
  BOTTOM w0.081: UT4.B5 22.87,55.62 22.87,55.14 23.05,54.96 23.05,54.55 23.15,54.45
  BOTTOM w0.14: 23.15,54.45 23.88,53.72 RT201.2
UPD_SMBDAT: length 368.7
  TOP w0.076: UE3.B4 295.34,12.59 295.34,12.04 295.27,11.97 295.27,10 294.94,9.67 294.94,9.65
  TOP w0.14: 294.94,9.65 294.17,8.88 293.67,8.88 293.65,8.87 293.6,8.87 293.2,8.48 v2(293.2,8.45) 293.2,8.45 292.99,8.23 RE293.1
  IN1 w0.099: v2(53.84,27.24) 53.72,27.13 53.73,26.83 53.39,26.49 52.86,26.49 51.66,27.69 46.63,27.69 45.77,26.83 45.77,25.91 44.07,24.22 42.1,24.22 41.34,24.98 41.34,28.9 39.46,30.77 35.78,30.77 34.27,32.28 34.27,33.88 34.7,34.31 34.7,34.77 34.16,35.31 33.63,35.31 32.96,35.98 32.96,38.03 32.21,38.78 32.21,40.56 31.67,41.1 31.67,42.91 28.98,45.59 28.98,46.5 28.56,46.92 28.56,48.12 28.29,48.39 27.69,48.39 27.14,48.94 27.14,49.44 26.84,49.75 26.67,49.75 v2(26.26,50.15)
  IN3 w0.089: 85.92,27 86.18,27.26 88.18,27.26 89.03,28.11 ; 75.06,27.31 75.07,27.29 75.08,27.29 75.46,26.91 76.34,26.91 76.34,26.91 79.36,26.91 79.91,27.46 80.19,27.46 80.19,27.46 80.21,27.46
  IN3 w0.091: 80.21,27.46 81,27.46 82.17,26.29 85.21,26.29 85.92,27 ; v2(121.74,39.24) 121.48,39.51 120.86,39.51 118.3,36.96 101.38,36.96 96.32,31.9 92.81,31.9 89.03,28.11 ; 75.06,27.31 74.15,28.22 71.78,28.22 70.47,26.91 68.06,26.91 67.43,27.53 55.4,27.53 55.27,27.67 53.88,27.67 53.76,27.54 53.76,27.33 v2(53.84,27.24)
  IN4 w0.091: v2(121.74,39.24) 121.74,39.41 121.5,39.65 120.76,39.65 112.92,31.81 112.92,31.33 113.95,30.3 113.95,26.85 113.58,26.49 113.58,21.08 115.39,19.27 115.9,19.27 116.63,18.54 116.63,17.79 116.2,17.36 114.68,17.36 113.83,16.52 113.83,15.26 114.06,15.04 118.98,15.04 121.69,17.76 148.93,17.76 149.1,17.59 151.29,17.59 153.17,19.47 174.1,19.47 174.71,18.86 176.94,18.86 177.36,19.28 183.32,19.28 184.7,17.91 227.49,17.91 228.7,19.12 230.88,19.12 231.4,18.61 231.4,18.61 232.28,17.72 253.27,17.72 253.52,17.97 257.01,17.97 257.14,18.1 259.43,18.1 259.8,18.47 259.8,19.68 261.88,21.76 278.8,21.76 279.53,21.03 279.53,20.71 v2(279.67,20.56)
  BOTTOM w0.14: v2(293.2,8.45) 293.2,8.69 292.38,9.51 292.38,12.32 291.24,13.46 291.24,14.69 291.47,14.92 291.47,16.1 289.39,18.18 288.88,18.18 286.7,20.36 283.37,20.36 281.32,22.42 280.15,22.42 279.55,21.82 279.55,20.68 v2(279.67,20.56) ; RT200.1 23.31,52.81 23.45,52.67 23.45,52.39 23.72,52.12 24.32,52.12 25.19,51.26 25.19,50.89 25.79,50.28 26.13,50.28 v2(26.26,50.15)
UPD_SMBDAT_R: length 2
  BOTTOM w0.081: UT4.A5 22.61,55.07 22.84,54.85 22.84,54.45
  BOTTOM w0.14: 22.84,54.45 22.84,54.39 23.31,53.92 RT200.2
USB2_COMP: length 4.4
  BOTTOM w0.089: UH2.F4 98.36,25.03 98.48,24.91 101.23,24.91 101.98,24.16
  BOTTOM w0.14: 101.98,24.16 RH109.1
USB2_VBUSSENSE: length 3.7
  BOTTOM w0.089: 101.98,25.08 98.7,25.08 98.57,25.21 UH2.F3
  BOTTOM w0.14: 101.98,25.08 102.16,25.08 RH580.1
USB3_PRX_C_RD_DTX_N1: length 2
  TOP w0.152: CI8.2 321.53,38.88 321.53,38.58 322.06,38.04 322.06,37.91 321.98,37.83 UI3.23
USB3_PRX_C_RD_DTX_P1: length 2
  TOP w0.152: UI3.22 322.48,37.82 322.39,37.9 322.39,38.18 321.86,38.72 321.86,38.88 CI7.2
USB3_PRX_DTX_N1: length 255.1
  TOP w0.152: CI8.1 321.56,40.51 321.56,40.96 v2(321.39,41.12)
  IN3 w0.099: v2(321.39,41.12) 321.59,40.94 321.6,40.91 321.6,39.67 321.23,39.31 315.2,39.31 312.47,36.58 308.98,36.58 307.77,35.37 306.25,35.37 305.62,34.75 304.57,34.75 303.78,33.95 303.07,33.95 302.07,32.96 300.09,32.96 299.3,32.17 295.96,32.17 294.71,30.92 293.09,30.92 290.85,28.68 290.85,28.37 289.82,27.34 288.81,27.34 287.7,26.23 283.85,26.23 277.97,20.35 269.09,20.35 268.14,19.41 264.12,19.41 263.87,19.15 261.29,19.15 259.8,17.65 257.8,17.65 257.41,17.27 255.91,17.27 254.83,18.35 252.97,18.35 251.68,17.07 231.25,17.07 230.78,16.6 206.16,16.6 205.98,16.78 202.76,16.78 200.57,18.97 184.84,18.97 183.78,17.91 177.38,17.91 176.6,17.12 153.6,17.12 151.03,19.69 140.78,19.69 140.14,20.33 122.74,20.33 122.28,20.78 118.35,20.78 117.27,21.86 117.27,26.54 115.79,28.03 109.89,28.03 107.65,30.28 95.56,30.28 94.02,28.74 94.02,27.7 94.14,27.59 94.14,27.39 94.04,27.29 v2(93.93,27.29)
  BOTTOM w0.089: v2(93.93,27.29) 93.93,27.29 93.93,26.99 93.8,26.87 93.8,25.71 93.92,25.59 UH2.D11
USB3_PRX_DTX_N2: length 154.9
  TOP w0.152: JUSB1.5 17.01,100.53 17.45,100.53 17.9,100.97 17.9,101.44 18.02,101.56 18.34,101.56 18.41,101.49 DI7.9 DI7.1 19.98,101.49 20.06,101.57 20.26,101.57 20.44,101.39 20.44,99.11 19.66,98.32 19.66,97.17 19.98,96.85 20.33,96.85 v2(20.48,96.7)
  IN2 w0.089: 95.22,27.81 95.22,26.85 94.26,25.89 94.26,21.71 93.83,21.29 91.86,21.29 91.53,21.62 91.53,21.98 91.22,22.29 89.72,22.29 89.33,21.9 89.33,21.73 87.95,20.36 85.73,20.36 85.22,20.87 83.2,20.87 83.06,20.73 81.82,20.73 81.35,21.2 80.61,21.2 80.1,20.7 79.37,20.7 78.08,21.98 77.23,21.98 76.99,22.22 76.99,23.62 76.24,24.38 76.24,24.95 76.5,25.21 76.5,26.25 75.13,27.61 75.06,27.61
  IN2 w0.107: v2(95.22,27.88) 95.22,27.81 ; 75.06,27.61 68.43,27.61 66.95,29.09 66.41,29.09 64.57,30.93 53.52,30.93 51.96,32.49 47.92,32.49 44.85,35.56 40.1,35.56 37.37,38.29 36.52,38.29 35.69,39.13 35.69,42.97 34.46,44.2 34.46,44.76 34,45.22 34,45.43 32.91,46.51 32.91,48.18 32.22,48.88 32.22,49.21 29.47,51.95 29.47,53.39 28.33,54.53 28.33,57.69 27.59,58.43 27.59,61.21 27.22,61.57 27.22,69.26 27.14,69.35 27.14,70.64 26.63,71.15 26.63,77.48 24.12,79.99 24.12,88.45 22.28,90.29 22.28,95.9 21.34,96.84 20.62,96.84 v2(20.48,96.7)
  BOTTOM w0.089: 95.16,27.81 95.04,27.7 95.04,26.97 95.25,26.76 95.25,26.51 95.16,26.42 95.09,26.42 95.03,26.48 UH2.B9
  BOTTOM w0.152: 95.16,27.81 v2(95.22,27.88)
USB3_PRX_DTX_P1: length 255.1
  TOP w0.152: CI7.1 321.89,40.45 321.89,41.04 v2(322,41.16)
  IN3 w0.099: v2(322,41.16) 321.79,40.92 321.79,39.59 321.31,39.12 315.28,39.12 312.55,36.39 309.06,36.39 307.85,35.18 306.33,35.18 305.7,34.56 304.65,34.56 303.86,33.76 303.14,33.76 302.15,32.77 300.17,32.77 299.38,31.98 296.04,31.98 294.79,30.73 293.17,30.73 291.04,28.6 291.04,28.29 289.9,27.15 288.89,27.15 287.78,26.04 283.93,26.04 278.05,20.16 269.16,20.16 268.22,19.22 264.2,19.22 263.95,18.96 261.37,18.96 259.87,17.46 257.87,17.46 257.49,17.08 255.83,17.08 254.75,18.16 253.05,18.16 251.76,16.88 231.33,16.88 230.86,16.41 206.08,16.41 205.9,16.59 202.68,16.59 200.49,18.78 184.92,18.78 183.86,17.72 177.46,17.72 176.67,16.93 153.52,16.93 150.95,19.5 140.7,19.5 140.06,20.14 122.66,20.14 122.2,20.59 118.27,20.59 117.08,21.78 117.08,26.47 115.71,27.84 109.82,27.84 107.57,30.09 95.64,30.09 94.21,28.66 94.21,27.78 94.33,27.67 94.33,27.18 v2(94.4,27)
  BOTTOM w0.089: v2(94.4,27) 94.31,27 94.07,26.76 94.07,26.41 94.3,26.18 94.3,25.97 94.2,25.87 94.08,25.87 94.01,25.95 UH2.C11
USB3_PRX_DTX_P2: length 154.9
  TOP w0.152: v2(20.49,97.32) 20.35,97.18 20.12,97.18 19.99,97.31 19.99,98.19 20.77,98.97 20.77,101.53 20.4,101.91 19.98,101.91 19.9,101.99 DI7.2 DI7.8 18.4,101.99 18.3,101.89 17.89,101.89 17.57,101.57 17.57,101.11 17.31,100.86 17.03,100.86 JUSB1.6
  IN2 w0.089: 94.77,27.81 95.04,27.55 95.04,26.93 94.08,25.97 94.08,21.79 93.76,21.47 91.94,21.47 91.71,21.7 91.71,22.06 91.3,22.47 89.64,22.47 89.14,21.97 89.14,21.81 87.88,20.54 85.8,20.54 85.3,21.05 83.12,21.05 82.98,20.92 81.89,20.92 81.42,21.39 80.53,21.39 80.03,20.88 79.44,20.88 78.16,22.17 77.31,22.17 77.18,22.3 77.18,23.7 76.42,24.46 76.42,24.87 76.68,25.13 76.68,26.32 75.19,27.82 75.07,27.82 75.06,27.82
  IN2 w0.107: 75.06,27.82 68.51,27.82 67.03,29.29 66.49,29.29 64.66,31.13 53.6,31.13 52.04,32.69 48.01,32.69 44.93,35.76 40.18,35.76 37.45,38.49 36.61,38.49 35.89,39.21 35.89,43.05 34.66,44.29 34.66,44.84 34.2,45.3 34.2,45.51 33.12,46.6 33.12,48.27 32.42,48.96 32.42,49.29 29.68,52.04 29.68,53.47 28.53,54.62 28.53,57.77 27.79,58.52 27.79,61.29 27.43,61.65 27.43,69.35 27.34,69.44 27.34,70.72 26.83,71.23 26.83,77.57 24.32,80.07 24.32,88.53 22.49,90.37 22.49,95.99 21.43,97.04 20.77,97.04 v2(20.49,97.32) ; v2(94.64,27.88) 94.71,27.88 94.77,27.81
  BOTTOM w0.089: 94.69,27.81 94.77,27.73 94.77,26.35 UH2.C9
  BOTTOM w0.152: v2(94.64,27.88) 94.64,27.87 94.69,27.81
USB3_PRX_L_DTX_N1: length 64.8
  TOP w0.152: v2(331.36,73.88) 331.52,73.71 332.17,73.71 332.26,73.8 DI9.1 DI9.9 333.71,73.8 333.79,73.72 334.02,73.72 334.2,73.9 334.2,75.76 335.12,76.68 335.66,76.68 335.82,76.83 JUSB2.5 ; v2(321.81,30.35) 321.97,30.52 321.97,31.06 RI40.2
  IN1 w0.107: v2(321.81,30.35) 321.81,30.52 321.81,30.67 321.81,31.15 322.07,31.42 326.66,31.42 329.62,34.38 329.62,35.26 330.63,36.28 330.63,36.53 331.47,37.37 331.47,39.79 332.79,41.11 332.79,44.73 333.3,45.23 333.3,49.89 336.3,52.89 336.3,61.49 332.53,65.25 331.54,65.25 329.9,66.89 329.9,72.76 330.85,73.71 331.19,73.71 v2(331.36,73.88)
USB3_PRX_L_DTX_P1: length 64.8
  TOP w0.152: RI39.2 322.3,30.94 322.3,30.48 v2(322.43,30.35) ; v2(331.36,73.29) 331.44,73.38 332.1,73.38 332.19,73.3 DI9.2 DI9.8 333.72,73.3 333.81,73.39 334.15,73.39 334.53,73.77 334.53,75.62 335.26,76.35 335.62,76.35 335.82,76.15 JUSB2.6
  IN1 w0.107: v2(331.36,73.29) 331.14,73.51 330.94,73.51 330.1,72.67 330.1,66.98 331.62,65.46 332.61,65.46 336.5,61.57 336.5,52.81 333.5,49.81 333.5,45.15 333,44.64 333,41.02 331.67,39.7 331.67,37.29 330.84,36.45 330.84,36.2 329.82,35.18 329.82,34.29 326.75,31.22 322.16,31.22 322.01,31.07 322.01,30.73 322.39,30.35 v2(322.43,30.35)
USB3_PRX_RD_DTX_N1: length 1.5
  TOP w0.152: UI3.8 321.98,33.12 322.05,33.04 322.05,32.36 RI40.1
USB3_PRX_RD_DTX_P1: length 1.5
  TOP w0.152: UI3.9 322.48,33.14 322.38,33.04 322.38,32.33 RI39.1
USB3_PTX_C_DRX_N1: length 1.1
  TOP w0.14: CI16.2 324.17,30.9 324.17,30.55 RI37.1
USB3_PTX_C_DRX_N2: length 14.3
  TOP w0.152: JUSB1.8 17.04,106.55 17.36,106.55 17.63,106.29 17.63,103.42 17.99,103.06 18.3,103.06 18.37,102.99 DI7.7 DI7.4 20.12,102.99 20.2,103.07 20.55,103.07 20.83,103.35 20.83,104.33 20.19,104.96 20.19,106.54 v2(20.31,106.66)
  BOTTOM w0.152: v2(20.31,106.66) 20.19,106.53 20.19,106.25 20.31,106.12 20.54,106.12 20.82,106.4 21.57,106.4 CI9.2
USB3_PTX_C_DRX_P1: length 1.1
  TOP w0.14: RI38.1 324.49,30.61 324.49,30.96 CI20.2
USB3_PTX_C_DRX_P2: length 14.3
  TOP w0.152: v2(19.73,106.66) 19.86,106.53 19.86,104.83 20.5,104.19 20.5,103.49 20.42,103.41 20.2,103.41 20.12,103.49 DI7.5 DI7.6 18.36,103.49 18.26,103.39 18.12,103.39 17.96,103.56 17.96,106.43 17.5,106.88 17,106.88 JUSB1.9
  BOTTOM w0.152: CI10.2 21.57,106.07 20.96,106.07 20.68,105.79 20.18,105.79 19.86,106.11 19.86,106.53 v2(19.73,106.66)
USB3_PTX_C_RD_DRX_N1: length 1.9
  TOP w0.152: CI6.2 323.76,38.8 323.76,38.57 323.56,38.37 323.56,38.08 323.48,37.99 UI3.20
USB3_PTX_C_RD_DRX_P1: length 1.9
  TOP w0.152: CI5.2 324.09,38.82 324.09,38.43 323.89,38.23 323.89,38.04 323.98,37.96 UI3.19
USB3_PTX_DRX_N1: length 255.4
  TOP w0.152: v2(323.61,41.17) 323.75,41.03 323.75,40.54 CI6.1
  IN3 w0.089: v2(95.27,24.11) 95.37,24.41 95.34,24.47 95.28,24.53 95.28,26.99 95.65,27.36 95.65,27.53 95.91,27.79 97.02,27.79 97.05,27.81
  IN3 w0.099: v2(323.61,41.17) 323.78,41 323.78,40.33 320.66,37.21 314.08,37.21 312.24,35.37 308.63,35.37 308.02,34.76 306.58,34.76 305.87,34.05 304.82,34.05 301.7,30.93 296.59,30.93 295.02,29.35 292.63,29.35 291.57,28.29 291.57,27.87 290.12,26.42 289.69,26.42 287.66,24.39 285.04,24.39 284.21,23.56 283.27,23.56 279.2,19.5 271.22,19.5 270.56,18.84 268.63,18.84 268.2,18.4 261.47,18.4 260.08,17.02 258.19,17.02 257.74,16.57 256.61,16.57 256,15.96 253.21,15.96 252.77,16.41 249.31,16.41 248.33,15.43 246.78,15.43 245.74,16.47 231.51,16.47 231.04,16 205.88,16 205.71,16.18 202.12,16.18 201.19,17.12 177.71,17.12 177.11,16.52 153.01,16.52 152.71,16.83 147.89,16.83 145.63,19.09 140.5,19.09 139.91,19.69 122.37,19.69 121.94,20.12 118.18,20.12 116.59,21.71 116.59,25.8 115.03,27.36 109.67,27.36 107.4,29.62 98.86,29.62 97.25,28.02 97.05,27.81
  BOTTOM w0.089: UH2.F9 v2(95.27,24.11)
USB3_PTX_DRX_N2: length 159.3
  IN2 w0.089: 75.06,25.62 75.11,25.57 75.11,24.64 76.16,23.59 76.16,21.41 77.23,20.34 78.63,20.34 80.99,17.97 83.69,17.97 84.03,18.31 84.03,18.84 84.27,19.08 87.86,19.08 88,18.94 88.67,18.94 88.83,19.1 91.87,19.1 91.89,19.08 95.26,19.08 96.48,20.3 96.96,20.3 97.62,20.96 97.62,23.12 98.56,24.05 98.56,25.17 98.31,25.41 v2(98.31,25.67)
  IN2 w0.107: 75.06,25.62 73.7,26.99 68.06,26.99 67.29,27.76 66.42,27.76 63.9,30.29 53.29,30.29 51.77,31.8 47.22,31.8 44.1,34.93 39.85,34.93 37.64,37.14 36.81,37.14 35.04,38.91 35.04,42.12 33.84,43.33 33.84,44.51 33.34,45.01 33.34,45.22 32.76,45.79 32.14,45.79 31.5,46.44 31.5,46.99 31.69,47.18 31.69,47.94 31.57,48.06 31.57,48.92 28.86,51.63 28.86,52.64 26.95,54.55 26.95,55.81 27.69,56.55 27.69,57.35 26.93,58.11 26.93,60.96 26.61,61.28 26.61,68.79 26.5,68.89 26.5,70.36 25.18,71.69 25.18,74.37 23.2,76.35 23.2,88.35 21.64,89.91 21.64,93.48 19.43,95.69 19.43,97.08 19.86,97.51 19.86,99.27 22.4,101.81 22.4,105.68 23.14,106.41 23.66,106.41 v2(23.75,106.5)
  BOTTOM w0.089: UH2.C3 v2(98.31,25.67)
  BOTTOM w0.152: v2(23.75,106.5) 23.62,106.38 22.73,106.38 CI9.1
USB3_PTX_DRX_P1: length 255.4
  TOP w0.152: CI5.1 324.08,40.54 324.08,41.03 v2(324.23,41.18)
  IN3 w0.089: 97.32,27.81 97.11,27.61 95.99,27.61 95.84,27.46 95.84,27.28 95.47,26.91 95.47,24.6 95.49,24.57 95.53,24.5 v2(95.84,24.4)
  IN3 w0.099: 97.32,27.81 98.94,29.43 107.32,29.43 109.59,27.17 114.95,27.17 116.4,25.72 116.4,21.63 118.1,19.93 121.86,19.93 122.29,19.5 139.83,19.5 140.42,18.9 145.55,18.9 147.81,16.64 152.63,16.64 152.93,16.33 177.19,16.33 177.79,16.93 201.11,16.93 202.05,15.99 205.63,15.99 205.8,15.81 231.12,15.81 231.59,16.28 245.66,16.28 246.7,15.24 248.41,15.24 249.39,16.22 252.69,16.22 253.14,15.77 256.08,15.77 256.69,16.38 257.82,16.38 258.27,16.83 260.16,16.83 261.54,18.21 268.28,18.21 268.71,18.64 270.64,18.64 271.3,19.31 279.28,19.31 283.35,23.37 284.29,23.37 285.12,24.19 287.74,24.19 289.77,26.23 290.2,26.23 291.76,27.79 291.76,28.21 292.71,29.16 295.1,29.16 296.67,30.74 301.78,30.74 304.9,33.86 305.94,33.86 306.66,34.57 308.1,34.57 308.71,35.18 312.32,35.18 314.16,37.02 320.74,37.02 323.97,40.25 323.97,40.92 v2(324.23,41.18)
  BOTTOM w0.089: UH2.F7 95.75,24.81 95.75,24.49 v2(95.84,24.4)
USB3_PTX_DRX_P2: length 159.2
  IN2 w0.089: 75.06,25.92 75.29,25.69 75.29,24.71 76.35,23.66 76.35,21.48 77.31,20.52 78.71,20.52 81.07,18.16 83.62,18.16 83.85,18.39 83.85,18.92 84.19,19.26 87.94,19.26 88.07,19.13 88.59,19.13 88.75,19.29 91.94,19.29 91.97,19.26 95.18,19.26 96.4,20.48 96.88,20.48 97.44,21.03 97.44,23.19 98.38,24.13 98.38,25.09 98.25,25.21 98.17,25.21 97.95,25 97.82,25 97.75,25.06 v2(97.75,25.38)
  IN2 w0.107: 75.06,25.92 73.79,27.19 68.15,27.19 67.37,27.97 66.5,27.97 63.98,30.49 53.37,30.49 51.86,32.01 47.31,32.01 44.18,35.13 39.93,35.13 37.72,37.34 36.89,37.34 35.24,38.99 35.24,42.21 34.04,43.41 34.04,44.59 33.54,45.09 33.54,45.3 32.85,46 32.23,46 31.7,46.52 31.7,46.91 31.89,47.1 31.89,48.03 31.78,48.14 31.78,49 29.06,51.72 29.06,52.73 27.15,54.64 27.15,55.73 27.89,56.47 27.89,57.44 27.13,58.2 27.13,61.04 26.81,61.36 26.81,68.87 26.71,68.98 26.71,70.45 25.38,71.78 25.38,74.45 23.4,76.43 23.4,88.43 21.84,90 21.84,93.57 19.64,95.77 19.64,96.99 20.07,97.43 20.07,99.19 22.61,101.73 22.61,105.59 23.22,106.21 23.46,106.21 v2(23.75,105.92)
  BOTTOM w0.089: UH2.D4 97.86,25.88 97.95,25.79 97.95,25.43 97.9,25.38 v2(97.75,25.38)
  BOTTOM w0.152: v2(23.75,105.92) 23.62,106.05 22.5,106.05 22.43,105.98 CI10.1
USB3_PTX_L_DRX_N1: length 62.8
  TOP w0.152: v2(324.03,28.41) 324.19,28.57 324.19,29.23 RI37.2 ; JUSB2.8 335.82,71.09 335.39,70.66 335.22,70.66 334.6,71.28 334.6,71.81 334.19,72.21 333.87,72.21 333.79,72.3 DI9.7 DI9.4 332.34,72.3 332.26,72.21 331.97,72.21 331.66,71.91 331.52,71.91 v2(331.37,72.06)
  IN1 w0.107: v2(324.03,28.41) 324.03,29.3 325.53,30.8 327.06,30.8 330.25,33.99 330.25,34.76 330.93,35.43 332.36,35.43 333.43,36.5 333.43,43.17 335.06,44.8 335.06,50.52 337.06,52.52 337.06,62.73 333.91,65.87 331.79,65.87 330.66,67.01 330.66,70.72 330.52,70.86 330.52,71.84 330.74,72.06 v2(331.37,72.06)
USB3_PTX_L_DRX_P1: length 62.8
  TOP w0.152: v2(331.37,71.43) 331.52,71.58 331.8,71.58 332.11,71.88 332.26,71.88 332.34,71.8 DI9.5 DI9.6 333.73,71.8 333.82,71.88 334.05,71.88 334.27,71.67 334.27,71.15 335.08,70.33 335.31,70.33 335.82,69.82 JUSB2.9 ; v2(324.68,28.45) 324.52,28.61 324.52,29.22 RI38.2
  IN1 w0.107: v2(331.37,71.43) 330.94,71.86 330.82,71.86 330.72,71.76 330.72,70.94 330.86,70.8 330.86,67.1 331.88,66.08 334,66.08 337.26,62.81 337.26,52.43 335.27,50.43 335.27,44.72 333.63,43.08 333.63,36.42 332.44,35.23 331.01,35.23 330.46,34.67 330.46,33.91 327.14,30.6 325.62,30.6 324.24,29.22 324.24,28.89 v2(324.68,28.45)
USB3_PTX_RD_DRX_N1: length 1.7
  TOP w0.152: CI16.1 324.05,32.33 324.05,32.55 323.48,33.13 UI3.11
USB3_PTX_RD_DRX_P1: length 1.7
  TOP w0.152: UI3.12 323.98,33.1 324.38,32.69 324.38,32.49 CI20.1
USB20_FP_N7_CONN: length 4.5
  BOTTOM w0.152: ML17.3 316.48,32.21 316.7,32.43 316.7,32.88 DI17.1 316.7,33.41 316.7,33.69 315.68,34.71 315.68,35.09 315.6,35.18 JFP.6
USB20_FP_P7_CONN: length 4.5
  BOTTOM w0.152: JFP.5 316.1,35.18 316.01,35.09 316.01,34.85 317.03,33.83 317.03,33.41 DI13.1 317.03,32.88 317.03,32.48 317.33,32.18 ML17.2
USB20_N1: length 279.2
  IN1 w0.076: v2(100,23.38) 100.09,23.29 101.09,23.29 101.82,24.02 101.82,24.04 101.84,24.06
  IN1 w0.107: v2(330.15,61.85) 330.15,62.62 329.86,62.91 329.1,62.91 328.31,62.12 328.31,56.31 325.62,53.61 325.62,51.08 322.64,48.1 322.64,40.93 321.89,40.17 314.86,40.17 304.38,29.69 300.61,29.69 297.72,26.81 296.37,26.81 295.37,25.81 294.37,25.81 292.35,23.79 288.55,23.79 288.33,23.57 278.5,23.57 276.42,21.49 270.9,21.49 270.28,20.87 268.66,20.87 267.79,19.99 264.8,19.99 263.53,18.72 262.75,18.72 260.47,16.44 260.47,12.56 259.46,11.55 253.27,11.55 252.07,12.75 247.21,12.75 246.61,13.35 238.81,13.35 237.51,14.65 232.22,14.65 231.45,13.87 156.85,13.87 155.95,14.77 154.92,14.77 151.75,17.95 147.08,17.95 145.99,19.04 140.86,19.04 138.82,21.08 137.52,21.08 136.88,21.73 136.88,25.61 134.97,27.52 109.23,27.52 108.2,28.55 106.8,28.55 105.66,27.41 105.19,27.41 101.84,24.06
  BOTTOM w0.089: UH2.J3 98.03,23.18 98.32,23.47 99.7,23.47 99.79,23.38 v2(100,23.38)
  BOTTOM w0.152: UI2.2 330.07,62.32 329.99,62.23 329.99,62.02 v2(330.15,61.85)
