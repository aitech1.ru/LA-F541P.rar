# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP: 27.54,45.11 27.54,44.47 27.77,44.25 27.77,43.98 27.9,43.85 28.09,43.85 28.26,44.01 28.26,44.5 28.27,44.52 28.19,44.6 28.19,45.41 28.13,45.46 28.03,45.46 27.63,45.87 26.45,45.87 26.37,45.79 26.37,45.32 26.48,45.22 27.44,45.22
GND on TOP: 149.42,74.73 147.9,74.73 147.75,74.58 147.75,69.76 148.02,69.5 149.37,69.5 149.74,69.87 149.74,74.41
GND on TOP: 237.75,53 235.29,53 235.21,53.09 235.21,53.21 234.47,53.94 234.47,54.83 234.76,55.12 235.59,55.12 235.59,55.24 242.15,55.24 242.29,55.37 242.29,56.07 242.85,56.63 242.85,56.65 243.19,57 245.33,57 245.42,56.94 245.41,56.84 245.68,56.31 245.95,56.84 245.94,56.94 246.03,57 246.34,57 246.34,55.93 246.41,55.93 246.41,55.68 246.06,55.34 246.06,55.18 246,55.18 246,54.74 245.62,54.36 239.1,54.36
GND on TOP: 20.5,14.31 20.56,14.25 20.56,12.94 20.15,12.54 18.71,12.54 18.52,12.35 18.52,9.9 17.92,9.29 17.92,7.46 17.8,7.34 16.32,7.34 16.26,7.39 16.26,7.39 15.44,7.39 15.24,7.6 15.24,8.48 15.27,8.51 15.27,10.39 16.26,11.38 16.26,13.1 16.59,13.43 19.94,13.43 20.08,13.57 20.08,14.23 20.17,14.31
GND on TOP: 266.69,22.67 267.45,22.67 267.57,22.56 267.57,21.68 267.43,21.54 266.9,21.54 266.66,21.3 266.66,20.35 266.83,20.18 267.06,20.18 267.36,20.48 267.89,20.48 268.02,20.36 268.02,18.75 267.86,18.59 266.05,18.59 265.52,19.12 265.52,21.5
GND on TOP: 149.62,81.59 147.89,81.59 147.61,81.31 147.61,76.13 147.69,76.05 149.5,76.05 149.72,76.28 149.72,81.49
GND on TOP: 32.11,35.56 33.3,35.56 33.73,35.13 33.73,33.58 33.3,33.15 32.13,33.15 31.73,33.55 31.73,35.18
GND on TOP: 21.58,35.93 20.82,35.93 20.7,36.05 20.7,36.29 20.85,36.44 20.85,40.11 21.46,40.72 21.46,42.61 21.41,42.66 21.46,42.71 21.46,42.77 21.46,42.78 21.48,42.87 21.46,42.97 21.46,42.98 21.46,43.38 21.46,43.38 21.48,43.48 21.46,43.58 21.46,43.59 21.46,43.66 20.88,44.25 20.88,45.23 20.83,45.28 19.68,46.42 19.68,47.59 19.94,47.85 21.13,47.85 21.21,47.77 21.21,46.36 21.21,46.35 22.24,45.32 22.49,45.32 22.66,45.15 22.66,44.38 22.6,44.33 22.1,44.33 21.89,44.12 21.89,40.22 21.69,40.03 21.69,36.6 22.22,36.06 22.98,36.06 23.05,36.14 23.05,37.04 23.26,37.24 24.27,37.24 24.34,37.17 24.33,37.14 24.34,37 24.41,36.88 24.41,36.08 24.36,35.99 24.26,35.99 23.88,35.93 23.84,35.54 23.84,35.44 23.75,35.39 21.9,35.39 21.68,35.6 21.68,35.83
GND on TOP: 144.58,82.25 144.1,82.25 143.78,81.94 143.78,79.72 143.78,79.6 143.4,79.22 143.4,76.33 143.7,76.03 144.52,76.03 144.85,76.36 144.85,81.91 144.89,81.95
GND on TOP: 245.47,109.36 244.41,109.36 244.16,109.11 244.16,106.94 244.39,106.71 245.82,106.71 245.92,106.81 245.92,107.14 245.65,107.41 245.65,109.17
GND on TOP: 10.93,18.35 11.04,18.46 12.91,18.46 13.04,18.33 13.04,16.74 12.92,16.62 12.92,15.88 12.72,15.68 11.12,15.68 10.93,15.87
GND on TOP: 134.7,111.65 135.03,111.32 135.03,109.39 134.64,108.99 126.64,108.99 126.49,109.14 126.49,109.42 125.48,110.44 125.48,110.57 124.99,111.05 124.99,111.33 125.31,111.65
GND on TOP: 275.53,9.15 275.53,10.03 275.46,10.1 273.05,10.1 272.67,9.72 272.67,5.65 273.05,5.27 275.91,5.27 276.04,5.4 276.04,6.16 275.91,6.29 273.88,6.29 273.69,6.48 273.69,7.75 274.07,8.13 274.07,8.95 274.19,9.08 275.46,9.08
GND on TOP: 170.77,74.09 170.77,72.6 170.56,72.39 170.07,72.39 169.69,72.01 169.69,69.85 168.69,68.85 168.3,68.85 168.12,69.03 168.12,70.17 168.39,70.44 168.39,75.36 168.28,75.46 166.41,75.46 165.31,76.56 165.31,78.45 166.08,79.21 170.45,79.21 170.53,79.14 170.53,74.34
GND on TOP: 118.87,59.67 118.87,57.02 118.56,56.71 114.45,56.71 114.27,56.89 114.27,59.15 115.04,59.92 118.62,59.92
GND on TOP: 98.81,6.74 99.05,6.5 99.05,5.05 98.75,4.75 98.75,4.25 99.97,3.03 99.97,1.67 99.57,1.27 98.55,1.27 97.57,2.25 97.57,4.56 97.83,4.82 97.83,5.25 97.49,5.6 97.49,6.38 97.85,6.74
GND on TOP: 108.62,98.16 110.99,98.16 112.38,96.77 112.38,94.18 111.9,93.71 111.9,93.15 111.19,92.44 104.26,92.44 103.96,92.74 103.96,94.87 104.09,95 104.88,95 104.98,94.9 104.98,94.11 105.31,93.78 107.98,93.78 108.33,94.13 108.33,95.78 108.24,95.87 108.24,97.78
GND on TOP: 126,15.62 126,13.88 125.94,13.82 125.94,12.83 125.72,12.61 125.08,12.61 125.01,12.69 125.01,15.14 124.88,15.26 123.96,15.26 123.66,15.56 123.66,15.82 123.89,16.05 125.57,16.05
GND on TOP: 166.87,33.17 163.96,33.17 163.34,32.55 163.34,29.19 163.55,28.97 166.57,28.97 167.17,29.57 167.17,32.87
GND on TOP: 242.72,111.71 246.46,111.71 246.61,111.86 246.61,113.08 246.28,113.41 242.8,113.41 242.52,113.13 242.52,111.91
GND on BOTTOM: 44.07,27.69 43.69,27.31 39.57,27.31 39.35,27.53 39.35,30.56 39.28,30.63 39.28,30.99 39.41,31.12 42.55,31.12 42.93,31.5 42.93,32.51 43.18,32.77 43.82,32.77 44.07,32.51
GND on BOTTOM: 191.52,111.38 191.52,110.24 191.71,110.05 192.91,110.05 193.04,109.92 193.04,109.73 193.17,109.6 194.18,109.6 194.57,109.98 197.23,109.98 197.49,110.24 197.49,110.75 197.36,110.87 193.42,110.87 193.1,111.19 193.1,111.44 192.85,111.7 192.6,111.7 192.47,111.57 191.71,111.57
GND on BOTTOM: 97.8,5.23 99.08,5.23 99.2,5.12 99.2,4.87 99.35,4.72 101.2,4.72 101.98,5.5 102.53,5.5 102.63,5.4 102.63,4.86 103.06,4.42 103.06,3.5 102.96,3.39 102.53,3.39 102.42,3.51 102.42,4.31 102.43,4.32 102.43,4.64 102.39,4.67 101.97,4.67 101.96,4.66 101.8,4.66 101.75,4.61 101.75,4.29 101.49,4.03 100.25,4.03 99.25,3.03 97.73,3.03 97.44,3.33 97.44,3.85 97.44,3.86 97.44,4.87
GND on BOTTOM: 25.85,84.28 25.85,85.38 26.01,85.54 26.46,85.54 26.67,85.75 26.67,89.44 26.53,89.58 26.53,90.35 26.34,90.54 25.11,90.54 24.89,90.76 24.89,92.05 24.92,92.08 24.92,92.43 25.45,92.96 26.5,92.96 26.69,92.77 26.69,92.56 26.54,92.41 26.54,91.7 26.74,91.5 28.47,91.5 28.64,91.67 28.82,91.67 28.96,91.54 28.96,90.37 28.96,84.27 28.37,83.68 26.44,83.68
GND on BOTTOM: outline of 628 points within 18.47,35.17 31.75,47.93
GND on BOTTOM: 165.05,92.86 163.42,94.49 163.42,96.85 161.9,98.38 161.9,105.41 162.15,105.67 163.17,105.67 163.47,105.96 165.05,105.96 165.17,105.85 165.17,104.38 164.94,104.15 164.94,102.55 164.42,102.03 164.39,102.03 164.39,101.04 164.75,100.68 166.42,100.68 166.9,100.2 166.9,99.87 166.85,99.82 166.85,99.34 166.7,99.19 166.32,99.19 165.99,98.86 165.99,97.74 166.19,97.54 166.98,97.54 167.11,97.66 167.11,98.27 167.36,98.53 168.24,98.53 168.37,98.4 168.37,95.59 169,94.96 174.12,94.96 174.94,94.13 176.3,94.13 176.4,94.03 176.4,93.07 176.2,92.86 169.61,92.86 168.94,93.54 166.82,93.54 166.63,93.35 166.63,92.99 166.5,92.86
GND on BOTTOM: 213.78,119.76 215.01,119.76 215.27,120.02 215.27,121.03 215.1,121.2 208.71,121.2 208.54,121.03 208.54,120.27 209.36,119.45 213.47,119.45
GND on BOTTOM: 105.61,61.85 107.01,61.85 107.39,62.23 108.51,62.23 108.89,61.85 109.88,61.85 109.98,61.75 109.98,61.62 109.88,61.52 108.94,61.52 108.31,60.88 107.14,60.88 106.94,61.09 105.82,61.09 105.14,60.41 105.14,59.68 105.77,59.06 106,59.06 106.07,58.98 106.07,57.94 105.97,57.84 104.85,57.84 104.45,57.43 103.89,57.43 103.76,57.56 103.76,60
GND on BOTTOM: 287.54,31.98 287.54,31.17 287.5,31.13 287.41,31.13 286.92,31.62 286.64,31.62 286.04,32.22 286.04,33.45 286.18,33.59 287.5,33.59 287.63,33.47 287.63,33.1 287.16,32.63 287.16,32.34 287.31,32.19 287.33,32.19
GND on BOTTOM: 103.36,21.76 103.36,18.27 102.68,17.59 102.25,17.59 101.79,17.13 100.91,17.13 100.5,17.54 100.5,17.78 100.64,17.91 100.81,17.91 100.91,17.81 100.94,17.81 101.04,17.71 101.75,17.71 102.01,17.98 102.01,18.48 101.86,18.63 101.86,20.1 101.86,20.1 101.86,20.62 102.26,21.02 102.26,21.77 102.4,21.91 103.2,21.91
GND on BOTTOM: 27.69,20.97 27.5,21.16 27.5,21.16 27.44,21.21 27.44,22.62 27.43,22.63 26.56,22.63 26.38,22.45 26.38,21.98 25.73,21.34 25.66,21.34 25.56,21.23 25.56,20.65 25.67,20.54 27.6,20.54 27.69,20.63
GND on BOTTOM: 342.39,63.83 342.39,60.01 342.14,59.75 341.5,59.75 341.44,59.82 341.44,63.89 341.53,63.98 342.24,63.98
GND on BOTTOM: 239.02,115.11 240.67,115.11 240.82,115.27 240.82,115.52 240.87,115.57 243.59,115.57 243.74,115.72 244.07,115.72 244.53,115.27 246.74,115.27 246.81,115.19 246.81,114.25 246.53,113.97 244.45,113.97 243.64,114.78 242.47,114.78 242.37,114.68 242.37,114.22 242.24,114.1 240.95,114.1 240.82,114.22 240.82,114.61 240.64,114.78 239.5,114.78 239.35,114.63 239.35,114.43 238.89,113.97 238.41,113.97 238.33,114.05 238.33,114.43
GND on BOTTOM: 50.46,36.73 51.91,36.73 51.91,35.41 53.11,34.2 53.11,33.73 54.84,32 54.84,30.61 54.66,30.43 54.66,29.85 54.51,29.69 53.57,29.69 53.09,30.18 50.67,30.18 50.3,30.54 50.3,33.08 50.62,33.41 50.62,35.13 50.46,35.3
GND on BOTTOM: 256.82,33.89 260.25,33.89 260.52,34.17 260.91,34.17 261.14,34.4 261.14,35.41 261.84,36.11 261.84,37.96 262.35,38.48 262.35,41.78 261.85,42.27 261.81,42.27 261.02,43.06 257.25,43.06 256.16,41.97 256.16,37.02 256.8,36.39 256.8,33.92
GND on BOTTOM: 194.82,119.32 194.82,119.51 194.06,120.27 194.06,120.52 194.18,120.65 194.57,120.65 194.69,120.78 194.69,121.1 194.82,121.22 199.2,121.22 199.33,121.1 199.33,120.97 198.38,120.02 198.31,120.02 198.12,119.83 198.12,119.25 197.93,119.06 195.07,119.06
GND on BOTTOM: 91.2,5.86 91.2,4.91 91.34,4.77 91.34,4.31 91.44,4.22 91.44,2.8 91.82,2.41 91.82,1.91 91.7,1.78 91.06,1.78 90.78,2.06 90.78,3.9 90.8,3.92 90.8,5.82 90.48,6.14 89.96,6.14 89.85,6.25 89.85,6.47 89.96,6.59 90.29,6.59 90.3,6.59 90.47,6.59
GND on BOTTOM: 243.84,8 243.59,7.75 241.43,7.75 241.05,7.37 241.05,6.61 240.92,6.48 238.63,6.48 237.87,5.72 228.6,5.72 228.18,6.14 228.18,10.37 228.45,10.64 229.55,10.64 230.21,9.99 230.21,9.32 231.01,8.51 238.76,8.51 239.15,8.9 239.15,11.98 239.37,12.2 240.92,12.2 241.05,12.32 241.05,13.53 240.92,13.65 237.55,13.65 237.43,13.78 237.43,14.61 237.55,14.73 242.76,14.73 243.84,13.65
GND on BOTTOM: 258.69,2.97 258.38,3.28 258.38,4.42 259.72,5.76 262.13,5.76 263.25,4.65 263.25,3.16 263.06,2.97
GND on BOTTOM: 102.69,23.06 102.59,23.16 102.59,25.32 102.68,25.41 104.27,25.41 104.34,25.34 104.34,24.32 104.41,24.24 104.41,23.3 104.16,23.06
GND on BOTTOM: 157.48,10.05 157.27,9.85 155.65,9.85 155.14,10.36 154.26,10.36 154.13,10.49 154.13,11.02 154.23,11.13 154.66,11.13 155.12,11.58 157.27,11.58 157.48,11.38
GND on BOTTOM: 24.23,74.65 24.23,72.87 23.75,72.39 23.75,70.74 24.44,70.05 24.44,69.39 24.16,69.11 23.22,69.11 22.99,68.89 22.48,68.89 22.45,68.91 22.45,69.88 22.38,69.95 21.97,69.95 21.57,70.36 21.57,72.29 20.6,73.25 20.6,73.61 20.66,73.66 21.39,73.66 21.77,73.28 22.71,73.28 22.86,73.43 22.86,75.11 23.01,75.26 23.62,75.26
GND on BOTTOM: 35.87,17.42 35.82,17.36 32.31,17.36 32.09,17.58 32.09,20.54 32.3,20.76 32.31,20.75 35.42,20.75 35.87,20.29
GND on BOTTOM: 259.72,23.27 261.44,23.27 263.74,20.97 266.4,20.97 266.6,20.76 266.6,20.21 266.32,19.92 261.68,19.92 261.39,20.21 261.39,20.89 261.6,21.09 261.6,22.1 261.34,22.35 259.74,22.35 259.63,22.47 259.63,23.18
GND on BOTTOM: 16.84,72.09 16.23,72.09 15.88,71.73 15.88,70.36 15.5,69.98 13.21,69.98 12.83,70.36 12.83,72.62 13.36,73.15 16.79,73.15 16.97,72.98 16.97,72.21
GND on BOTTOM: 32.33,28.3 32.17,28.46 32.17,29.67 32.36,29.87 37.13,29.87 37.13,29.87 37.87,29.87 38.09,29.64 38.09,28.42 37.97,28.3
GND on BOTTOM: 29.28,25.53 29.36,25.45 30.21,25.45 30.22,25.45 30.32,25.45 30.41,25.54 30.41,28.66 30.26,28.8 29.57,28.8 29.39,28.63 29.39,27.05 29.28,26.94
GND on BOTTOM: 178.82,2.8 178.69,2.92 178.69,3.3 179.52,4.13 179.52,7.62 179.89,7.99 179.97,7.99 181.4,9.42 183.46,9.42 183.78,9.75 183.78,11.28 183.43,11.63 179.91,11.63 179.63,11.91 179.63,12.75 180.32,13.44 183.72,13.44 184.39,12.77 184.39,9.37 184.3,9.29 184.3,9.28 184.3,6.92 181.36,3.97 181.36,3.56 180.6,2.8
GND on BOTTOM: 75.99,5.26 75.85,5.26 75.68,5.09 75.24,5.09 74.67,4.53 74.67,4.24 75.08,3.84 75.46,3.84 75.57,3.94 75.57,4.12 76.1,4.65 76.1,5.14
GND on BOTTOM: 116.87,4.53 117.92,3.48 118.6,3.48 118.69,3.57 125.44,3.57 125.55,3.46 125.55,1.63 125.12,1.19 116.61,1.19 116.26,1.55 116.26,2.45 116.56,2.76 116.56,3.58 116.31,3.84 116.31,4.42 116.41,4.53
GND on BOTTOM: 244.94,106.86 245.13,106.67 245.13,104.33 245.58,103.88 245.58,101.87 245.62,101.83 245.62,101.3 245.72,101.19 246.23,101.19 246.3,101.27 246.3,101.98 245.97,102.32 245.97,102.33 245.97,103.9 246.4,104.33 246.4,105.32 245.97,105.75 245.97,106.96 246.38,107.36 246.38,108.13 246.3,108.21 244.26,108.21 244.1,108.05 244.1,107.17 244.41,106.86
GND on BOTTOM: 29.29,52.76 29.08,52.96 29.08,55.87 29.44,56.22 30.34,56.22 30.89,54.66 31.53,53.13 31.16,52.76
GND on BOTTOM: 55.5,10.44 55.6,10.34 55.6,9.69 55.44,9.53 49.1,9.53 48.97,9.65 47.63,9.65 47.37,9.91 47.37,13.46 47.45,13.54 51.37,13.54 52.51,12.4 53.09,12.4 53.21,12.52 53.21,12.85 53.29,12.93 54.56,12.93 54.64,12.85 54.64,12.31 54.76,12.18 55.38,12.18 55.5,12.05
GND on BOTTOM: 18.37,8.76 18.37,15.47 18.22,15.62 13.26,15.62 12.9,15.98 12.9,16.43 12.8,16.54 10.14,16.54 9.5,15.9 9.5,12.4 8.74,11.63 7.21,11.63 6.96,11.38 6.96,9.25 7.68,8.53 9.46,8.53 9.86,8.13 9.86,6.83 10.93,5.76 12.01,5.76 12.19,5.94 16.33,5.94 16.41,5.86 16.51,5.76 17.9,5.76 18.37,6.23 18.37,8.76
GND on BOTTOM: 44.7,37.1 46.49,37.1 46.81,36.79 46.81,33.14 46.42,32.76 44.89,32.76 44.64,33 44.56,33 44.56,36.96
GND on BOTTOM: 51.4,19.26 51.71,18.95 51.71,16.09 51.41,15.8 48.84,15.8 48.69,15.96 48.69,19.16 48.79,19.26
GND on BOTTOM: 112.1,1.95 110.69,1.95 110.57,2.07 110.57,2.95 109.86,3.66 109.86,4.45 110.01,4.6 110.5,4.6 110.83,4.93 110.83,5.98 110.85,6 110.85,6.94 110.95,7.04 111.18,7.04 111.25,6.96 111.25,6.05 111.27,6.04 111.27,4.71 111.27,4.71 111.27,3.24 112.2,2.32 112.2,2.05
GND on BOTTOM: outline of 565 points within 66.98,6.05 98.02,36.84 ; 5 cut-outs
GND on BOTTOM: 136.4,109.35 138.33,109.35 138.51,109.17 138.51,107.93 138.28,107.7 136.4,107.7 136.3,107.8 136.3,109.25
GND on GND1, GND3: outline of 362 points within 0.2,0.2 352.5,123.1 ; 1 cut-out
GND on IN1: 139.57,119.96 139.91,120.29 144.88,120.29 145.29,119.89 145.29,117.12 143.88,115.71 142.89,115.71 141.48,114.3 139.83,114.3 139.57,114.56
GND on IN1: 11.88,70.03 11.88,70.03 11.4,70.52 7.99,70.52 7.11,69.63 7.11,63.85 7.82,63.13 7.82,62.02 8.98,60.86 12.14,60.86 12.64,61.36 12.64,69.28
GND on IN2: outline of 200 points within 132.66,20.78 249.53,68
GND on IN2: outline of 168 points within 191.65,50.93 250.89,113.41
GND on GND2: outline of 362 points within 0.2,0.2 352.5,123.1 ; 2 cut-outs
GND on IN4: 206.51,22.17 205.77,22.91 205.77,25.12 204.5,26.39 202.74,26.39 202.31,26.82 198.63,26.82 198.25,27.2 184.54,27.2 184.09,27.65 174.94,27.65 172.64,29.95 162.82,29.95 160.76,32.01 123.22,32.01 122.73,32.49 122.73,40.41 134.88,52.55 134.88,66.78 136.07,67.97 154.17,67.97 154.26,67.88 156.2,67.88 156.39,68.07 159.05,68.07 159.14,68.02 159.14,67.92 159.42,67.42 159.7,67.92 159.7,68.02 159.79,68.07 160.01,68.07 160.15,67.93 160.1,67.85 160.11,67.51 160.41,67.36 161.79,65.98 161.79,64.4 162.82,63.37 162.82,61.5 163.72,60.61 163.72,58.54 169.83,52.42 170.86,52.42 171.78,52.42 175.27,48.93 202.09,48.93 204.15,46.87 212.72,46.87 227.77,31.82 227.77,27.97 227.78,27.96 227.78,26.81 226.97,26 226.97,22.77 225.92,21.73 225.92,21.2 225.9,21.18 225.9,20.88 225.67,20.65 208.03,20.65
GND on VCC: 3.72,32.39 3.75,32.42 3.75,37.42 4.11,37.78 5.69,37.78 6.29,38.38 6.29,40.69 6.33,40.73 10.72,40.71 10.82,40.71 11.33,40.2 13.44,40.2 13.76,40.51 14.9,40.51 14.95,40.57 16.2,39.32 16.2,35.99 17.61,34.58 17.61,33.18 17.45,33.02 16.67,33.81 6.78,33.81 5.36,32.39
GND on VCC: 10.02,77.11 9.91,77.22 9.76,77.26 9.76,91.61 10.14,91.87 10.25,92.31 10.87,93.37 11.59,94.36 16.11,94.36 21.72,99.98 28.83,99.98 28.83,77.11
GND on IN5: 134.34,63.63 134.45,63.63 134.49,63.67 134.53,63.67 135.38,64.52 137.16,64.52 138.18,63.5 172.41,63.5 172.41,63.49 172.9,63 172.9,62.09 182.38,52.6 182.38,39.09 173.89,30.59 173.89,24.38 173.21,23.7 173.21,21.4 172.99,21.17 170.13,21.17 169.93,20.97 146.2,20.97 146.19,20.98 143.33,20.98 142.85,20.5 131.4,20.5 130.87,21.03 108.59,21.03 108.56,21.06 107.56,21.06 107.41,21.21 106.9,21.21 106.9,21.22 106.65,21.47 106.65,27.39 107.03,27.78 107.03,30.36 107.61,30.94 107.61,33.41 119.11,44.91 119.11,47.21 124.04,52.14 124.04,52.64 131.08,59.69 131.08,60.37
GND on IN5: outline of 727 points within 194.09,53.09 243.97,110.5
GND on IN6: 8.42,68.81 8.01,69.23 8.01,72.33 8.17,72.49 10.54,72.49 10.67,72.37 10.67,71.98 10.54,71.86 10.39,71.86 9.84,71.31 9.84,69.73 10.03,69.54 10.3,69.54 10.46,69.7 10.46,70.28 10.61,70.43 10.96,70.43 11.13,70.26 11.13,69.14 10.8,68.81
GND on IN6: 12.35,63.68 8.49,63.68 7.83,63.03 7.83,61.42 8.86,60.39 12.25,60.39 12.98,61.13 12.98,63.05
GND on IN6: 16.52,40.49 16.52,37.91 17.87,36.55 17.87,34.34 18.1,34.11 19.45,34.11 20.54,35.2 20.54,36.3 20.28,36.56 20.28,40.09 20.12,40.24 20.12,41.32 19.8,41.64 17.67,41.64
VBATT on BOTTOM: 31.51,20.45 31.78,20.18 31.78,16.86 31.68,16.77 30.96,16.77 30.87,16.68 30.87,15.87 30.83,15.83 29.72,15.83 29.59,15.95 29.59,17.35 29.47,17.48 27.97,17.48 27.45,17.99 25.86,17.99 25.86,17.99 25.68,17.99 25.58,18.09 25.58,20.37 25.66,20.45
VCC0V9_LVR_OUT on TOP (solid shape): 26.33,40.3 26.33,39.97 26.28,39.89 26.19,39.88 25.98,39.9 25.81,39.79 25.73,39.76 25.66,39.79 25.18,39.81 25.18,39.33 25.18,37.53 25.02,37.36 23.16,37.36 22.98,37.18 22.98,36.23 22.96,36.21 22.22,36.21 21.79,36.64 21.79,39.92 21.84,39.96 22.47,39.96 22.52,39.92 22.52,38.41 22.51,38.4 22.65,37.99 23.07,38.05 23.14,38.08 23.21,38.05 23.62,37.99 23.77,38.37 23.76,38.4 23.94,38.57 24.31,38.57 24.52,38.79 24.52,39.69 25.34,40.51 26.12,40.51
VCC0V9_LVR_OUT on IN1: 27.18,40.36 27.18,37.75 26.26,36.83 22.73,36.83 21.82,37.75 21.82,38.74 22.42,39.33 22.42,41.06 22.84,41.48 26.06,41.48
VCC0V9_LVR_OUT on IN3, IN6: 26.21,40.53 24.96,40.53 24.53,40.1 24.53,38.75 23.75,37.97 23.75,37.46 23.88,37.33 25.32,37.33 25.76,37.77 25.76,39.69 25.85,39.79 26.19,39.79 26.33,39.93 26.33,40.41
VCC0V9_SVR on BOTTOM (solid shape): 21.67,50.28 21.67,48.18 22.63,47.22 22.63,46.61 22.73,46.51 22.73,45.71 22.57,45.54 22.27,45.54 21.78,46.04 21.75,46.06 21.73,46.09 21.36,46.46 21.02,46.46 20.98,46.49 20.98,47.42 20.65,47.75 20.65,50.23 20.77,50.34 20.77,50.36 20.83,50.42 21.53,50.42
VCC0V9_SVR on BOTTOM (solid shape): 27.17,41.3 27.17,40.85 27.09,40.77 27.06,40.78 26.93,40.75 26.83,40.66 26.61,40.66 26.45,40.83 26.3,40.83 26.18,40.7 26.18,40.69 26.13,40.64 25.99,40.64 25.83,40.79 25.64,40.79 25.58,40.85 25.58,41.3 25.65,41.36 27.11,41.36
VCC0V9_SVR on BOTTOM (solid shape): 24.5,40.66 24.55,40.62 24.63,40.53 24.63,38.38 24.44,38.18 24.42,38.18 24.32,38.15 24.24,38.08 24.23,38.06 23.99,38.06 23.96,38.09 23.93,38.13 23.88,38.16 23.88,38.35 24.02,38.49 24.02,38.7 23.83,38.9 23.83,39.03 23.65,39.2 23.65,39.31 23.79,39.6 23.62,39.86 23.62,40.15 23.78,40.32 23.8,40.32 23.85,40.33 23.9,40.35 23.97,40.41 24.01,40.5 24.01,40.52 24.05,40.55 24.07,40.55 24.23,40.57 24.36,40.66
VCC0V9_SVR on TOP: 25.3,40.61 24.42,39.73 24.42,39.71 24.42,38.91 24.2,38.69 23.98,38.69 23.79,38.88 23.79,38.91 23.76,39.05 23.68,39.17 23.64,39.25 23.68,39.33 23.76,39.71 23.42,39.9 23.4,39.9 23.15,40.15 23.16,40.17 23.07,40.44 22.8,40.54 22.65,40.54 22.51,40.4 22.51,40.22 22.45,40.17 22.06,40.17 22.01,40.22 22.01,44.04 22.06,44.09 22.63,44.09 22.84,44.3 22.84,45.33 22.64,45.53 22.23,45.53 21.53,46.23 21.53,47.85 22.51,47.85 22.58,47.78 22.58,47.08 22.8,46.87 23.31,46.87 23.75,46.43 23.75,45.44 23.95,45.24 23.95,43.92 23.12,43.09 23.12,42.04 23.13,42.03 23.13,40.91 23.32,40.57 23.71,40.66 23.78,40.69 23.86,40.66 24.1,40.54 24.42,40.68 24.5,40.65 24.88,40.55 25.1,40.87 25.1,41.04 25.18,41.12 26.84,41.12 26.95,41.01 26.95,40.75 26.82,40.61 25.32,40.61
VCC0V9_SVR on IN2: 21.51,42.28 21.48,42.31 21.48,43.17 21.18,43.47 21.18,46.14 21.51,46.47 21.51,46.48 21.62,46.59 24.85,46.59 26.95,44.5 27.5,44.5 29.63,42.36 31.13,42.36 32.19,41.31 32.19,36.37 31.64,35.82 26.32,35.82 26.3,35.8 23.74,35.8 21.51,38.03
VCC3V3_FLASH on TOP: 24.69,61.69 24.56,61.82 24.17,61.82 24,61.65 24,59.89 24.2,59.69 24.49,59.69 24.97,59.21 24.97,58.31 25.12,58.15 25.52,58.15 25.89,58.53 27.01,58.53 27.07,58.58 29.43,58.58 29.53,58.69 29.53,59.06 29.42,59.17 28.8,59.17 28.68,59.29 26.73,59.29 26.57,59.14 25.78,59.14 25.46,59.45 25.46,59.93 25.42,59.98 25.12,59.98 25.06,60.03 25.06,60.54 24.69,60.91
VCC5V0_SYS on BOTTOM: 25.53,55.37 25.53,56.21 25.49,56.26 25.49,56.92 25.52,56.94 25.53,56.94 25.58,57 26.8,57 26.8,57.15 26.93,57.28 29.33,57.28 29.43,57.18 29.43,56.51 28.83,55.91 28.83,52.81 28.68,52.66 28.2,52.66 28.13,52.73 28.13,53.08 27.98,53.23 27.57,53.23 27.46,53.12 26.08,53.12 26.04,53.16 26.04,54.87
VCCGT_B+ on BOTTOM (solid shape): 107.7,86.36 107.7,84.39 107.39,84.09 107.39,80.74 107.39,80.73 107.05,80.73 106.98,80.66 106.98,79.24 107.33,78.88 107.33,78.15 107.15,77.97 107.15,76.62 106.62,76.09 106.62,73.28 106.13,72.8 106.13,71.73 106.14,71.73 106.14,71.61 106.49,71.26 106.86,71.26 107.88,70.23 109.36,70.23 109.52,70.07 109.52,68.99 109.38,68.85 106.13,68.85 105.94,69.04 105.94,69.99 105.95,69.99 105.95,71.24 105.79,71.4 105.79,72.65 105.16,73.28 105.16,76.14 105.23,76.22 105.23,77.8 105.5,78.07 106.35,78.07 106.58,78.3 106.58,80.6 106.45,80.73 106.27,80.73 106.27,80.73 105.93,80.73 105.92,80.74 105.92,86.34 105.98,86.38 106.02,86.42 106.06,86.49 107.57,86.49
VCCGT_B+ on IN3 (solid shape): 107.67,86.36 107.67,84.1 107.38,83.81 107.38,80.76 107.06,80.76 106.98,80.68 106.98,78.92 107.23,78.68 107.75,78.68 107.87,78.55 107.87,78.26 107.09,77.47 107.09,76.51 106.67,76.09 106.67,73.01 106.02,72.37 106.02,71.72 106.48,71.26 106.81,71.26 107.65,70.41 108.71,70.41 108.99,70.13 108.99,69.5 108.46,68.96 106.27,68.96 105.64,69.6 105.64,71.48 105.74,71.58 105.74,72.33 105.08,72.99 105.08,77.62 106.58,79.12 106.58,80.61 106.45,80.74 105.92,80.74 105.92,86.41 106.02,86.51 107.52,86.51
VCCGT_B+ on TOP: 105.14,69.71 104.63,70.23 104.62,70.23 103.89,70.97 103.56,70.97 103.32,71.21 103.32,72.22 103.37,72.31 103.47,72.3 103.96,72.34 103.96,72.82 103.93,72.85 103.89,72.93 103.93,73.01 103.96,73.04 103.96,73.52 103.47,73.56 103.37,73.55 103.32,73.64 103.32,75.25 103.36,75.33 103.46,75.34 103.99,75.65 103.46,75.96 103.36,75.97 103.32,76.06 103.32,86.49 103.76,86.93 107.37,86.93 107.7,86.6 107.7,83.95 107.37,83.62 107.37,79.06 107.63,78.8 107.63,77.97 107.13,77.47 107.13,76.4 106.62,75.88 106.62,73.17 106.62,73.17 106.62,73.13 106.91,72.84 106.95,72.84 108,72.84 108,72.84 109.86,72.84 110.43,72.26 110.43,70.13 110.01,69.71
VCCGT_B+ on IN4: 107.52,86.51 107.67,86.36 107.67,84.1 107.38,83.81 107.38,80.67 107.37,80.66 107.37,79.06 107.87,78.55 107.87,78.26 107.09,77.47 107.09,76.51 106.67,76.09 106.67,73.01 106.68,73 106.68,71.4 107.67,70.41 108.71,70.41 108.99,70.13 108.99,69.5 108.46,68.96 106.27,68.96 105.08,70.16 105.08,77.62 105.77,78.31 105.77,86.44 105.84,86.51
VCCGT_B+ on IN6: 107.67,84.1 107.38,83.81 107.38,79.02 107.72,78.68 107.75,78.68 107.87,78.55 107.87,78.26 107.09,77.47 107.09,76.51 106.67,76.09 106.67,71.41 107.67,70.41 108.71,70.41 108.99,70.13 108.99,69.5 108.46,68.96 105.89,68.96 103.89,70.97 103.56,70.97 103.3,71.22 103.3,86.46 103.76,86.92 107.37,86.92 107.67,86.62
VDDQ_DDR on IN6 (solid shape): outline of 3717 points within 148.85,62.1 174.5,68.71
VDDQ_DDR on TOP: outline of 439 points within 132.08,51.06 180.29,68.99
VDDQ_DDR on IN4: 160.42,68.02 160.95,68.02 161.17,67.8 171.6,67.8 171.93,67.47 173.25,67.47 174.09,66.63 174.09,63.13 173.78,62.82 164.21,62.82 162.62,64.4 162.62,64.41 162.2,64.83 162.2,66.01 160.84,67.38 160.2,67.38 160.06,67.52 160.06,67.66
3S_BATT+ on BOTTOM: 28.09,20.84 27.58,21.34 27.58,22.73 27.48,22.83 26.38,22.83 26.26,22.94 26.26,25.25 26.28,25.26 26.28,25.95 26.52,26.19 27.38,26.19 27.54,26.35 29.02,26.35 29.08,26.29 29.08,25.45 29.36,25.17 29.36,24.72 29.31,24.66 28.6,24.66 28.42,24.49 28.42,24.05 28.6,23.88 29.34,23.88 29.99,23.23 29.99,20.94 29.89,20.84
+1.8ALWP on BOTTOM (solid shape): 245.54,99.54 246.99,99.54 247.3,99.85 248.18,99.85 248.29,99.75 248.29,95.2 248.12,95.04 246.9,95.04 246.64,95.3 246.64,96.81 246.33,97.12 245.45,97.12 245.43,97.1 245.43,96.58 245.42,96.57 244.98,96.57 244.97,96.58 244.97,97.11 244.96,97.12 244.24,97.12 244.23,97.11 244.23,96.58 244.22,96.57 243.78,96.57 243.77,96.58 243.77,97.11 243.77,97.12 243.04,97.12 242.77,97.38 242.77,99.82 242.93,99.98 245.11,99.98
+AC_IN on TOP: 25.49,29.48 25.53,29.44 25.53,28.96 25.48,28.91 25.02,28.91 24.97,28.86 24.97,28.2 24.99,28.17 25.48,28.17 25.53,28.12 25.53,27.71 25.5,27.69 25.05,27.69 24.97,27.61 24.97,27 25.02,26.95 25.45,26.95 25.5,26.9 25.5,26.34 25.68,26.16 27.76,26.16 27.86,26.06 27.86,25.17 26.98,24.28 26.98,23.65 26.59,23.27 24.04,23.27 23.6,23.7 22.68,23.7 22.53,23.85 22.53,25.84 22.29,26.07 22.29,28.67 22.37,28.75 23.29,28.75 24.03,29.48
+AC_IN on BOTTOM: 20.96,28.7 21.74,28.7 22.2,28.24 24.14,28.24 24.26,28.13 24.26,26.11 23.99,25.84 22.34,25.84 22.24,25.94 22.24,26 22.12,26.12 22.12,26.28 21.6,26.8 20.96,26.8 20.7,27.05 20.7,28.45
+AC_IN on IN3: 21.15,27.77 29.3,27.77 29.77,27.3 29.77,25.81 29.31,25.34 21.3,25.34 20.82,25.83 20.82,27.44
+CHG_SRC_20V on TOP (solid shape): 49.1,6.3 51.55,6.3 51.77,6.08 51.77,1.66 51.51,1.4 44.83,1.4 44.48,1.74 44.22,1.74 44.2,1.76 44.2,6.4 44.28,6.48 48.93,6.48
+CHG_SRC_20V on BOTTOM: 51.7,1.92 51.18,1.4 50.42,1.4 50.17,1.65 44.81,1.65 44.07,2.4 44.07,6.99 44.15,7.06 49.1,7.06 49.58,7.54 49.58,9.04 49.73,9.2 55.42,9.2 55.58,9.04 55.58,8.38 55.52,8.33 53.67,8.33 53.56,8.21 52.58,7.24 52.58,7.24 52.45,7.24 52.07,6.86 52.07,3.18 52.09,3.16 51.7,2.77
+DC_IN on BOTTOM: 26.85,78.9 26.85,78.89 26.09,78.12 25.07,78.12 23.69,79.5 17.25,79.5 16.92,79.83 16.92,83.61 17.08,83.77 25.32,83.77 25.74,83.36 27.07,83.36 27.71,82.72 27.71,79.76
+DC_IN on BOTTOM: 15.78,28.7 15.78,28.04 15.69,27.96 13.47,27.96 12.36,27.96 12.16,28.16 12.16,30.36 12.17,30.38 12.17,30.59 12.28,30.69 12.98,30.69 13.06,30.77 13.06,31.02 13.22,31.18 13.86,31.18 13.87,31.19 14.06,31.19 14.34,30.91 15.52,30.91 15.55,30.89 15.55,28.94
+DC_IN on IN1: 14.82,30.93 14.82,28.55 14.72,28.45 12.38,28.45 12.12,28.71 12.12,30.92 12.6,31.4 14.35,31.4
+DC_IN on IN4: 27.67,82.86 27.67,61.3 27.67,61.3 27.67,57.11 28.9,55.88 28.9,53.54 30.01,52.42 30.01,50.96 31.52,49.45 31.52,43.77 33.05,42.24 33.05,33.09 32.26,32.3 23.5,32.3 22.67,31.47 22.67,29.01 27.61,24.07 27.61,18.31 27.15,17.86 24.41,17.86 23.93,17.37 23.93,15.14 23.56,14.77 5.11,14.77 4.34,15.54 4.3,15.54 2.97,16.87 2.97,31.37 3.78,32.19 3.78,35.63 4.5,36.35 10.84,36.35 11.07,36.58 11.07,39.94 11.31,40.18 13.9,40.18 13.9,40.19 14.66,40.19 15.41,40.94 15.41,44.92 16.02,45.54 16.02,50.07 15.67,50.42 15.67,58.9 14.64,59.93 13.68,59.93 13.11,60.5 13.11,68.99 12.53,69.57 12.53,74.57 15.88,77.92 16.76,77.92 21.95,83.11 27.42,83.11
+DC_IN_SS on TOP: 14.25,27.36 14.76,27.36 14.86,27.26 14.86,26.81 14.78,26.73 14.22,26.73 14.19,26.7 14.19,26.18 13.98,25.96 13.98,25.83 13.98,25.82 13.98,25.16 13.87,25.04 12.86,25.04 12.76,25.13 12.76,25.96 12.74,25.99 11.34,25.99 11.22,26.11 11.22,26.46 11.74,26.98 13.87,26.98
+DC_IN_SS on BOTTOM: 9.29,21.26 9.15,21.41 9.15,24.45 8.83,24.77 8.83,25.47 9.21,25.85 10.58,26.21 11.68,27.09 13.39,27.09 13.83,27.52 16.42,27.52 16.62,27.32 16.62,25.19 16.95,24.86 16.95,23.27 15.64,23.27 15.38,23.01 12.87,23.01 12.19,22.34 12.19,21.51 11.94,21.26
+EDPVDD on TOP: 57.66,34.82 58.45,34.82 59.23,34.04 59.23,32.82 57.79,31.37 56.9,31.37 55.63,30.1 54.87,30.1 54.74,29.97 54.74,28.2 54.23,27.69 51.82,27.69 51.56,27.94 51.56,30.61 51.69,30.74 51.94,30.74 52.2,30.99 52.2,32.01 54.1,33.91 56.74,33.91 56.99,34.15 57.02,34.14 57.4,34.22 57.48,34.6 57.47,34.63
+EDPVDD on BOTTOM: 57.53,36.73 58.93,36.73 58.93,35.31 59.18,35.05 59.18,34.42 58.93,34.16 57.66,34.16 57.53,34.29
+FB_PLLAVDD on TOP (solid shape): 191.96,85.83 192.81,85.83 192.95,85.69 192.95,84.68 191.73,83.46 191.39,83.46 191.2,83.65 191.2,84.39 190.75,84.84 190.75,85.71 190.88,85.83 191.96,85.83
+FB_PLLAVDD on IN1 (solid shape): outline of 650 points within 212.68,71.63 217,79.76
+FB_PLLAVDD on IN6: outline of 164 points within 191.39,77.55 215.98,84.71
+GPCPLL_AVDD on TOP: 215.35,76.78 215.51,76.94 215.51,77.48 215.74,77.71 216.35,77.71 216.59,77.96 216.59,79.29 217.05,79.29 217.05,78.92 217.55,78.42 220.57,78.42 220.98,78.83 220.98,81.52 220.37,82.13 217.83,82.13 216.95,81.24 216.95,80.6 216.69,80.34 216,80.34 215.96,80.31 215.89,80.31 215.45,79.87 215.45,78.79 214.39,77.73 214.39,76.92 214.53,76.78
+GPCPLL_AVDD on IN2: 213.44,81.2 213.15,80.91 213.15,80.56 213.76,79.95 213.76,78.84 214.14,78.46 215.7,78.46 216.33,79.09 216.33,81.13 214.78,82.68 213.67,82.68 213.44,82.45
+GPU_CORE on TOP (solid shape): 184.41,109.78 184.41,107.47 184.73,107.14 184.73,105.28 185.14,104.87 185.14,101.32 184.21,100.39 184.21,98.87 184.41,98.68 187.3,98.68 187.61,98.15 187.91,98.69 188.34,99.12 188.34,100.71 188.6,100.97 189.61,100.97 189.8,100.78 189.8,95.57 188.34,94.11 184.11,94.11 183.94,93.94 181.14,93.94 180.47,94.61 180.47,110.64 180.57,110.74 180.57,111.34 180.76,111.53 182.65,111.53
+GPU_CORE on BOTTOM (solid shape): 184.39,110.58 184.39,108.91 184.82,108.48 184.82,103.83 185.09,103.56 187.05,103.56 187.24,103.36 187.24,102.05 187.19,101.99 184.54,101.99 184.34,101.79 184.34,97.4 184.44,97.3 187.1,97.3 187.28,97.13 187.28,94.37 187.05,94.14 184.22,94.14 183.92,93.84 179.76,93.84 179.61,93.98 179.61,96.34 180.47,97.2 180.47,110.4 181.33,111.26 183.71,111.26
+GPU_CORE on BOTTOM (solid shape): outline of 3920 points within 201.34,54.34 215.59,78.63
+GPU_CORE on TOP: 203.2,77.22 203.66,77.22 204.04,77.6 204.78,77.6 205,77.83 205,78.49 204.9,78.59 203.86,78.59 203.05,77.78 203.05,77.37
+GPU_CORE on TOP: outline of 246 points within 202.24,60.33 216.22,78.68 ; 1 cut-out
+GPU_CORE on IN1: 182.77,93.49 181.17,93.49 176.95,97.71 176.95,108.73 178.18,109.96 184.23,109.96 184.86,109.33 184.86,106.36 185.16,106.05 185.16,104.07 185.34,103.89 185.72,103.89 186.15,103.46 186.15,98.38 188.02,96.51 188.02,94.12 187.87,93.97 183.25,93.97
+GPU_CORE on IN2: outline of 92 points within 175.42,93.73 192.42,111.97
+GPU_CORE on GND2: 191.37,54.1 189.49,55.99 189.49,57.76 187.05,60.2 180.7,60.2 179.45,61.45 179.45,64.75 178.18,66.02 178.18,89.64 173.48,94.34 173.48,116.35 173.97,116.84 182.48,116.84 184.38,118.75 192.68,118.75 193.82,117.6 202.59,117.6 203.71,116.48 203.71,97.37 210.02,91.06 222.21,91.06 226.89,86.38 226.89,54.14 226.84,54.1
+GPU_CORE on IN4: outline of 134 points within 177.3,58.27 226.94,111.25
+GPU_CORE on VCC: 176.13,53.6 175.52,54.21 175.52,85.2 173.48,87.23 173.48,93.96 172.25,95.19 168.76,95.19 167.2,96.75 167.2,105.62 167.37,105.79 169.31,105.79 170.82,107.3 170.82,108.88 171.28,109.35 194.74,109.35 195.62,108.46 203.48,108.46 203.71,108.23 203.71,97.69 220.6,80.79 220.6,54.08 220.11,53.6
+GPU_CORE on IN5: 196.32,52.96 192.84,56.43 192.84,63.7 190.99,65.56 183.43,65.56 181.49,67.5 181.49,84.13 180.15,85.47 180.15,85.59 180.16,85.6 180.2,85.76 180.16,85.92 180.15,85.94 180.15,86.38 180.16,86.39 180.2,86.55 180.16,86.71 180.15,86.72 180.15,93.66 179.66,94.15 179.66,109.09 179.86,109.28 185.23,109.28 186.06,108.45 192.98,108.45 193.65,107.77 193.65,81.56 194.39,80.82 200.84,80.82 202.01,79.66 214.91,79.66 215.67,78.89 215.67,66.78 215.22,66.32 212.24,66.32 208.92,62.99 208.92,55.25 206.63,52.96
+GPU_CORE_VDDS on TOP (solid shape): 206.41,76.6 206.57,76.6 206.69,76.49 206.69,76.1 206.52,75.93 205.24,75.93 205.08,76.1 205.08,77.33 205.19,77.45 205.57,77.45
+GPU_CORE_VDDS on TOP (solid shape): 211.54,68.36 211.54,67.22 211.43,67.11 211.11,67.11 210.19,68.03 210.19,68.39 210.31,68.51 211.39,68.51
+GPU_CORE_VDDS on TOP (solid shape): 204.58,75.34 204.58,74.7 204.84,74.44 204.84,74.05 204.77,73.98 204.3,73.98 203.15,75.13 203.15,75.46 203.23,75.53 204.39,75.53
+GPU_CORE_VDDS on TOP (solid shape): 209.24,73.01 209.24,72.21 209.55,71.89 209.55,71.08 209.55,71.08 209.55,70.96 209.5,70.91 208.74,70.91 208.71,70.93 208.71,71.59 208.11,72.19 208.11,72.55 208.66,73.09 209.16,73.09
+GPU_CORE_VDDS on TOP (solid shape): 211.53,77.52 211.91,77.15 211.91,76.08 211.83,76.01 210.2,76.01 210.09,76.11 210.09,76.47 210.2,76.58 210.71,76.58 211.1,76.97 211.1,77.39 211.22,77.51 211.24,77.51 211.25,77.52 211.53,77.52
+GPU_CORE_VDDS on TOP (solid shape): 204.66,70.45 204.66,70.06 204.24,69.64 204.24,69.37 203.77,68.9 203.26,68.9 203.14,69.03 203.14,69.22 203.49,69.57 203.49,70.03 203.55,70.08 203.77,70.08 204.28,70.59 204.52,70.59
+GPU_CORE_VDDS on TOP (solid shape): 213.82,75.6 213.82,75.16 213.16,74.49 213.1,74.49 213.09,74.5 212.99,74.5 212.55,74.06 212.1,74.06 211.9,74.25 211.9,74.6 211.99,74.68 212.19,74.68 212.46,74.95 212.46,75.66 212.63,75.83 213.6,75.83
+GPU_CORE_VDDS on TOP (solid shape): 212.37,70.56 212.37,70.31 212.41,70.31 212.41,70.23 212.58,70.06 212.87,70.06 212.87,70.06 212.96,70.06 213.62,69.41 213.62,69.15 213.49,69.03 213.3,69.03 213.04,69.28 212.72,69.28 211.9,70.1 211.9,70.38 211.91,70.39 211.92,70.43 211.94,70.47 211.96,70.5 211.96,70.55 212.03,70.62 212.32,70.62
+GPU_CORE_VDDS on IN1 (solid shape): 198.67,104.23 198.67,103.35 198.07,102.76 198.07,98.46 196.53,96.91 190.71,96.91 190.52,97.11 190.52,102 191.14,102.62 191.14,104.27 191.51,104.64 196.59,104.64 196.6,104.65 198.25,104.65
+GPU_CORE_VDDS on IN2 (solid shape): 194.87,104.69 198.22,104.69 198.54,104.36 198.54,102.94 197.68,102.07 197.68,98.2 196.7,97.23 192.86,97.23 192.71,97.07 192.61,97.07 192.55,97.12 192.55,103.22 193.57,104.24 194.01,104.69
+GPU_CORE_VDDS on TOP: 190.09,94.2 189.99,94.3 189.99,96.51 190.56,97.08 190.56,100.65 190.76,100.84 192.72,100.84 192.91,101.03 192.98,101.03 192.98,101.09 193.04,101.16 193.04,104.53 192.87,104.7 192.87,105.72 193.07,105.92 196.83,105.92 197.15,105.6 198.32,105.6 198.38,105.55 198.38,102.62 198.06,102.3 198.06,98.45 194.41,94.8 191.41,94.8 190.82,94.2
+GPU_CORE_VDDS on BOTTOM: 190.3,92.33 190.01,92.62 190.01,96.38 190.37,96.74 190.37,97.87 190.69,98.19 192.06,98.19 192.34,98.47 192.34,103 193.61,104.27 193.62,104.27 193.82,104.47 197.97,104.47 198,104.44 198.16,104.44 198.48,104.12 198.48,97.9 198.12,97.54 197.23,97.54 196.88,97.18 196.88,92.61 196.6,92.33
+GPU_CORE_VDDS on IN2: outline of 113 points within 202.76,66.68 214.12,78.8
+GPU_CORE_VDDS on IN3: outline of 337 points within 181.58,61.85 214.47,104.57
+GPU_CORE_VDDS on IN6: outline of 371 points within 182.1,62.1 214.56,104.65 ; 2 cut-outs
+INV_PWR_SRC on TOP: 45.09,31.24 44.83,31.5 44.83,35.21 44.95,35.33 45.55,35.33 45.84,35.62 45.84,36.21 46.51,36.88 47.32,36.88 47.62,36.58 50.25,36.58 50.56,36.27 50.56,35.18 50.04,34.66 50.04,32.71 49.34,32.01 48.52,32.01 47.75,31.24
+INV_PWR_SRC on BOTTOM: 48.39,34.55 47.63,35.31 47.63,36.7 47.89,36.97 48.64,36.84 49.4,36.76 49.4,35.82 49.79,35.43 49.79,34.8 49.53,34.55
+NVVDDS_B+ on TOP (solid shape): 196.45,108.9 198.19,108.9 198.5,109.21 200.37,109.21 200.81,108.77 200.81,106.1 200.53,105.82 197.23,105.82 196.23,106.81 196.23,107.6 196.13,107.7 195.39,107.7 195.22,107.87 195.22,109.42 195.24,109.44 195.91,109.44
+NVVDDS_B+ on BOTTOM (solid shape): 200.79,109.21 200.79,106.15 199.44,104.8 193.75,104.8 193.63,104.93 193.63,109.2 193.77,109.34 200.65,109.34
+ODR_PWR on TOP (solid shape): 329.5,51.37 330.88,51.37 331.07,51.18 331.07,50.27 330.9,50.1 327.01,50.1 326.96,50.15 326.96,50.55 326.96,50.55 326.96,51.35 327.25,51.64 329.24,51.64
+ODR_PWR on IN3 (solid shape): 329.31,51.06 329.31,50.24 329.19,50.12 326.95,50.12 326.9,50.17 326.9,50.41 326.9,50.41 326.9,50.99 327.34,51.44 328.93,51.44
+ODR_PWR on IN3: 334.2,40.38 334.62,40.8 337.26,40.8 337.63,40.43 337.63,36.97 337.43,36.77 335.75,36.77 334.2,38.32
+PECI_VREF on TOP: 302.62,26.64 301.82,26.64 301.72,26.54 301.72,26 301.81,25.91 302.15,25.91 302.41,25.65 302.41,25.06 302.21,24.86 302.21,24.32 302.32,24.21 302.76,24.21 303.5,24.95 303.59,24.95 303.72,25.08 303.72,25.65 303.59,25.78 303.03,25.78 302.83,25.97 302.83,26.43
+PEX_PLL_HVDD on TOP: 198.63,66.32 198.63,66.87 198.69,66.93 199.21,66.93 199.39,67.11 199.39,67.25 199.74,67.59 200.11,67.59 200.22,67.48 200.22,67.01 200.09,66.88 199.85,66.88 199.61,66.64 199.61,65.46 198.93,64.78 198.8,64.78 198.31,65.27 198.31,65.99
+PWR_SRC_AC on BOTTOM: 56.79,9.67 56.82,9.63 56.82,9 57.01,8.82 57.29,8.82 57.51,9.04 57.51,9.64 57.54,9.67 58.69,9.67 58.8,9.55 58.8,8.64 59.31,8.13 59.31,5.4 58.6,4.69 57.2,4.69 56.45,3.94 54.31,3.94 54.23,4.01 54.23,6.76 54.28,6.81 55.26,6.81 55.84,7.39 55.84,9.25 55.85,9.25 55.85,9.49 56.02,9.67
+RTC_CELL_VBAT on TOP: 284.48,14.31 283.61,14.31 283.61,15.86 283.86,16.11 285.12,16.11 285.69,15.53 287.75,15.53 287.89,15.66 287.89,16.47 287.81,16.54 287.15,16.54 286.89,16.29 286.5,16.29 285.5,17.29 282.74,17.29 282.47,17.01 282.47,12.35 282.69,12.13 284.63,12.13 284.81,12.31 284.81,13.06 284.61,13.27 284.61,14.19
+RTCVCC on IN2: 65.22,7.63 69.34,7.63 70.52,6.45 73.8,6.45 74.44,5.8 74.44,5.36 74.07,4.99 69.83,4.99 68.51,6.32 65.24,6.32 65.02,6.54 65.02,7.43
+RTCVCC_R on TOP: 280.93,7.44 279.32,7.44 279.15,7.27 279.15,4.29 279.25,4.19 280.93,4.19 281.18,4.45 281.18,5.65 281.05,5.78 281.05,7.32
+RTCVCC_R on IN4: 81.6,1.53 82.3,2.22 83.19,2.22 83.63,1.78 84.2,1.78 84.27,1.84 84.71,1.84 84.96,1.59 84.96,1.27 84.77,1.08 83.5,1.08 83.44,1.02 82.42,1.02 82.3,1.14 81.73,1.14 81.6,1.27
+SD_VDD2 on TOP (solid shape): 350.69,48.22 351.83,48.22 352.03,48.01 352.03,47.44 351.84,47.25 349.63,47.25 349.38,47.5 349.38,48.52 349.51,48.64 350.27,48.64
+SD_VDD2 on IN6 (solid shape): 350.58,44.62 350.58,42.99 350.45,42.86 349.44,42.86 349.15,43.15 349.15,43.39 349.46,43.7 349.46,44.14 349.61,44.3 349.61,44.38 349.61,44.45 349.64,44.48 349.64,44.48 349.86,44.7 350.5,44.7
+SD_VDD2 on BOTTOM: 349.45,47.43 349.41,47.47 349.41,48.52 349.63,48.74 350.39,48.74 350.55,48.59 350.55,45.34 350.62,45.26 350.62,43.95 350.32,43.65 349.87,43.65 349.71,43.8 349.71,44.63 349.85,44.76 349.85,45.83 349.45,46.22
+SDC_IN on BOTTOM (solid shape): 59.83,12.19 59.83,10.8 59.83,10.77 59.71,10.65 59.42,10.65 58.8,10.03 58.24,10.03 58.14,10.13 58.14,10.29 57.79,10.65 57.55,10.65 57.53,10.67 57.53,11.19 57.53,11.25 57.52,11.29 57.51,11.33 57.48,11.38 57.47,11.41 57.44,11.44 57.42,11.47 57.39,11.5 57.36,11.52 57.31,11.54 57.27,11.56 57.23,11.57 57.17,11.58 57.12,11.58 57.07,11.57 57.02,11.56 56.97,11.53 56.93,11.51 56.88,11.47 56.85,11.44 56.82,11.39 56.8,11.34 56.79,11.3 56.78,11.26 56.77,11.22 56.78,10.91 56.78,10.65 56.46,10.33 55.94,10.33 55.65,10.63 55.65,12.21 55.7,12.27 56.04,12.27 56.09,12.22 58.09,12.22 58.15,12.27 58.16,12.27 58.29,12.4 59.63,12.4
+SDC_IN on TOP: 14.91,20.5 14.91,21.19 15.37,21.64 16.64,21.64 16.99,21.29 17.58,21.29 18.01,21.72 19.21,21.72 19.42,21.51 20.91,21.51 21,21.42 21,20.66 20.67,20.33 20.12,20.33 20,20.21 20,19.82 19.94,19.76 19.03,19.76 18.47,19.2 17.18,19.2 17.05,19.33 17.05,20.47 16.63,20.89 15.91,20.89 15.63,20.6 15.63,18.71 15.51,18.6 10.57,18.6 10.26,18.91 10.26,20.55 10.8,21.08 11.3,21.08 11.32,21.07 11.82,21.07 12.04,20.85 12.73,20.85 13.26,20.32 14.73,20.32
+SDC_IN on TOP: 56.64,12.45 56.9,12.7 56.9,14.61 57.02,14.73 58.17,14.73 58.29,14.61 58.29,12.96 58.68,12.57 59.56,12.57 59.82,12.32 59.82,10.8 59.67,10.65 59.26,10.65 58.72,10.1 58.69,10.07 58.23,10.07 57.77,10.54 55.75,10.54 55.6,10.69 55.6,12.37 55.68,12.45
+SDC_IN on BOTTOM: 25.81,21.77 25.81,22.51 25.64,22.67 24.13,22.67 24.13,22.67 23.92,22.67 23.8,22.54 23.8,21.79 23.67,21.67 22.99,21.67 22.57,21.24 22.08,21.24 22.07,21.25 22.01,21.25 21.93,21.32 21.93,22.47 21.87,22.53 13.42,22.53 13.31,22.42 13.31,21.72 12.5,20.91 10.19,20.91 9.88,20.6 9.88,17.37 10.57,16.69 23.42,16.69 23.85,17.12 23.85,17.81 24.11,18.06 25.1,18.06 25.38,18.34 25.38,21.34
+SDC_IN on VCC: 20.07,8.51 11.37,17.21 11.37,21.23 17.21,27.06 17.24,27.06 19.97,24.34 32.45,24.34 32.45,21.92 33.6,20.77 39.97,20.77 41.04,19.7 60.35,19.7 60.71,19.34 60.71,18.53 60.75,18.49 60.75,10.77 58.49,8.51
+SP_PLLVDD on TOP: 203.57,62.59 203.7,62.72 203.7,64.2 203.06,64.84 201.78,64.84 201.2,64.27 201.17,64.27 200.51,63.61 200.51,63.61 200.51,63.25 200.64,63.12 202.37,63.12 202.5,63 202.5,62.69 202.59,62.59
+TBTA_VBUS_1 on TOP: 25.65,26.52 25.65,27.08 25.63,27.1 25.11,27.1 25.1,27.11 25.1,27.55 25.12,27.57 25.65,27.57 25.66,27.58 25.66,27.91 25.65,27.92 25.65,28.28 25.63,28.3 25.11,28.3 25.11,28.31 25.11,28.75 25.12,28.76 25.65,28.76 25.66,28.77 25.66,29.42 26.71,30.48 29.97,30.48 30.1,30.35 30.1,27.31 30,27.2 28.91,27.2 28.65,26.95 28.65,26.65 28.53,26.52
+TBTA_VBUS_1 on BOTTOM: 25.07,29.21 25.6,29.21 26.22,29.82 28.9,29.82 29.22,29.5 29.22,27.14 28.59,26.5 27.09,26.5 27,26.42 24.87,26.42 24.84,26.45 24.84,28.98
+TBTA_VBUS_1 on IN4: 28.93,26.52 28.75,26.35 27.14,26.35 25.98,27.51 25.98,29.54 26.12,29.68 28.78,29.68 28.93,29.54
+VDISPLAY_VCC on IN4 (solid shape): 14.62,91.02 14.62,90.39 14.4,90.16 13.92,90.16 13.44,89.68 11.85,89.68 11.82,89.68 11.26,89.13 11.26,88.33 10.94,88 10.3,88 10.18,88.13 10.18,89.12 11.57,90.52 12.46,90.52 13.2,91.26 14.38,91.26
+VDISPLAY_VCC on TOP: 13.8,91.07 13.8,90.26 14.04,90.03 16.87,90.03 17.22,90.38 17.22,91.27 16.89,91.6 14.34,91.6
+VDISPLAY_VCC on IN3: 13.72,91.21 14.25,91.21 14.38,91.08 14.38,90.34 14.23,90.19 14.11,90.19 13.62,89.69 11.84,89.69 11.08,88.93 11.08,88.19 10.9,88.01 10.26,88.01 10.16,88.11 10.16,89.18 11.43,90.45 12.96,90.45
+VGA_B+ on TOP (solid shape): 166.42,109.23 169.17,109.23 169.34,109.07 169.34,103.95 169.41,103.89 170.41,103.89 170.62,103.69 170.62,103.14 170.43,102.95 168.41,102.95 168.41,102.95 167.21,102.95 167.2,102.93 167.04,102.93 166.85,102.74 166.85,101.7 167.01,101.55 167.01,101.35 166.83,101.17 166.19,101.17 165.49,101.87 165.49,105.66 165.14,106.02 165.14,109.15 165.27,109.29 166.36,109.29
+VGA_B+ on BOTTOM: 168.02,111.99 172.39,111.99 172.41,111.97 172.41,106.82 171.65,106.07 171.65,101.32 171.37,101.04 165.74,101.04 165.73,101.05 164.92,101.05 164.7,101.27 164.7,102.03 165.07,102.41 165.07,103.99 165.51,104.43 165.51,107.2 165.14,107.57 165.14,109.12 165.27,109.26 165.8,109.26 165.88,109.17 167.67,109.17 167.9,109.4 167.9,111.86
+VLDOIN_1.2V on BOTTOM (solid shape): 285.31,30.67 287.2,30.67 287.29,30.58 287.29,30.46 287.25,30.42 286.07,30.42 286.07,30.42 283.97,30.42 283.97,30.83 283.4,30.83 283.4,31.02 283.94,31.02 283.94,31.02 283.97,31.02 283.97,31.43 284.04,31.5 284.48,31.5
+XS_PLLVDD on TOP: 203.82,62.47 203.79,62.51 203.78,62.51 203.78,64.38 203.19,64.96 203.19,65.48 203.34,65.63 204.43,65.63 204.82,65.24 204.82,64.5 205.28,64.04 205.28,62.65 205.1,62.47
B+ on TOP (solid shape): 109.35,69.19 109.35,67.25 109.09,66.99 104.08,66.99 103.95,67.12 103.95,69.29 104.1,69.44 109.09,69.44
B+ on TOP (solid shape): 164.82,110.85 164.82,110.36 164.82,110.35 164.82,106.21 164.82,106.21 164.82,106.1 164.75,106.03 163.39,106.03 163.07,106.35 162.8,106.35 162.79,106.35 162.67,106.35 162.52,106.5 162.52,107.6 161.78,108.34 161.78,109.84 162.92,110.97 164.69,110.97
B+ on BOTTOM (solid shape): 106.2,57.53 106.2,56.08 106.08,55.97 103.65,55.97 103.51,56.11 103.51,57.07 103.63,57.2 104.5,57.2 104.93,57.63 106.1,57.63
B+ on BOTTOM (solid shape): 105.41,69.22 105.41,68.82 105.82,68.41 109.48,68.41 109.52,68.37 109.52,67.01 109.44,66.93 104.01,66.93 103.82,67.12 103.82,69.19 104.16,69.52 105.11,69.52
B+ on BOTTOM (solid shape): 110.91,101.25 111.02,101.19 111.14,101.18 111.38,100.94 111.38,99.59 110.87,99.09 110.28,99.09 110.24,99.13 110.24,99.62 109.53,99.62 109.53,99.24 109.04,99.24 109.04,99.62 108.33,99.62 108.33,99.13 108.31,99.1 107.48,99.1 106.3,97.92 106.3,97.8 106.21,97.71 104.89,97.71 104.78,97.83 104.78,100.5 105.53,101.25
B+ on BOTTOM (solid shape): 281.69,33.72 283.19,33.72 283.41,33.5 283.41,32.85 283.13,32.57 282.52,32.57 281.93,31.99 281.93,31.06 280.85,29.98 280.85,29.51 280.59,29.25 280.59,28.2 279.98,27.59 279.98,26.52 279.9,26.44 278.89,26.44 278.8,26.53 278.8,28.67 279.39,29.26 279.39,30.45 279.38,30.45 278.84,30.45 278.83,30.9 278.84,30.91 279.37,30.91 279.38,30.92 279.38,31.64 279.37,31.65 278.82,31.65 278.82,32.1 278.84,32.12 279.33,32.12 279.37,32.16 279.37,33.57 279.54,33.74 281.67,33.74
B+ on IN6 (solid shape): 254.53,23.06 254.53,21.51 254.33,21.31 253.35,21.31 253.25,21.41 253.25,23 253.49,23.24 254.36,23.24
B+ on IN6 (solid shape): 280.04,26.8 280.04,25.73 279.73,25.43 278.05,25.43 277.72,25.76 277.72,26.03 277.95,26.26 278.44,26.26 278.53,26.36 278.53,27.01 278.74,27.23 279.61,27.23
B+ on TOP: 37.67,25.49 37.67,21.85 37.52,21.69 33.58,21.69 32.94,22.33 32.94,25.35 32.92,25.37 32.92,26.09 32.92,26.1 32.92,26.89 32.35,27.46 32.19,27.46 32.15,27.49 32.15,28.1 32.19,28.14 37.02,28.14 37.11,28.04 37.11,26.05
B+ on TOP: 200.47,111.76 200.28,111.95 196.03,111.95 195.84,111.76 195.84,109.74 196.4,109.18 198.15,109.18 198.35,109.37 200.11,109.37 200.47,109.73
B+ on TOP: 279.91,27.05 278.77,27.05 278.51,26.8 278.51,25.53 278.64,25.4 280.04,25.4 280.16,25.53 280.16,26.8
B+ on TOP: 44.38,33.09 44.38,31.38 44.28,31.28 43.91,31.28 43.44,31.75 43.44,32.77 43.05,33.15 41.28,33.15 41.02,33.4 41.02,33.91 41.03,33.92 41.03,34.48 41.15,34.6 41.78,34.6 41.91,34.47 43,34.47
B+ on TOP: 15.66,11.4 15.37,11.1 12.72,11.1 12.52,11.3 12.52,12.56 12.13,12.96 10.36,12.96 10.11,13.21 10.11,14 10.31,14.2 14.95,14.2 15.66,13.49
B+ on TOP: 318.76,18.11 318.76,12.88 318.8,12.84 318.8,12.13 319.33,12.13 319.33,11.68 318.8,11.68 318.8,10.93 319.33,10.93 319.33,10.48 318.8,10.48 318.8,9.34 317.25,9.34 315.38,11.21 315.38,17.74 315.93,18.29 318.58,18.29
B+ on BOTTOM: 252.26,19.62 252.26,21.48 253.24,22.45 253.65,22.45 253.8,22.3 253.8,20.32 252.97,19.5 252.39,19.5
B+ on BOTTOM: 39.02,24.77 44.2,24.77 44.32,24.64 44.32,24.13 44.12,23.93 43.06,23.93 42.73,23.61 42.75,23.59 42.75,21.9 42.95,21.69 43.32,21.69 43.43,21.8 44.07,21.8 44.18,21.7 44.18,21.26 42.92,20 40.77,20 40.55,19.78 37.46,19.78 36.03,21.21 32.98,21.21 32.97,21.22 31.97,21.22 31.14,22.05 30.37,22.05 30.2,22.22 30.2,23.83 30.25,23.88 30.94,23.88 31.12,24.05 31.12,24.49 30.96,24.64 30.28,24.64 30.23,24.69 30.23,25.22 30.3,25.3 32.09,25.3 32.3,25.51 32.3,27.18 32.15,27.33 32.15,28.1 32.21,28.16 38.02,28.16 38.04,28.15 38.04,27.88 38.09,27.83 38.05,27.79 38.05,27.18 37.9,27.03 37.57,27.03 37.21,26.67 37.21,26.34 38.1,25.45 38.33,25.45
B+ on BOTTOM: 131.24,107.07 131.4,106.92 131.4,104.89 131.23,104.72 126.61,104.72 126.47,104.86 126.47,106.84 126.71,107.07
B+ on BOTTOM: 247.19,114.07 247.27,114.15 248.46,114.15 249.04,114.73 250.16,114.73 250.31,114.57 250.31,112.06 249.6,111.35 247.29,111.35 247.19,111.45
B+ on BOTTOM: 149.68,13.72 149.86,13.54 149.86,12.17 148.46,10.77 140.18,10.77 139.72,11.23 137.95,11.23 137.54,11.63 137.54,13.39 137.87,13.72
B+ on IN3: 33.18,24.03 33.53,24.39 33.53,27.31 33.78,27.56 36.45,27.56 36.7,27.31 36.7,26.42 37.82,25.31 37.82,21.07 37.54,20.79 34.08,20.79 33.18,21.69
B+ on IN3: 11.69,14.12 10.26,14.12 10.16,14.02 10.16,13.08 10.31,12.93 11.69,12.93 11.89,13.13 11.89,13.92
B+ on VCC: outline of 119 points within 33.47,14.61 318.64,121.08
B+ on IN5: outline of 145 points within 97.06,45.93 200.61,121.17
B++ on TOP (solid shape): 332.96,22.77 332.96,20.73 332.79,20.55 332.1,20.55 331.35,19.8 331.35,17.98 331.35,17.98 331.35,17.66 331.34,17.65 331.34,14.86 330.96,14.48 326.65,14.48 325.7,13.53 325.7,12.12 325.55,11.96 322.3,11.96 321.8,11.47 321.8,9.83 321.5,9.53 319.06,9.53 318.93,9.65 318.93,10.35 319.46,10.35 319.46,11.06 318.93,11.06 318.93,11.55 319.46,11.55 319.46,12.26 318.93,12.26 318.93,13.59 319.47,14.13 319.47,18.48 319.47,18.7 321.67,20.9 326.35,20.9 326.55,20.7 329.14,20.7 330.04,21.6 330.04,22.74 330.32,23.02 332.72,23.02
B+_0.95V on TOP (solid shape): 109.32,59.41 109.32,58.32 108.87,57.87 108.87,56.71 108.76,56.59 107.19,56.59 106.86,56.92 106.86,59.61 106.91,59.67 109.07,59.67
B+_0.95V on BOTTOM (solid shape): 108.51,60.5 108.51,57.94 108.87,57.58 108.87,56.38 108.55,56.06 106.55,56.06 106.45,56.16 106.45,60 106.91,60.45 106.91,60.53 106.96,60.58 108.43,60.58
B+_1.8VSP on TOP: 247.9,109.62 246.11,109.62 245.81,109.33 245.81,107.52 245.92,107.41 247.41,107.41 248.12,108.12 248.12,109.4
B+_1.8VSP on BOTTOM: 243.76,104.16 243.55,104.37 243.54,104.37 243.16,104.75 242.92,104.75 242.53,105.14 242.53,109.3 243.04,109.81 246.69,109.81 246.82,109.94 246.82,110.81 246.96,110.96 248.98,110.96 249.07,110.86 249.07,109.48 248.4,108.81 248.4,108.23 248.2,108.03 246.89,108.03 246.56,108.36 244.22,108.36 243.84,107.98 243.84,107.7 243.33,107.19 243.33,106.2 243.7,105.84 244.58,105.84 244.69,105.72 244.69,104.2 244.64,104.16
B+_1V on TOP: 136.28,8.48 136.09,8.66 136.09,10.31 136.22,10.44 138.26,10.44 138.6,10.1 138.6,8.57 138.5,8.48
B+_1V on BOTTOM: 133.35,9.53 133.76,9.53 135.27,11.04 139.62,11.04 139.7,10.95 139.7,9.9 139.44,9.64 139.29,9.64 139.12,9.46 139.12,8.84 138.81,8.54 136.7,8.54 136.44,8.79 135.23,8.79 134.44,8 132.99,8 132.94,8.05 132.94,9.12
B+_1VSP on BOTTOM: 248.77,116.42 248.77,114.86 248.64,114.73 247.27,114.73 247.17,114.83 247.17,115.14 247.16,115.15 247.16,115.23 246.86,115.52 244.53,115.52 244.16,115.89 244.16,116.47 243.89,116.74 242.9,116.74 242.58,116.42 242.58,116.29 242.57,116.28 242.57,116.1 242.49,116.03 241.05,116.03 240.95,116.13 240.95,118.14 241.17,118.37 245.87,118.37 247.55,116.69 248.51,116.69
BATBTN# on BOTTOM (solid shape): 350.58,113.86 349.57,113.86 349.57,115.51 350.58,115.51
BATBTN# on BOTTOM (solid shape): 350.58,109.98 349.57,109.98 349.57,111.63 350.58,111.63
BATT++ on TOP: 27.66,15.39 27.59,15.32 25.12,15.32 24.68,15.76 24.68,16.77 25.37,17.47 27.38,17.47 27.66,17.19
BATT++ on BOTTOM: 23.37,8.76 23.37,15.52 25.63,17.78 27.36,17.78 27.73,17.41 28.79,17.41 28.85,17.35 28.85,8.13 28.84,8.12 28.84,5.85 28.42,5.44 23.98,5.44 23.52,5.89 21.92,5.89 21.77,6.05 21.77,7.7 22.18,8.1 22.71,8.1
BATT++ on IN5: 27.18,16.51 27.18,12.16 28.17,11.17 28.17,5.67 27.81,5.31 20.78,5.31 19.76,6.33 19.76,13.54 23.17,16.94 26.75,16.94
BOOT2_ISL88738 on TOP (solid shape): 47.3,15.34 47.3,15.24 47.25,15.19 45.54,15.19 44.98,14.63 44.98,14.43 44.87,14.3 44.82,14.13 43.92,13.23 43.16,13.23 43.08,13.31 43.08,14.15 43.21,14.28 43.69,14.28 44.83,15.42 47.22,15.42
BOOT_1.2V on BOTTOM (solid shape): 287.29,30.18 287.29,30.09 287.23,30.04 285.43,30.04 284.87,29.47 284.87,28.71 284.82,28.66 284.16,28.66 284.11,28.71 284.11,29.86 284.5,30.24 287.23,30.24
BST1_3V on TOP (solid shape): 342.64,25.02 342.64,24.12 342.52,24.01 340.73,24.01 340.62,24.12 340.62,25.02 340.68,25.08 342.58,25.08
BST1_5V on TOP (solid shape): 344.55,17.27 344.49,17.21 343.03,17.21 342.96,17.27 342.96,18.16 344.55,18.16
