# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RE84  10K_0201_5%  [R_0201]  336.69 49.58 0 bottom
RE86  10K_0201_5%  [R_0201]  154.31 13.63 270 top
RE87  100K_0402_5%  [R_0402]  189 10.75 180 top
RE89  10K_0402_5%  [R_0402]  285.81 13.89 90 top
RE90  100K_0402_5%  [R_0402]  284.09 13.91 0 top
RE94  2.2K_0402_5%  [R_0402]  283.97 6.78 90 top
RE95  2.2K_0402_5%  [R_0402]  286.97 9.21 180 top
RE96  100_0402_5%  [R_0402]  300.03 22.43 90 top
RE99  10K_0402_5%  [R_0402]  297.18 22.4 90 top
RE100  10K_0201_5%  [R_0201]  98.08 33.45 0 top
RE101  10K_0201_5%  [R_0201]  334.15 51.23 0 bottom
RE104  0_0603_5%  [R0603_0OHM]  97.03 34.57 90 top
RE105  0_0603_5%  [R0603_0OHM]  335.71 49.57 90 bottom
RE108  0_0402_1%  [R0402_0OHM]  81.33 35.42 0 top
RE109  0_0402_1%  [R0402_0OHM]  81.33 36.18 0 top
RE110  10K_0402_5%  [R_0402]  288.37 17.15 180 top
RE111  43K_0402_1%  [R_0402]  309.5 13.59 0 top
RE112  0_0402_1%  [R0402_0OHM]  312.34 18.8 0 top
RE113  33_0201_5%  [R_0201]  149.34 4.19 0 top
RE114  33_0201_5%  [R_0201]  148.9 7.37 0 top
RE115  33_0201_5%  [R_0201]  148.64 10.03 0 top
RE116  0_0402_1%  [R0402_0OHM]  152.66 10.92 0 bottom
RE117  0_0402_1%  [R0402_0OHM]  152.66 10.03 0 bottom
RE122  0_0402_1%  [R0402_0OHM]  307.42 9.15 180 top
RE125  0_0201_1%  [R_0201]  155.4 3.43 180 top
RE126  300_0402_5%  [R_0402]  309.49 11.11 0 top
RE129  0_0603_5%  [R0603_0OHM]  159.58 11.81 180 top
RE133  0_0201_5%  [R0201_0OHM]  148.9 8.38 0 top
RE136  5.1K_0402_1%  [R_0402]  283.97 9.15 0 top
RE137  5.1K_0402_1%  [R_0402]  288.16 7.7 270 top
RE138  0_0402_1%  [R0402_0OHM]  188.53 5.07 90 top
RE139  0_0402_1%  [R0402_0OHM]  309.47 12.07 0 top
RE141  0_0603_5%  [R0603_0OHM]  152.05 5.45 0 bottom
RE142  100K_0402_5%  [R_0402]  306.76 15.88 0 top
RE143  100K_0402_5%  [R_0402]  177.67 6.86 180 top
RE145  100K_0402_5%  [R_0402]  294.52 6.83 90 top
RE183  10K_0402_5%  [R_0402]  305.75 7.7 270 top
RE255  0_0402_5%  [R_0402]  318.39 30.91 90 bottom
RE273  0_0402_5%  [R_0402]  321.18 31.67 90 bottom
RE274  0_0402_5%  [R_0402]  319.79 31.67 90 bottom
RE275  10K_0402_5%  [R_0402]  331.47 44.27 270 bottom
RE283  10K_0402_5%  [R_0402]  296.06 4.95 270 top
RE284  10K_0402_5%  [R_0402]  295.28 4.95 270 top
RE285  0_0402_5%  [R_0402]  306.38 17.78 0 top
RE286  0_0402_5%  [R_0402]  306.45 11.94 0 top
RE287  0_0402_1%  [R0402_0OHM]  301.89 28.43 0 top
RE288  0_0402_1%  [R0402_0OHM]  302.4 29.25 0 top
RE290  0_0402_5%  [R_0402]  307.21 22.23 180 top
RE291  0_0402_5%  [R_0402]  102.24 7.75 180 bottom
RE292  0_0402_5%  [R_0402]  302.02 25.37 90 top
RE293  2.2K_0402_5%  [R_0402]  292.99 7.75 270 top
RE294  2.2K_0402_5%  [R_0402]  293.75 7.75 270 top
RE295  2.2K_0402_5%  [R_0402]  289.28 13.44 90 top
RE296  2.2K_0402_5%  [R_0402]  290.32 15.62 180 top
RE297  0_0402_5%  [R_0402]  306.43 25.53 0 top
RE298  10K_0402_5%  [R_0402]  302.52 30.1 0 top
RE299  0_0402_5%  [R_0402]  304.18 30.2 270 top
RE300  100K_0402_5%  [R_0402]  310.41 12.83 180 top
RE301  10K_0402_5%  [R_0402]  278.49 12.32 90 top
RE303  0_0402_5%  [R_0402]  303.82 3.92 90 top
RE304  0.01_0603_1%  [R_0603]  281.43 12.85 0 top
RE305  0_0402_1%  [R0402_0OHM]  309.5 25.4 0 top
RE306  0_0402_5%  [R_0402]  309.46 24.61 0 top
RE307  100K_0402_5%  [R_0402]  269.39 20.97 0 top
RE309  0_0402_5%  [R_0402]  152.52 8.61 0 bottom
RE310  0_0402_5%  [R_0402]  152.67 11.71 0 bottom
RE311  100K_0402_5%  [R_0402]  295.28 6.83 90 top
RE313  0_0201_5%  [R0201_0OHM]  294.18 32.93 270 bottom
RE321  0_0201_1%  [R_0201]  90.26 14.38 270 top
RE322  0_0402_5%  [R_0402]  305.88 27.67 90 bottom
RE323  0_0402_5%  [R_0402]  305.88 29.45 90 bottom
RF1  0_0603_5%  [R0603_0OHM]  241.66 44.97 90 top
RF2  100K_0402_5%  [R_0402]  232.93 43.94 270 top
RF3  100K_0402_5%  [R_0402]  238.44 44.91 270 top
RF4  100K_0402_5%  [R_0402]  238.34 46.23 180 top
RF5  100K_0402_5%  [R_0402]  239.33 44.91 270 top
RH2  1K_0201_5%  [R_0201]  76.44 2.22 90 top
RH5  3K_0402_5%  [R_0402]  123.5 95.16 90 bottom
RH6  0_0402_5%  [R_0402]  76.81 4.62 90 top
RH8  0_0402_1%  [R0402_0OHM]  124.25 95.81 0 bottom
RH12  0_0402_1%  [R0402_0OHM]  119.19 95.9 270 bottom
RH24  24.9_0201_1%  [R_0201]  173.81 56.51 0 bottom
RH30  24.9_0402_1%  [R_0402]  177.06 86.83 90 top
RH42  100K_0402_5%  [R_0402]  79.99 18.12 180 top
RH59  49.9_0201_1%  [R_0201]  131.99 78.41 0 bottom
RH67  1.3K_0402_5%  [R_0402]  279.45 7.02 180 top
RH70  10M_0402_5%  [R_0402]  70.36 5.59 0 bottom
RH71  60.4_0402_1%  [R_0402]  102.31 18.16 180 bottom
RH72  1M_0201_5%  [R_0201]  102.74 17.65 90 top
RH74  4.7K_0201_5%  [R_0201]  70.99 9.15 0 bottom
RH75  100K_0201_5%  [R_0201]  73.34 12.23 270 top
RH77  100K_0402_5%  [R_0402]  64.02 2.38 180 bottom
RH78  100K_0201_5%  [R_0201]  66.83 9.65 0 top
RH82  4.7K_0402_5%  [R_0402]  66.49 2.99 0 top
RH83  20K_0201_5%  [R_0201]  70.92 5.59 0 top
RH84  20K_0201_5%  [R_0201]  74.93 1.87 90 top
RH85  8.2K_0402_5%  [R_0402]  83.95 9.45 90 top
RH91  100K_0201_5%  [R_0201]  102.95 9.81 180 bottom
RH95  100_0402_5%  [R_0402]  102.7 11.79 180 bottom
RH96  0_0201_5%  [R0201_0OHM]  93.87 2.44 180 top
RH97  100_0402_5%  [R_0402]  119.34 92.42 0 bottom
RH98  51_0402_5%  [R_0402]  119.17 93.28 90 bottom
RH100  51_0402_5%  [R_0402]  118.33 93.31 90 bottom
RH108  100_0201_1%  [R_0201]  92.92 28.78 225 top
RH109  113_0402_1%  [R_0402]  102.08 24.05 0 bottom
RH110  10K_0201_5%  [R_0201]  89.88 1.4 0 bottom
RH119  4.7K_0402_5%  [R_0402]  108.33 4.12 90 top
RH120  4.7K_0402_5%  [R_0402]  107.44 4.12 90 top
RH130  4.7K_0402_5%  [R_0402]  86.04 8.12 180 top
RH133  0_0402_1%  [R0402_0OHM]  70.89 7.54 0 bottom
RH145  20_0402_5%  [R_0402]  180.65 80.72 315 bottom
RH146  30_0201_1%  [R_0201]  102.31 11.13 180 bottom
RH147  30_0201_1%  [R_0201]  105.33 11.1 180 bottom
RH148  121_0201_1%  [R_0201]  173.8 57.08 0 bottom
RH149  75_0201_1%  [R_0201]  173.8 57.67 0 bottom
RH150  100_0201_1%  [R_0201]  171.58 56.01 0 bottom
RH151  100_0402_5%  [R_0402]  132.8 103.51 270 top
RH152  56.2_0402_1%  [R_0402]  132.8 104.38 90 top
RH153  220_0402_5%  [R_0402]  133.69 105.3 270 top
RH154  60.4_0402_1%  [R_0402]  180.52 63.18 270 top
RH155  20_0402_5%  [R_0402]  130.27 83.19 0 bottom
RH156  51_0201_5%  [R_0201]  131.56 79.63 90 bottom
RH158  499_0201_1%  [R_0201]  130.15 81.34 0 bottom
RH163  1K_0402_5%  [R_0402]  172.51 81.07 90 top
RH164  1K_0402_5%  [R_0402]  181.34 62.27 90 top
RH165  1K_0201_5%  [R_0201]  129.78 79.63 90 bottom
RH167  30_0402_5%  [R_0402]  179.58 62.26 90 top
RH168  15_0201_1%  [R_0201]  81.67 6.38 270 top
RH183  1K_0402_5%  [R_0402]  131.93 77.24 90 top
RH184  1K_0402_5%  [R_0402]  132.79 77.79 90 top
RH185  1K_0402_5%  [R_0402]  133.87 75.31 180 top
RH186  1K_0402_5%  [R_0402]  131.81 72.5 0 top
RH187  1K_0402_5%  [R_0402]  132.06 74.4 90 top
RH188  1K_0402_5%  [R_0402]  134 73.34 180 top
RH189  30_0402_5%  [R_0402]  101.69 15.75 0 bottom
RH190  0_0402_1%  [R0402_0OHM]  132.94 84.89 0 bottom
RH191  620_0402_5%  [R_0402]  102.44 17.02 0 bottom
RH192  30_0402_5%  [R_0402]  191.72 62.21 90 top
RH197  100_0402_1%  [R_0402]  141.41 95.38 180 bottom
RH198  0_0402_1%  [R0402_0OHM]  139.72 95.36 90 bottom
RH200  300_0201_1%  [R_0201]  134.3 84.12 180 bottom
RH201  100_0402_1%  [R_0402]  134.4 105.56 270 bottom
RH202  0_0402_1%  [R0402_0OHM]  134.45 106.79 90 bottom
RH203  100_0402_1%  [R_0402]  133.26 95.23 90 bottom
RH204  0_0402_1%  [R0402_0OHM]  134.81 95.23 90 bottom
RH206  1K_0402_1%  [R_0402]  127.41 20.04 270 top
RH207  1K_0402_1%  [R_0402]  233.15 20.89 270 top
RH209  1K_0402_1%  [R_0402]  126.63 19.13 180 top
RH210  1K_0402_1%  [R_0402]  233.15 19.11 270 top
RH211  24.9_0402_1%  [R_0402]  124.03 19.01 180 top
RH212  24.9_0402_1%  [R_0402]  231.42 18.92 270 top
RH309  0_0402_5%  [R_0402]  67.49 8.38 0 top
RH383  10K_0402_5%  [R_0402]  86.87 10.62 270 top
RH401  100K_0201_5%  [R_0201]  67.36 6.43 0 top
RH423  100K_0201_5%  [R_0201]  99.44 6.35 180 top
RH428  22_0201_1%  [R_0201]  85.21 6.13 270 top
RH453  1K_0402_5%  [R_0402]  71.83 7.37 180 top
RH454  1K_0201_5%  [R_0201]  115.75 6.38 180 top
RH456  0_0402_5%  [R_0402]  181.24 86.72 90 bottom
RH458  1K_0201_5%  [R_0201]  107.06 9.58 90 bottom
RH459  1K_0201_5%  [R_0201]  111.89 9.27 180 bottom
RH460  1K_0201_5%  [R_0201]  85.89 2.44 90 top
RH461  1K_0201_5%  [R_0201]  86.46 2.48 90 top
RH462  1K_0201_5%  [R_0201]  109.75 10.2 270 top
RH463  1K_0201_5%  [R_0201]  110.36 10.2 270 top
RH465  0_0402_1%  [R0402_0OHM]  138.95 95.39 90 bottom
RH466  100_0402_1%  [R_0402]  138.14 95.42 90 bottom
RH469  100_0402_1%  [R_0402]  133.11 105.56 270 bottom
RH470  0_0402_1%  [R0402_0OHM]  133.11 106.79 90 bottom
RH471  0_0402_1%  [R0402_0OHM]  134.04 95.23 90 bottom
RH472  100_0402_1%  [R_0402]  135.59 96.14 270 bottom
RH474  1K_0402_5%  [R_0402]  130.18 85.47 0 bottom
RH475  0_0402_5%  [R_0402]  128.58 84.81 270 bottom
RH477  0_0402_1%  [R0402_0OHM]  118.3 95.9 270 bottom
RH478  0_0402_1%  [R0402_0OHM]  120.14 95.9 270 bottom
RH479  0_0402_5%  [R_0402]  119.19 94.88 180 top
RH480  1K_0402_5%  [R_0402]  119.19 93.99 180 top
RH481  1K_0402_5%  [R_0402]  130.47 93.24 270 top
RH482  1K_0402_5%  [R_0402]  130.47 90.55 90 top
RH483  150_0402_5%  [R_0402]  130.46 98.71 270 top
RH484  2_0402_1%  [R_0402]  125.72 19.93 0 top
RH485  2_0402_1%  [R_0402]  232.2 20.89 270 top
RH487  0_0201_5%  [R_0201]  116.7 6.4 0 top
RH488  1K_0402_5%  [R_0402]  130.47 96.93 270 top
RH489  1K_0402_5%  [R_0402]  76.23 9.5 180 top
RH490  0_0402_5%  [R_0402]  127.69 94.3 0 bottom
RH491  0_0402_1%  [R0402_0OHM]  131.89 102.59 90 top
RH492  2.2K_0402_5%  [R_0402]  119.19 95.9 180 top
RH493  2.2K_0402_5%  [R_0402]  74.12 12.23 270 top
RH494  51_0402_5%  [R_0402]  131.7 98.25 270 bottom
RH495  51_0402_5%  [R_0402]  134.62 98.25 270 bottom
RH496  51_0402_5%  [R_0402]  133.67 98.25 270 bottom
RH497  51_0402_5%  [R_0402]  130.15 82.42 0 bottom
RH498  51_0402_5%  [R_0402]  132 105.31 270 top
RH501  1K_0201_1%  [R_0201]  86.74 5.88 270 top
RH502  1K_0201_1%  [R_0201]  87.04 2.47 90 top
RH503  4.7K_0402_5%  [R_0402]  88.39 5.54 270 top
RH504  150K_0402_5%  [R_0402]  85.98 6.17 270 top
RH505  4.7K_0402_5%  [R_0402]  87.5 5.79 270 top
RH506  1M_0402_5%  [R_0402]  99.34 4.45 0 top
RH508  10K_0201_5%  [R_0201]  79.63 15.24 0 top
RH510  10K_0402_5%  [R_0402]  70.99 14.86 180 bottom
RH511  10K_0201_5%  [R_0201]  71.82 20.85 90 bottom
RH512  10K_0201_5%  [R_0201]  71.32 16.5 180 bottom
RH513  10K_0201_5%  [R_0201]  70.99 15.62 180 bottom
RH515  8.2K_0402_5%  [R_0402]  76.84 7.11 180 top
RH516  10K_0201_5%  [R_0201]  101.98 9.02 180 top
RH518  10K_0402_5%  [R_0402]  109.22 2.78 270 top
RH519  0_0402_5%  [R_0402]  130.3 83.95 0 bottom
RH523  10K_0402_5%  [R_0402]  88.94 10.28 270 top
RH524  4.7K_0402_5%  [R_0402]  102.31 5.84 180 top
RH525  100K_0402_5%  [R_0402]  121.36 54.74 180 top
RH527  10K_0402_5%  [R_0402]  66.74 13.83 90 bottom
RH528  10K_0402_5%  [R_0402]  67.82 12.45 180 bottom
RH529  100K_0201_5%  [R_0201]  63.17 4.83 0 bottom
RH530  0_0402_5%  [R_0402]  184.74 47.25 180 top
RH531  1M_0201_5%  [R_0201]  76.53 8.13 180 top
RH533  8.2K_0402_5%  [R_0402]  78.75 2.15 180 top
RH535  10K_0402_5%  [R_0402]  85.09 9.45 90 top
RH536  1K_0201_5%  [R_0201]  111.39 5.61 0 top
RH537  10K_0402_5%  [R_0402]  258.7 44.96 180 top
RH539  13_0402_5%  [R_0402]  102.61 14.98 180 bottom
RH540  0_0402_1%  [R0402_0OHM]  132.78 98.25 270 bottom
RH541  0_0402_1%  [R0402_0OHM]  135.51 98.25 270 bottom
RH542  0_0402_1%  [R0402_0OHM]  130.43 95.37 90 bottom
RH543  0_0402_1%  [R0402_0OHM]  128.81 82.28 270 bottom
RH544  10K_0402_5%  [R_0402]  67.4 4.53 180 top
RH545  10K_0201_5%  [R_0201]  77.03 2.81 270 top
RH546  10K_0402_5%  [R_0402]  87.76 8.64 180 top
RH547  10K_0402_5%  [R_0402]  83.54 2.45 270 bottom
RH548  10K_0402_5%  [R_0402]  88.38 1.54 90 bottom
RH549  10K_0402_5%  [R_0402]  86.23 1.54 90 bottom
RH550  10K_0402_5%  [R_0402]  84.91 11.56 180 top
RH551  10K_0402_5%  [R_0402]  70.65 17.08 0 top
RH552  10K_0201_5%  [R_0201]  81.65 14.46 90 top
RH553  10K_0201_5%  [R_0201]  77.03 13.86 180 top
RH554  10K_0201_5%  [R_0201]  76.58 14.73 180 top
RH555  10K_0201_5%  [R_0201]  77.03 13.09 180 top
RH557  10K_0402_5%  [R_0402]  66.68 6.22 180 top
RH561  49.9K_0402_1%  [R_0402]  105.58 5.02 180 top
RH562  49.9K_0402_1%  [R_0402]  105.58 6.03 180 top
RH563  10K_0402_5%  [R_0402]  103.13 2.41 180 top
RH564  100K_0402_5%  [R_0402]  77.34 10.97 90 top
RH565  100K_0402_5%  [R_0402]  76.59 11.88 180 top
RH566  100K_0402_5%  [R_0402]  108.48 9.53 180 top
RH567  100K_0402_5%  [R_0402]  106.73 9.53 180 top
RH568  100K_0201_5%  [R_0201]  98.27 7.7 270 top
RH569  100K_0201_5%  [R_0201]  98.81 8.31 0 top
RH570  49.9_0201_1%  [R_0201]  130.67 79.63 90 bottom
RH571  8.2K_0402_5%  [R_0402]  104.45 10.42 0 bottom
RH572  100K_0402_5%  [R_0402]  67.4 3.76 180 top
RH573  1K_0402_5%  [R_0402]  70.92 8.26 0 top
RH576  33_0402_5%  [R_0402]  68.14 10.68 270 top
RH577  0_0402_1%  [R0402_0OHM]  70.92 10.92 0 top
RH578  0_0402_1%  [R0402_0OHM]  70.95 10.13 0 top
RH579  0_0402_1%  [R0402_0OHM]  70.92 9.09 0 top
RH580  0_0201_5%  [R0201_0OHM]  102.2 25.12 0 bottom
RH581  0_0201_5%  [R0201_0OHM]  102.2 23.37 0 bottom
RH585  0.01_0603_1%  [R_0603]  62.51 12.32 180 bottom
RH586  0_0201_5%  [R0201_0OHM]  64.09 3.94 180 bottom
RH590  200_0201_1%  [R_0201]  280.8 7.2 90 top
RH597  0_0402_5%  [R_0402]  119.51 9.97 270 top
RH599  0_0402_5%  [R_0402]  119.97 11.94 180 top
RH1145  2.2K_0201_5%  [R_0201]  87.46 11.89 180 top
RH1146  2.2K_0201_5%  [R_0201]  102.36 10.38 0 bottom
RH1152  100K_0201_5%  [R_0201]  306.33 22.99 0 top
RH1943  8.2K_0402_1%  [R_0402]  120.52 9.48 270 top
RH1957  0.01_0603_1%  [R_0603]  124.64 11.89 180 top
RH1958  0_0402_5%  [R_0402]  130.18 84.71 0 bottom
RH5832  200_0201_1%  [R_0201]  102.11 3.68 0 bottom
RH5833  200_0201_1%  [R_0201]  102.11 4.32 0 bottom
RH5834  200_0201_1%  [R_0201]  102.16 5.85 270 bottom
RH5835  0_0402_5%  [R_0402]  102.36 8.64 180 bottom
RH5836  10K_0402_5%  [R_0402]  103.63 14.48 0 bottom
RH5837  4.7K_0402_5%  [R_0402]  81.34 1.56 0 bottom
RH5838  10K_0402_5%  [R_0402]  83.31 6.22 270 top
RH5839  0_0201_5%  [R_0201]  82.61 6.38 270 top
RH5840  10K_0201_5%  [R_0201]  79.08 10.99 0 top
RH5841  10K_0201_5%  [R_0201]  70.74 6.86 0 bottom
RH5842  10K_0402_5%  [R_0402]  79.71 1.56 0 bottom
RH5844  10K_0201_5%  [R_0201]  79.76 13.72 0 top
RH5845  10K_0201_5%  [R_0201]  72.25 12.73 180 bottom
RH5846  10K_0201_5%  [R_0201]  72.3 13.32 180 bottom
RH5847  10K_0201_5%  [R_0201]  80.44 12.66 0 top
RH5848  10K_0201_5%  [R_0201]  72.3 13.91 180 bottom
RH5849  10K_0201_5%  [R_0201]  72.3 14.48 180 bottom
RH5850  10K_0201_5%  [R_0201]  97.41 19.81 180 top
RH5853  10K_0201_5%  [R_0201]  92.89 10.81 270 top
RH5854  20K_0201_5%  [R_0201]  93.49 10.39 0 top
RH5855  10K_0201_5%  [R_0201]  90.65 12.33 270 top
RH5856  0_0402_5%  [R_0402]  91.97 18.19 270 top
RH5857  100K_0201_5%  [R_0201]  91.66 1.4 0 bottom
RH5858  100K_0201_5%  [R_0201]  92.24 2.03 180 bottom
RH5859  0_0402_5%  [R_0402]  68.84 7.62 180 top
RH5860  100K_0402_5%  [R_0402]  76.98 10.24 270 top
RH5861  100_0402_1%  [R_0402]  299.16 5.59 180 top
RH5864  0_0402_5%  [R_0402]  145.19 14.22 0 top
RH5865  0_0402_5%  [R_0402]  145.18 13.43 0 top
RH5866  0.01_0603_1%  [R_0603]  57.84 4.57 90 top
RH5867  100K_0402_5%  [R_0402]  136.15 15.06 270 top
RH5868  49.9K_0402_1%  [R_0402]  141.91 16.26 0 top
RH5869  0_0201_5%  [R_0201]  306.68 16.7 180 top
RH5870  0_0201_5%  [R_0201]  247.14 8.26 180 top
RH5871  0_0201_5%  [R_0201]  247.08 7.57 0 top
RH5872  0_0201_5%  [R0201_0OHM]  298.93 3.97 270 top
RH5873  0_0201_5%  [R0201_0OHM]  99.95 5.59 180 top
RH5875  100K_0402_5%  [R_0402]  91.08 7.73 90 top
RH5876  100K_0402_5%  [R_0402]  92.5 8.23 0 top
RH5879  0_0402_5%  [R_0402]  89.28 14.86 180 top
RH5880  0_0402_5%  [R_0402]  90.56 15.12 0 top
RH5881  4.7K_0201_5%  [R_0201]  78.91 16.51 180 top
RH5882  0_0201_5%  [R_0201]  83.12 9.55 180 top
RH5883  0_0201_5%  [R_0201]  81.41 8.75 90 top
RH5884  1M_0402_5%  [R_0402]  290.72 13.02 0 top
RH5889  10K_0201_5%  [R_0201]  97.07 1.5 180 top
RH5890  100K_0201_5%  [R_0201]  90.08 11.75 90 top
RH5891  100K_0201_5%  [R_0201]  341.63 45.17 90 bottom
RH5892  100K_0201_5%  [R_0201]  69.51 12.45 180 bottom
RH5893  0_0201_5%  [R_0201]  171.24 111.63 180 top
RI4  100K_0402_5%  [R_0402]  23.12 99.37 90 bottom
RI5  100K_0402_5%  [R_0402]  23.12 97.46 90 bottom
RI6  33K_0402_1%  [R_0402]  27.7 99.28 90 top
RI7  22.1K_0402_1%  [R_0402]  27.65 98.52 270 top
RI8  10K_0402_5%  [R_0402]  23.62 102.92 90 bottom
RI9  100K_0402_5%  [R_0402]  328.17 59.74 90 bottom
RI10  100K_0402_5%  [R_0402]  329.01 59.74 90 bottom
RI11  33K_0402_1%  [R_0402]  337.3 62.93 0 bottom
RI12  22.1K_0402_1%  [R_0402]  337.3 62.04 0 bottom
RI13  10K_0402_5%  [R_0402]  325.76 49.59 0 top
RI14  0.01_0805_1%  [R_0805]  327.66 41.75 270 top
RI15  10K_0402_5%  [R_0402]  326.26 36.58 0 top
RI16  0_0402_5%  [R_0402]  326.26 35.05 0 top
RI17  10K_0402_5%  [R_0402]  319.28 37.09 180 top
RI18  0_0402_5%  [R_0402]  319.28 35.56 180 top
RI19  4.7K_0402_5%  [R_0402]  326.26 35.82 0 top
RI20  4.7K_0402_5%  [R_0402]  326.26 37.34 0 top
RI21  4.7K_0402_5%  [R_0402]  319.28 36.32 180 top
RI22  4.7K_0402_5%  [R_0402]  319.28 34.04 180 top
RI23  4.99K_0402_1%  [R_0402]  321.06 32.13 270 top
RI24  4.7K_0402_5%  [R_0402]  326.26 34.29 0 top
RI25  0_0402_1%  [R0402_0OHM]  320.3 39.24 90 top
RI26  1M_0402_5%  [R_0402]  19.43 103.33 270 bottom
RI27  1M_0402_5%  [R_0402]  325.59 53.98 90 top
RI28  0_0402_5%  [R_0402]  326.54 51.16 90 top
RI30  100K_0402_5%  [R_0402]  325.79 42.72 90 bottom
RI31  100K_0402_5%  [R_0402]  330.58 43.36 90 bottom
RI32  0_0402_1%  [R0402_0OHM]  328.17 45.64 90 bottom
RI33  0_0402_1%  [R0402_0OHM]  329.06 45.64 90 bottom
RI34  0_0402_5%  [R_0402]  328.22 44.71 0 bottom
RI35  0_0402_5%  [R_0402]  327.15 42.72 90 bottom
RI36  0_0402_5%  [R_0402]  319.28 34.8 180 top
RI37  0_0402_1%  [R0402_0OHM]  323.98 30.35 270 top
RI38  0_0402_1%  [R0402_0OHM]  324.74 30.35 270 top
RI39  0_0402_1%  [R0402_0OHM]  322.58 32.13 270 top
RI40  0_0402_1%  [R0402_0OHM]  321.82 32.13 270 top
RI45  0_0805_5%  [R0805_0OHM]  327.66 34.16 90 bottom
RI46  10K_0402_5%  [R_0402]  323.55 44.71 180 top
RL1  820_0402_5%  [R_0402]  344.22 101.86 0 top
RL2  820_0402_5%  [R_0402]  344.22 102.87 0 top
RL3  820_0402_5%  [R_0402]  344.22 103.89 0 top
RL4  820_0402_5%  [R_0402]  344.22 104.9 0 top
RL5  820_0402_5%  [R_0402]  344.22 105.79 0 top
RM1  2.2K_0402_5%  [R_0402]  26.93 73.79 0 top
RM2  2.2K_0402_5%  [R_0402]  26.93 74.68 0 top
RM3  1K_0402_5%  [R_0402]  26.93 69.47 0 top
RM4  4.12K_0402_1%  [R_0402]  20.75 68.91 270 top
RM5  10K_0201_5%  [R_0201]  27.81 78.11 180 top
RM6  10K_0201_5%  [R_0201]  21.97 66.49 180 top
RM7  4.7K_0201_5%  [R_0201]  27.69 95.2 270 top
RM9  4.7K_0201_5%  [R_0201]  26.93 72.01 0 top
RM10  4.7K_0201_5%  [R_0201]  19.86 94.36 0 bottom
RM11  4.7K_0402_5%  [R_0402]  24.45 66.96 270 top
RM12  4.7K_0402_5%  [R_0402]  27.81 72.77 180 top
RM13  4.7K_0402_5%  [R_0402]  27.79 71.34 180 top
RM14  4.7K_0201_5%  [R_0201]  27.69 67.69 180 top
RM15  0_0603_5%  [R0603_0OHM]  27.05 65.91 270 top
RM16  4.7K_0201_5%  [R_0201]  25.79 67.63 90 top
RM17  4.7K_0201_5%  [R_0201]  25.21 67.12 270 top
RM18  4.7K_0201_5%  [R_0201]  26.43 68.21 270 top
RM19  0_0402_5%  [R_0402]  26.93 75.57 0 top
RM20  4.7K_0402_5%  [R_0402]  25.24 64.92 90 top
RM21  10K_0201_5%  [R_0201]  11.27 74.55 0 bottom
RM24  10K_0201_5%  [R_0201]  17.97 71.88 180 top
RM25  68_0201_1%  [R_0201]  15.53 71.5 0 bottom
RM26  68_0201_1%  [R_0201]  16.71 72.33 270 bottom
RM27  0_0402_5%  [R_0402]  26.93 77.34 0 top
RM28  10K_0201_5%  [R_0201]  27.69 93.26 270 top
RM102  1K_0201_1%  [R_0201]  17.9 75.04 270 top
RM103  33_0201_5%  [R_0201]  17.88 73.18 90 top
RM1145  100K_0201_5%  [R_0201]  97.89 9.97 180 top
RM1834  10M_0402_5%  [R_0402]  17.17 73.72 90 top
RN1  0_0201_5%  [R_0201]  342.72 100.65 180 top
RN33  100K_0402_5%  [R_0402]  339.35 104.6 270 top
RP1  2.2K_0804_8P4R_5%  [RP_0804_8P4R]  101.98 12.75 0 top
RP2  10K_0804_8P4R_5%  [RP_0804_8P4R]  66.23 14.85 0 top
RP4  33_0804_8P4R_5%  [RP_0804_8P4R]  71.95 11.67 180 bottom
RP8  10K_0804_8P4R_5%  [RP_0804_8P4R]  71.44 14.24 180 top
RP15  33_0804_8P4R_5%  [RP_0804_8P4R]  105.58 5.03 90 bottom
RP19  100K_0804_8P4R_5%  [RP_0804_8P4R]  285.44 11.32 180 top
RP20  10K_0804_8P4R_5%  [RP_0804_8P4R]  310.5 28.9 270 top
RP22  10K_0804_8P4R_5%  [RP_0804_8P4R]  70.72 19.69 0 top
RP23  10K_0804_8P4R_5%  [RP_0804_8P4R]  70.87 18.42 0 bottom
RR1  10K_0201_5%  [R_0201]  345.99 35.43 180 bottom
RR2  0_0402_1%  [R0402_0OHM]  334.91 39.56 180 bottom
RR3  0_0402_1%  [R0402_0OHM]  334.91 40.45 180 bottom
RR4  0_0402_1%  [R0402_0OHM]  336.11 41.33 90 bottom
RR5  0_0402_1%  [R0402_0OHM]  338.71 42.41 90 bottom
RR6  6.2K_0402_1%  [R_0402]  336.87 33.07 90 bottom
RR7  0_0402_1%  [R0402_0OHM]  339.6 42.41 90 bottom
RR8  0_0402_1%  [R0402_0OHM]  340.49 42.41 90 bottom
RR9  10K_0201_5%  [R_0201]  345.4 36.2 0 bottom
RR10  0_0201_5%  [R0201_0OHM]  343.41 34.6 90 bottom
RR41  0_0201_5%  [R_0201]  342.44 44.86 90 bottom
RR42  0_0201_5%  [R_0201]  340.23 45.17 90 bottom
RR43  0_0201_5%  [R_0201]  344.68 44.86 90 bottom
RR44  0_0201_5%  [R_0201]  344.04 44.86 90 bottom
RR45  0_0201_5%  [R_0201]  340.87 45.17 90 bottom
RT1  3.01K_0402_1%  [R_0402]  28.04 37.64 90 top
RT2  14K_0402_1%  [R_0402]  29.85 42.17 0 top
RT3  100_0201_1%  [R_0201]  25.09 48.99 270 top
RT4  100_0201_1%  [R_0201]  34.96 43.69 180 bottom
RT5  14K_0402_1%  [R_0402]  31.62 36.07 0 top
RT6  10K_0201_5%  [R_0201]  34.61 42.88 180 top
RT7  10K_0201_5%  [R_0201]  34.48 44.68 180 top
RT8  10K_0201_5%  [R_0201]  34.48 44.11 180 top
RT9  10K_0201_5%  [R_0201]  34.48 43.51 180 top
RT10  4.75K_0402_0.5%  [R_0402]  25.02 41.53 0 top
RT12  499_0201_1%  [R_0201]  24.96 35.09 270 top
RT15  3.3K_0201_1%  [R_0201]  41.05 24.07 90 top
RT16  2.2K_0201_5%  [R_0201]  38.94 26.54 90 top
RT17  3.3K_0201_1%  [R_0201]  42.08 31.75 0 top
RT18  2.2K_0201_5%  [R_0201]  39.63 31.71 90 top
RT21  10K_0201_5%  [R_0201]  31.69 48.55 270 top
RT22  10K_0201_5%  [R_0201]  30.1 47.25 270 bottom
RT23  10K_0201_5%  [R_0201]  30 47.31 0 top
RT25  10K_0201_5%  [R_0201]  24.45 48.93 270 top
RT33  100K_0201_5%  [R_0201]  33.02 46.04 180 top
RT34  100K_0201_5%  [R_0201]  33.02 46.61 180 top
RT35  2.2K_0201_5%  [R_0201]  27.33 47.22 270 bottom
RT36  2.2K_0201_5%  [R_0201]  28.83 47.25 270 bottom
RT37  100K_0201_5%  [R_0201]  29.47 47.25 270 bottom
RT38  100K_0201_5%  [R_0201]  28.8 48.13 180 top
RT39  10K_0201_5%  [R_0201]  19.2 50.15 270 bottom
RT40  10K_0201_5%  [R_0201]  26.73 48.71 270 top
RT41  100K_0201_5%  [R_0201]  33.8 45.11 90 bottom
RT42  100K_0201_5%  [R_0201]  36.01 43.16 270 top
RT43  100K_0201_5%  [R_0201]  29.38 47.25 180 top
RT44  1M_0201_1%  [R_0201]  19.67 42.48 0 bottom
RT45  1M_0201_1%  [R_0201]  19.67 43.09 0 bottom
RT46  0_0603_5%  [R_0603]  18.03 46.17 270 bottom
RT107  1M_0201_1%  [R_0201]  33.61 46.04 90 top
RT113  0_0603_5%  [R0603_0OHM]  20.57 53.35 0 top
RT164  499_0201_1%  [R_0201]  24.39 34.51 90 top
RT165  0_0805_5%  [R0805_0OHM]  26.8 51.86 90 bottom
RT167  10K_0201_5%  [R_0201]  17.18 53.34 180 bottom
RT168  3.3K_0201_1%  [R_0201]  21.85 53.09 90 bottom
RT169  3.3K_0201_1%  [R_0201]  22.48 53.09 90 bottom
RT170  3.3K_0201_1%  [R_0201]  25.24 59.77 0 top
RT171  3.3K_0201_1%  [R_0201]  47.5 29.3 270 top
RT176  0_0201_5%  [R0201_0OHM]  25.19 62.38 90 bottom
RT177  0_0201_5%  [R0201_0OHM]  24.6 62.38 90 bottom
RT178  0_0201_5%  [R0201_0OHM]  17.78 55.69 180 bottom
RT181  0_0201_5%  [R0201_0OHM]  25.64 53.82 270 bottom
RT182  0_0201_5%  [R0201_0OHM]  25.4 55.75 0 top
RT183  100K_0201_1%  [R_0201]  22.74 61.19 270 top
RT184  0_0201_5%  [R0201_0OHM]  19.37 63.25 270 bottom
RT185  0_0201_5%  [R0201_0OHM]  18.79 63.25 270 bottom
RT186  100K_0201_5%  [R_0201]  27.27 56.77 0 top
RT187  100K_0201_5%  [R_0201]  20.87 62.93 270 bottom
RT188  100K_0201_5%  [R_0201]  20.23 62.93 270 bottom
RT189  0_0201_5%  [R_0201]  25.4 57.84 90 top
RT191  15K_0402_0.1%  [R_0402]  18.42 59.06 180 bottom
RT194  100K_0201_5%  [R_0201]  26.46 55.12 180 top
RT195  0_0201_5%  [R0201_0OHM]  27.52 50.47 270 top
RT199  0_0201_5%  [R_0201]  27.36 58.17 0 top
RT200  0_0201_5%  [R0201_0OHM]  23.31 53.05 90 bottom
RT201  0_0201_5%  [R0201_0OHM]  23.88 53.05 90 bottom
RT202  10K_0201_5%  [R_0201]  32.45 48.6 90 top
RT207  1M_0201_1%  [R_0201]  19.67 43.67 0 bottom
RT208  1M_0201_1%  [R_0201]  19.67 41.89 0 bottom
RT209  100K_0201_5%  [R_0201]  26.18 46.78 180 bottom
RT226  10K_0201_5%  [R_0201]  20.66 59.95 0 top
RT227  10K_0201_5%  [R_0201]  24.85 60.33 0 top
RT232  0_0201_5%  [R_0201]  20.91 64.03 180 bottom
RT233  0_0201_5%  [R_0201]  22.05 62.31 180 bottom
RT241  0_0603_5%  [R0603_0OHM]  16.8 43.52 90 bottom
RT242  0_0402_5%  [R_0402]  35.33 42.88 270 top
RT243  0_0402_1%  [R0402_0OHM]  42.94 31.05 180 top
RT244  0_0201_5%  [R0201_0OHM]  31.69 49.18 90 top
RT245  0_0201_5%  [R_0201]  27.27 57.41 0 top
RT429  100K_0201_5%  [R_0201]  23.69 57.2 90 top
RT430  100K_0201_5%  [R_0201]  20.99 56.64 180 top
RT431  100K_0201_5%  [R_0201]  19.99 60.43 270 top
RT432  100K_0201_5%  [R_0201]  19.42 61.41 270 top
RT433  0_0201_5%  [R0201_0OHM]  21.09 48.26 0 top
RT435  0_0201_5%  [R_0201]  16.51 47.65 90 bottom
RT437  1M_0201_1%  [R_0201]  27.27 56.14 0 top
RT1092  0_0603_5%  [R_0603]  23.05 55.62 270 top
RT1093  10K_0201_1%  [R_0201]  22.73 62.4 270 top
RT1095  0_0402_5%  [R_0402]  16.63 54.5 0 bottom
RT1133  0_0402_5%  [R_0402]  174.12 10.16 0 top
RT1134  1M_0402_5%  [R_0402]  25.77 48.31 90 top
RT1135  0_0402_5%  [R_0402]  296.95 29.22 270 top
RT1136  0_0402_5%  [R_0402]  71.81 8.33 180 bottom
RT1139  0_0402_5%  [R_0402]  310.34 17.78 180 top
RT1141  0_0201_5%  [R_0201]  21.92 64.63 90 bottom
RT1142  0_0201_5%  [R_0201]  22.96 64.63 90 bottom
RT1143  0_0201_5%  [R_0201]  22.73 66.42 270 bottom
RT1144  0_0201_5%  [R_0201]  22.15 66.42 270 bottom
RT1145  10K_0201_5%  [R_0201]  25.02 47.37 270 bottom
RT5832  0_0201_5%  [R0201_0OHM]  19.26 40.59 0 bottom
RT5833  0_0201_5%  [R0201_0OHM]  19.26 40.03 0 bottom
RT5834  0_0201_5%  [R0201_0OHM]  19.71 35.37 0 bottom
RT5835  0_0201_5%  [R0201_0OHM]  19.71 35.94 0 bottom
RT5836  0_0201_5%  [R_0201]  18.8 57.28 0 bottom
RT5837  0_0201_5%  [R_0201]  18.8 56.72 0 bottom
RT5838  0_0201_5%  [R_0201]  18.75 55.55 90 bottom
RT5839  0_0402_5%  [R_0402]  311.79 17.65 0 top
RT5840  0_0402_5%  [R_0402]  311.79 16.89 0 top
RT5841  0_0201_5%  [R0201_0OHM]  25.8 51.17 270 top
RT5842  0_0201_5%  [R_0201]  19.23 51.74 270 bottom
RT5843  0_0201_5%  [R_0201]  73.13 5.21 180 top
RT5844  0_0201_5%  [R0201_0OHM]  27.66 58.99 0 bottom
RT5845  0_0201_5%  [R0201_0OHM]  34.52 44.32 180 bottom
RT5846  0_0201_5%  [R0201_0OHM]  28.65 48.71 180 top
RT5847  2.2K_0201_5%  [R_0201]  30 46.74 0 top
RT5848  2.2K_0201_5%  [R_0201]  30 46.17 0 top
RT5849  0_0201_5%  [R_0201]  71.97 4.64 0 top
RT5850  100K_0201_5%  [R_0201]  19.2 48.29 90 bottom
RT5855  0_0201_5%  [R_0201]  16.45 45.75 90 bottom
RT5856  0_0201_5%  [R_0201]  306.67 24.51 0 top
RT5857  100K_0201_5%  [R_0201]  89.16 5.55 90 top
RV8  10_0402_1%  [R_0402]  251.13 56.62 0 top
RV11  100_0402_5%  [R_0402]  248.46 45.98 0 top
RV12  100K_0402_5%  [R_0402]  253.95 52.33 180 top
RV103  100K_0402_5%  [R_0402]  220.27 116.97 0 top
RV107  10K_0402_5%  [R_0402]  47.7 29.21 180 bottom
RV109  4.7K_0402_5%  [R_0402]  44.88 29.21 0 bottom
RV110  0_0402_1%  [R0402_0OHM]  49.15 28.7 90 bottom
RV111  100K_0402_5%  [R_0402]  254.26 45.85 180 top
RV112  10_0402_1%  [R_0402]  222.84 116.97 180 top
RV113  0_0201_5%  [R0201_0OHM]  50.55 29.21 180 bottom
RV114  100K_0402_5%  [R_0402]  51.44 29.21 270 bottom
RV119  270K_0402_5%  [R_0402]  41.4 34.21 90 top
RV120  47K_0402_5%  [R_0402]  40.51 35.13 270 top
RV135  220K_0402_5%  [R_0402]  36.36 34.65 270 top
RV325  1.8K_0402_5%  [R_0402]  200.32 49.37 270 top
RV326  1.8K_0402_5%  [R_0402]  201.12 49.37 270 top
RV399  10K_0402_5%  [R_0402]  246.84 48.96 270 top
RV520  0_0201_5%  [R0201_0OHM]  62.61 28.79 90 bottom
RV521  0_0201_5%  [R0201_0OHM]  63.25 28.79 90 bottom
RV522  0_0201_5%  [R0201_0OHM]  64.9 28.79 90 bottom
RV523  0_0201_5%  [R0201_0OHM]  65.53 28.79 90 bottom
RV524  0_0201_5%  [R0201_0OHM]  66.17 28.79 90 bottom
RV525  0_0201_5%  [R0201_0OHM]  66.8 28.79 90 bottom
RV526  0_0201_5%  [R0201_0OHM]  67.57 28.79 90 bottom
RV527  0_0201_5%  [R0201_0OHM]  68.2 28.79 90 bottom
RV528  0_0201_5%  [R0201_0OHM]  61.98 28.79 90 bottom
RV529  0_0201_5%  [R0201_0OHM]  61.34 28.79 90 bottom
RV530  8.2_0201_1%  [R_0201]  17.69 84.33 180 top
RV531  8.2_0201_1%  [R_0201]  17.69 84.96 180 top
RV532  8.2_0201_1%  [R_0201]  17.69 88.47 180 top
RV533  8.2_0201_1%  [R_0201]  17.69 87.89 180 top
RV534  8.2_0201_1%  [R_0201]  16.8 86.65 180 top
RV535  8.2_0201_1%  [R_0201]  16.8 86.07 180 top
RV536  8.2_0201_1%  [R_0201]  16.8 83.06 180 top
RV537  8.2_0201_1%  [R_0201]  16.8 82.42 180 top
RV538  150_0201_1%  [R_0201]  16.51 84.88 270 top
RV539  150_0201_1%  [R_0201]  16.51 88.47 270 top
RV540  150_0201_1%  [R_0201]  15.62 86.65 270 top
RV541  150_0201_1%  [R_0201]  15.62 83.1 270 top
RV550  100K_0402_5%  [R_0402]  207.72 45.72 180 top
RV551  10K_0402_5%  [R_0402]  215.22 45.87 90 top
RV552  10K_0402_5%  [R_0402]  198.04 53.79 0 bottom
RV553  10K_0402_5%  [R_0402]  212.47 55.7 270 bottom
RV554  100K_0402_5%  [R_0402]  214.5 50.05 270 top
RV557  10K_0402_5%  [R_0402]  221.74 50.43 270 top
RV561  2.2K_0402_5%  [R_0402]  26.93 76.46 0 top
RV562  10K_0402_5%  [R_0402]  207.52 47.42 90 top
RV563  10K_0402_5%  [R_0402]  222.37 48.2 0 top
RV564  10K_0402_5%  [R_0402]  214.11 48.24 0 top
RV566  10K_0402_5%  [R_0402]  212.22 42.72 90 top
RV567  100K_0402_5%  [R_0402]  213.74 55.7 270 bottom
RV570  1.8K_0402_5%  [R_0402]  200.92 52.91 270 top
RV571  1.8K_0402_5%  [R_0402]  201.68 52.91 270 top
RV572  1.8K_0402_5%  [R_0402]  209.3 56.03 270 bottom
RV573  1.8K_0402_5%  [R_0402]  208.41 56.03 270 bottom
RV574  0_0402_5%  [R_0402]  213.45 81.34 90 top
RV575  0_0402_5%  [R_0402]  204.12 63.02 270 top
RV576  0_0402_5%  [R_0402]  203.33 63.01 270 top
RV577  0_0402_5%  [R_0402]  189.89 61.64 0 bottom
RV578  2.49K_0402_1%  [R_0402]  191.2 86.31 270 bottom
RV579  10K_0402_5%  [R_0402]  220.65 52.84 0 top
RV580  10K_0402_5%  [R_0402]  227.47 43.24 180 top
RV581  10K_0402_5%  [R_0402]  220.79 50.43 270 top
RV582  0_0402_5%  [R_0402]  199.26 61.83 0 top
RV587  0_0402_5%  [R_0402]  224.66 42.23 180 top
RV589  100K_0402_5%  [R_0402]  189.03 61.63 90 bottom
RV590  10K_0402_5%  [R_0402]  197.6 48.59 270 top
RV591  10K_0402_5%  [R_0402]  200.41 50.29 90 top
RV592  10K_0402_5%  [R_0402]  190.79 62.52 180 bottom
RV593  10K_0402_5%  [R_0402]  189.12 64.24 0 bottom
RV594  10K_0402_5%  [R_0402]  219.46 46.56 270 top
RV597  0_0603_5%  [R_0603]  199.02 65.34 315 top
RV600  40.2_0402_1%  [R_0402]  215.18 84.14 270 top
RV601  40.2_0402_1%  [R_0402]  216.84 83.33 180 top
RV602  60.4_0402_1%  [R_0402]  219.25 77.48 180 top
RV605  10K_0402_5%  [R_0402]  231.34 104.08 180 top
RV606  10K_0402_5%  [R_0402]  244.11 62.8 90 top
RV607  10K_0402_5%  [R_0402]  211.63 105.54 0 top
RV608  10K_0402_5%  [R_0402]  245.63 80.07 180 top
RV613  10K_0402_5%  [R_0402]  217.55 104.38 90 bottom
RV614  10K_0402_5%  [R_0402]  225.25 103.54 90 bottom
RV615  10K_0402_5%  [R_0402]  243.46 82.67 90 top
RV616  10K_0402_5%  [R_0402]  241.81 63.96 270 top
RV617  1K_0402_1%  [R_0402]  225.25 106.13 270 bottom
RV618  1K_0402_1%  [R_0402]  215.6 105.53 90 top
RV619  121_0402_1%  [R_0402]  239.35 103.38 180 top
RV620  121_0402_1%  [R_0402]  207.63 104.97 0 top
RV621  40.2_0201_1%  [R_0201]  238.56 104.27 0 top
RV622  40.2_0201_1%  [R_0201]  238.56 105.03 0 top
RV623  549_0402_1%  [R_0402]  225.17 108.9 180 top
RV624  931_0402_1%  [R_0402]  223.61 107.96 0 top
RV625  1.33K_0402_1%  [R_0402]  223.7 109.75 90 top
RV626  40.2_0201_1%  [R_0201]  205.18 105.03 180 top
RV627  40.2_0201_1%  [R_0201]  205.18 104.27 180 top
RV628  40.2_0201_1%  [R_0201]  244.34 56.57 270 top
RV629  40.2_0201_1%  [R_0201]  243.76 56.57 270 top
RV630  1K_0201_1%  [R_0201]  243.07 77.98 0 bottom
RV631  1K_0402_1%  [R_0402]  242.7 67.68 90 top
RV632  121_0402_1%  [R_0402]  244.97 88.66 90 top
RV633  121_0402_1%  [R_0402]  241.89 55.7 270 top
RV634  549_0402_1%  [R_0402]  245.23 96.84 0 top
RV635  931_0402_1%  [R_0402]  246.14 94.99 90 top
RV636  1.33K_0402_1%  [R_0402]  247.06 94.94 0 top
RV637  40.2_0201_1%  [R_0201]  243.23 90.08 90 top
RV638  40.2_0201_1%  [R_0201]  242.66 90.08 90 top
RV639  100K_0402_5%  [R_0402]  225.43 50.44 270 top
RV640  100K_0402_5%  [R_0402]  226.45 50.44 270 top
RV641  100K_0402_5%  [R_0402]  230.95 51.8 90 top
RV642  100K_0402_5%  [R_0402]  225.43 52.72 270 top
RV643  100K_0402_5%  [R_0402]  226.45 52.72 270 top
RV644  100K_0402_5%  [R_0402]  230 52.72 270 top
RV645  100K_0402_5%  [R_0402]  223.46 50.44 270 top
RV646  100K_0402_5%  [R_0402]  228.23 50.44 270 top
RV647  100K_0402_5%  [R_0402]  227.34 50.44 270 top
RV648  100K_0402_5%  [R_0402]  229.12 50.44 270 top
RV649  100K_0402_5%  [R_0402]  224.42 50.44 270 top
RV650  100K_0402_5%  [R_0402]  222.57 50.43 270 top
RV651  100K_0402_5%  [R_0402]  223.45 52.71 270 top
RV652  100K_0402_5%  [R_0402]  228.23 52.72 270 top
RV653  100K_0402_5%  [R_0402]  227.34 52.72 270 top
RV654  100K_0402_5%  [R_0402]  229.12 52.72 270 top
RV655  100K_0402_5%  [R_0402]  224.42 52.72 270 top
RV656  100K_0402_5%  [R_0402]  222.44 52.86 270 top
RV657  100K_0402_5%  [R_0402]  247.75 48.06 90 top
RV658  0_0603_5%  [R_0603]  204.46 44.46 135 top
RV1068  0_0603_5%  [R_0603]  201.63 67.93 270 top
RV1080  0_0402_5%  [R_0402]  231.9 51.8 90 top
RV1082  0_0402_5%  [R_0402]  218.44 46.56 270 top
RV1083  0_0402_5%  [R_0402]  216.33 45.59 0 top
RV1084  0_0402_5%  [R_0402]  219.46 43.13 270 top
RV1086  0_0402_5%  [R_0402]  228.99 47.15 270 top
RV1095  0_0201_5%  [R_0201]  164.31 118.58 180 bottom
RV1098  0_0201_5%  [R_0201]  184.21 113.16 0 bottom
RV1112  1.8K_0402_5%  [R_0402]  244.67 46.61 180 top
RV1128  1M_0402_5%  [R_0402]  175.11 111.52 0 top
RV1130  10K_0402_5%  [R_0402]  164.55 114.79 180 top
RV1131  0_0402_5%  [R_0402]  201 43.4 0 top
RV1132  0_0402_5%  [R_0402]  200.13 43.4 180 top
RV1133  100K_0402_5%  [R_0402]  242.37 43.44 180 top
RV1350  1M_0402_5%  [R_0402]  248.79 52.12 90 top
RV1807  0_0402_5%  [R_0402]  175.27 113.2 270 top
RV1808  10_0402_1%  [R_0402]  224.59 119.06 90 top
RV1809  100K_0402_5%  [R_0402]  165.55 119.52 270 top
RV1810  10_0402_1%  [R_0402]  168.97 119.52 270 top
RV1811  100_0402_5%  [R_0402]  254.64 42.17 180 top
RV1833  10M_0402_5%  [R_0402]  218.26 52.58 180 top
RV1834  100K_0402_5%  [R_0402]  199.21 52.83 0 top
RV1835  100K_0402_5%  [R_0402]  186.03 113.93 180 bottom
RV1836  10K_0402_5%  [R_0402]  186.64 116.71 180 top
RV1837  100K_0402_5%  [R_0402]  215.65 55.75 270 bottom
RV1838  100K_0402_5%  [R_0402]  212.14 48.13 0 top
RV1839  10K_0402_5%  [R_0402]  213.87 45.52 90 top
RV1840  100K_0402_5%  [R_0402]  210.08 55.09 90 bottom
RV1841  100K_0402_5%  [R_0402]  198.48 52.83 180 top
RV1842  10K_0402_5%  [R_0402]  221.87 46.05 270 top
RV1843  0_0201_5%  [R0201_0OHM]  66.77 33.96 180 top
RV1844  10K_0402_5%  [R_0402]  204.09 48.08 270 top
RV1845  0_0402_1%  [R0402_0OHM]  18.67 58.17 180 bottom
RZ18  0_0603_5%  [R0603_0OHM]  57.41 3.43 0 top
RZ28  0_0603_5%  [R0603_0OHM]  348.43 37.01 180 bottom
RZ32  100K_0402_5%  [R_0402]  194.95 7.58 270 top
RZ37  0_0603_5%  [R0603_0OHM]  52.58 27.84 90 bottom
RZ38  100K_0402_5%  [R_0402]  78.93 2.43 270 bottom
RZ39  100K_0402_5%  [R_0402]  339.35 62.36 270 bottom
RZ40  100K_0402_5%  [R_0402]  63.37 28.37 90 top
RZ41  100K_0402_5%  [R_0402]  288.24 22.23 180 top
RZ43  100K_0402_5%  [R_0402]  264.16 39.71 270 top
RZ46  100K_0402_5%  [R_0402]  58.55 8.89 180 top
RZ50  100K_0201_5%  [R_0201]  108.84 45.99 270 top
RZ58  0_0201_5%  [R0201_0OHM]  107.89 45.4 90 top
RZ59  0_0402_5%  [R_0402]  111.76 54.8 0 top
RZ60  0_0402_1%  [R0402_0OHM]  114.08 49.9 0 top
RZ61  0_0402_5%  [R_0402]  120.09 51.32 90 top
RZ71  100K_0402_5%  [R_0402]  115.04 50.71 90 top
RZ72  0_0402_5%  [R_0402]  190.2 42.8 180 top
RZ81  0_0402_5%  [R_0402]  120.07 57.28 0 top
RZ82  0_0402_5%  [R_0402]  122.56 58.28 90 top
RZ84  100K_0402_5%  [R_0402]  120.51 61.11 180 top
RZ86  100K_0402_5%  [R_0402]  114.03 50.71 90 top
RZ87  100K_0402_5%  [R_0402]  119.51 65.86 270 top
RZ91  0_0402_1%  [R0402_0OHM]  105.33 54.99 0 top
RZ106  0_0402_5%  [R_0402]  251.61 42.04 0 top
RZ1133  0_0402_5%  [R_0402]  58.55 8.13 180 top
RZ1136  0_0603_5%  [R0603_0OHM]  313.63 13.21 180 top
RZ1138  0_0603_5%  [R0603_0OHM]  165.37 8.99 180 top
RZ1141  0_0402_5%  [R_0402]  333.3 45.85 0 bottom
RZ1142  0_0402_5%  [R_0402]  336.37 46.48 180 bottom
RZ1148  0_0603_5%  [R0603_0OHM]  275.4 4.19 0 top
RZ1149  100K_0402_5%  [R_0402]  80.01 6.17 270 top
RZ1150  100K_0201_5%  [R_0201]  20.84 52.06 270 top
RZ1151  100K_0201_5%  [R_0201]  175.72 5.46 0 top
RZ1153  0_0402_5%  [R_0402]  106.94 48.97 270 top
RZ1951  2.2K_0402_5%  [R_0402]  245.63 11.33 180 top
RZ1952  0_0402_5%  [R_0402]  127.99 13.98 90 top
RZ1953  0_0201_1%  [R_0201]  109.73 45.4 90 top
RZ1954  0_0402_5%  [R_0402]  107.01 55.88 180 top
RZ1955  0_0402_5%  [R_0402]  120.41 58.39 90 bottom
RZ1956  0_0402_5%  [R_0402]  234.7 4.88 90 top
RZ1957  0_0402_5%  [R_0402]  121.19 58.39 90 bottom
RZ1958  100K_0402_5%  [R_0402]  238.7 4.81 90 top
RZ1960  0_0603_5%  [R0603_0OHM]  320.49 26.93 180 bottom
RZ1964  0_0402_5%  [R_0402]  247.02 53.04 270 top
RZ1965  0_0402_5%  [R_0402]  106.94 49.77 90 top
RZ1966  100K_0402_5%  [R_0402]  123.83 67.87 90 top
SW1  SKRBAAE010_4P  [SW_SKRBAAE010_4P]  336.54 114.75 90 top
SW2  NTC311-EA1T-A160T_4P  [SW_NTC311-EA1T-A160T_4P]  348.63 110.83 90 top
SW4  SSAL120100_3P  [SW_SSAL120100_3P]  114 4.76 0 top
SW_BOT  SKRBAAE010_4P  [SW_SKRBAAE010_4P]  329.39 30.49 0 bottom
T2  PAD~D  [TPC12]  80.91 11.51 0 top
T4  PAD~D  [TPC12]  67.21 21.24 180 bottom
T8  PAD~D  [TPC12]  69.48 16.99 180 bottom
T17  PAD~D  [TPC12]  81.98 2.66 180 bottom
T20  PAD~D  [TPC12]  80.1 2.64 180 bottom
T39  PAD~D  [TPC12]  176.63 59.86 0 top
T40  PAD~D  [TPC12]  175.63 60.67 0 top
T41  PAD~D  [TPC12]  175.4 59.12 0 top
T42  PAD~D  [TPC12]  176.53 58.55 0 top
T43  PAD~D  [TPC12]  137.29 59.21 0 top
T44  PAD~D  [TPC12]  137.43 60.57 0 top
T45  PAD~D  [TPC12]  138.6 84.79 0 top
T46  PAD~D  [TPC12]  172.91 74.87 0 top
T47  PAD~D  [TPC12]  174.83 77.17 0 top
T48  PAD~D  [TPC12]  138.74 83.19 0 top
T49  PAD~D  [TPC12]  140.59 84.46 0 top
T50  PAD~D  [TPC12]  169.74 81.43 0 top
T51  PAD~D  [TPC12]  168.16 68.03 0 top
T52  PAD~D  [TPC12]  159.38 79.68 0 top
T53  PAD~D  [TPC12]  162.61 68.71 0 top
T57  PAD~D  [TPC12]  173.86 82.28 0 top
T58  PAD~D  [TPC12]  180.21 81.73 180 bottom
T59  PAD~D  [TPC12]  178.41 83.87 0 top
T60  PAD~D  [TPC12]  176.95 81.69 0 top
T61  PAD~D  [TPC12]  174.21 59.58 0 top
T62  PAD~D  [TPC12]  174.17 60.87 0 top
T63  PAD~D  [TPC12]  133.31 86.23 180 bottom
T64  PAD~D  [TPC12]  138.58 81.87 0 top
T65  PAD~D  [TPC12]  143.28 81.57 0 top
T66  PAD~D  [TPC12]  140.92 80.6 0 top
T67  PAD~D  [TPC12]  141.97 79.62 0 top
T82  PAD~D  [TPC12]  141.62 82.34 0 top
T83  PAD~D  [TPC12]  157.05 64.89 0 top
T84  PAD~D  [TPC12]  173.64 69.86 0 top
T85  PAD~D  [TPC12]  179.93 91.9 180 bottom
T86  PAD~D  [TPC12]  175.15 55.72 180 bottom
T87  PAD~D  [TPC12]  136.04 59.69 0 top
T88  PAD~D  [TPC12]  136.09 58.4 0 top
T89  PAD~D  [TPC12]  181.33 91.9 180 bottom
T90  PAD~D  [TPC12]  176.12 56.54 180 bottom
T91  PAD~D  [TPC12]  68.81 20.64 180 bottom
T92  PAD~D  [TPC12]  70.22 21.55 180 bottom
T94  PAD~D  [TPC12]  68.33 22.82 180 bottom
T121  PAD~D  [TPC12]  90.3 9.77 0 top
T124  PAD~D  [TPC12]  82.12 5.11 0 top
T185  PAD~D  [TPC12]  19.69 53.15 0 bottom
T191  PAD~D  [TPC12]  24.97 52.52 0 bottom
T192  PAD~D  [TPC12]  24.79 53.81 0 bottom
T193  PAD~D  [TPC12]  22.12 59.01 180 top
T194  PAD~D  [TPC12]  22.81 56.9 180 top
T196  PAD~D  [TPC12]  31.31 44.5 0 top
T197  PAD~D  [TPC12]  30 44.79 0 top
T198  PAD~D  [TPC12]  28.69 44.87 0 top
T199  PAD~D  [TPC12]  33.17 42.75 0 top
T201  PAD~D  [TPC12]  184.46 62.55 180 bottom
T202  PAD~D  [TPC12]  186.3 62.75 180 bottom
T203  PAD~D  [TPC12]  192.43 66.35 180 bottom
T204  PAD~D  [TPC12]  191.83 65.11 180 bottom
T205  PAD~D  [TPC12]  217.09 61.85 0 top
T210  PAD~D  [TPC12]  212.85 46.1 0 top
T4936  PAD~D  [TPC12]  27.31 68.54 0 top
T4937  PAD~D  [TPC12]  25.95 69.06 0 top
T4943  PAD~D  [TPC12]  69.46 24.87 180 bottom
T4944  PAD~D  [TPC12]  69.46 23.56 180 bottom
T4945  PAD~D  [TPC12]  84.3 5.63 0 top
T4947  PAD~D  [TPC12]  82.36 11.57 0 top
T4948  PAD~D  [TPC12]  296.56 13.68 180 bottom
T4949  PAD~D  [TPC12]  104.01 9.51 180 bottom
T4950  PAD~D  [TPC12]  92.41 20.35 0 top
T4951  PAD~D  [TPC12]  93.73 20.54 0 top
T4952  PAD~D  [TPC12]  97.84 20.71 0 top
T4953  PAD~D  [TPC12]  93.33 17.72 0 top
T4954  PAD~D  [TPC12]  92.3 16.35 0 top
T4955  PAD~D  [TPC12]  81.43 19.23 0 top
T4956  PAD~D  [TPC12]  82.73 19.28 0 top
T4957  PAD~D  [TPC12]  85.5 20.6 0 top
T4958  PAD~D  [TPC12]  84.02 20.07 0 top
T4959  PAD~D  [TPC12]  92.46 13.59 0 top
T4960  PAD~D  [TPC12]  93.32 14.57 0 top
T4961  PAD~D  [TPC12]  103.73 8 180 bottom
T4962  PAD~D  [TPC12]  82.63 16.6 0 top
T4963  PAD~D  [TPC12]  82.55 17.91 0 top
T4964  PAD~D  [TPC12]  92.97 19.18 0 top
T4965  PAD~D  [TPC12]  154.73 69.67 0 top
T4966  PAD~D  [TPC12]  154.89 79.92 0 top
T4967  PAD~D  [TPC12]  149.84 67.98 0 top
T4968  PAD~D  [TPC12]  147.91 68.34 0 top
T4969  PAD~D  [TPC12]  151.66 68.06 0 top
T4970  PAD~D  [TPC12]  149.06 69.05 0 top
T4971  PAD~D  [TPC12]  139.91 81.46 0 top
T4972  PAD~D  [TPC12]  136.73 82.34 0 top
T4973  PAD~D  [TPC12]  211.71 60.83 0 top
T4974  PAD~D  [TPC12]  211 55.68 180 bottom
T4975  PAD~D  [TPC12]  213.74 63.5 0 top
T4976  PAD~D  [TPC12]  210.24 57.93 0 top
T4977  PAD~D  [TPC12]  211.34 54.94 180 bottom
T4978  PAD~D  [TPC12]  211.71 62.47 0 top
T4979  PAD~D  [TPC12]  213.87 59.31 0 top
T4980  PAD~D  [TPC12]  207.53 58.01 0 top
T4982  PAD~D  [TPC12]  298.59 8.65 0 top
T4988  PAD~D  [TPC12]  87.78 11.04 0 top
T4989  PAD~D  [TPC12]  88.69 8.47 0 top
T4991  PAD~D  [TPC12]  199.25 79.41 0 top
T4992  PAD~D  [TPC12]  197.88 79.54 0 top
T4993  PAD~D  [TPC12]  200.36 68.48 0 top
T4994  PAD~D  [TPC12]  201.68 77.95 0 top
T4995  PAD~D  [TPC12]  210.27 59.82 0 top
T4996  PAD~D  [TPC12]  210.01 62.14 0 top
T5003  PAD~D  [TPC12]  89.09 13.49 90 top
T5004  PAD~D  [TPC12]  87.91 12.74 0 top
T5990  PAD~D  [TPC12]  76.24 20.14 0 top
T5991  PAD~D  [TPC12]  91.82 6.3 0 top
T5992  PAD~D  [TPC12]  91.64 11.39 0 top
T5994  PAD~D  [TPC12]  67.37 36.63 0 top
T5995  PAD~D  [TPC12]  66.03 36.63 0 top
T5996  PAD~D  [TPC12]  313.69 23.24 0 top
T5997  PAD~D  [TPC12]  312.42 23.24 0 top
T5998  PAD~D  [TPC12]  312.42 25.53 0 top
T5999  PAD~D  [TPC12]  313.95 21.21 0 top
T6000  PAD~D  [TPC12]  298.58 11.75 180 bottom
T6002  PAD~D  [TPC12]  87.76 7.11 0 top
T6003  PAD~D  [TPC12]  271.4 7.24 0 top
T6004  PAD~D  [TPC12]  276.1 13.72 0 top
TC287  PAD~D  [TPC12]  131.93 95.15 0 top
TV3  PAD~D  [TPC12]  234.86 110.1 0 top
TV4  PAD~D  [TPC12]  208.37 110.61 0 top
TV5  PAD~D  [TPC12]  250.19 87.48 0 top
TV6  PAD~D  [TPC12]  248.53 59.37 0 top
U32  -  [NPCT750JAAYX_QFN32_5X5]  156.73 6 180 top
U33  -  [SLG4U41821VTR_STQFN20_2X3]  204.08 52.1 0 top
UA1  -  [ALC3266-CG_QFN56_7X7]  11.24 35.28 90 bottom
UA3  -  [APE8937GN2_DFN8_2X2]  5.84 12.24 180 bottom
UA4  -  [EM5209VF_DFN14_3X2]  8.29 6.05 0 top
UC1  -  [74AUP1G07GW_TSSOP5]  124.85 53.71 90 top
UE2  APX8132AI-TRG SOT-23 3P  [AH1806-W-7_SC59-3]  347.25 120.28 90 top
UE3  MEC5105K_D2_TN_TR_WFBGA_169P  [MEC5105_WFBGA_169P]  294.16 10.57 90 top
UE5  -  [74AUP1G07SE-7_SOT353-5]  306.82 3.37 0 top
UE6  -  [APE8937GN2_DFN8_2X2]  191.61 5.84 0 top
UE7  -  [74AUP1G07SE-7_SOT353-5]  121.53 61.28 0 top
UF1  -  [LNG2DMTR_LGA12_2X2]  237.36 47.5 180 top
UH1  CFL-H_BGA1440  [CFL-H_BGA_1440P-T]  178.08 60.24 270 bottom
UH2  CNP-H_BGA874  [CNP-H_BGA_874P-T]  99.06 27.21 180 bottom
UH7  -  [MC74VHC1G08DFT2G_SC70-5]  67.44 3.3 270 bottom
UH8  W25Q256JVEIQ_WSON8  [W25Q256FVEIG_WSON8]  68.78 10.42 270 bottom
UH14  -  [MC74VHC1G08DFT2G_SC70-5]  59.76 3.44 90 bottom
UI1  -  [TPS2546RTER_QFN16_3X3]  27.04 97.77 180 bottom
UI2  -  [TPS2546RTER_QFN16_3X3]  330.57 62.71 180 bottom
UI3  -  [PS8713BTQFN24GTR2_TQFN24_4X4]  320.68 36.79 270 top
UI4  MC74VHC1G32DFT2G_SC70-5~D  [MC74VHC1G32DFT2G_SC70-5]  21.46 103.76 270 bottom
UI5  MC74VHC1G32DFT2G_SC70-5~D  [MC74VHC1G32DFT2G_SC70-5]  324.71 51.76 0 top
UM1  S IC PS175HDMBGA64GTR2-B2 TFBGA 64P  [PS175HDMBGA64GTR2-A0_TFBGA_64P]  25.15 70.61 180 top
UM2  -  [W25X20CLSNIG_SO8]  27.6 95.76 270 bottom
UN3  -  [APE8937GN2_DFN8_2X2]  337.94 102.86 90 top
UR1  -  [RTS5242-GR_QFN32_4X4]  341.38 35.54 90 bottom
UT1  ALPINE-RIDGE_BGA337  [ALPINE-RIDGE_BGA_337P]  21.97 44.96 270 bottom
UT2  -  [W25Q80DVZPIG_WSON8]  39.63 32.16 0 bottom
UT4  SN1703018ZQZR_BGA96  [TPS65982_BGA_96P]  20.61 55.37 0 bottom
UT5  -  [W25Q80DVZPIG_WSON8]  40.31 29.77 270 top
UV16  -  [AP2330W-7_SC59-3]  19.11 91.95 270 top
UV18  N17P-GT_BGA908  [N15P-GT_BGA_908P]  222.04 58.6 90 bottom
UV19  TC7SZ08FU_SSOP5  [MC74VHC1G08DFT2G_SC70-5]  226.62 44.33 0 top
UV20  TC7SZ08FU_SSOP5  [TC7SH08FU_SSOP5]  197.78 44.43 0 top
UV23  K4G80325FB-HC03_FBGA170~D  [H5GQ1H24AFR-T2L_BGA_170P]  227.61 98.08 0 bottom
UV24  K4G80325FB-HC03_FBGA170~D  [H5GQ1H24AFR-T2L_BGA_170P]  215.15 110.88 180 bottom
UV25  K4G80325FB-HC03_FBGA170~D  [H5GQ1H24AFR-T2L_BGA_170P]  236.52 66.61 270 bottom
UV26  K4G80325FB-HC03_FBGA170~D  [H5GQ1H24AFR-T2L_BGA_170P]  249.32 80.33 90 bottom
UV28  TC7SZ08FU_SSOP5  [MC74VHC1G08DFT2G_SC70-5]  172.19 112.35 270 top
UV29  TC7SZ08FU_SSOP5  [TC7SH08FU_SSOP5]  222.52 44.13 180 top
UZ1  -  [EM5209VF_DFN14_3X2]  262.38 37.72 90 top
UZ4  -  [APE8937GN2_DFN8_2X2]  56.44 6.75 180 top
UZ5  -  [APE8937GN2_DFN8_2X2]  340.79 61.42 90 bottom
UZ6  MC74VHC1G32DFT2G_SC70-5~D  [MC74VHC1G32DFT2G_SC70-5]  236.73 4.83 90 top
UZ8  -  [SY6288C20AAC_SOT23-5]  55.32 30.41 270 top
UZ9  -  [TPS22961DNYR_WSON8]  182.36 83.07 90 bottom
UZ12  -  [MC74VHC1G08DFT2G_SC70-5]  118.35 53.27 180 top
UZ15  -  [TPS22961DNYR_WSON8]  181.57 85.27 180 top
UZ16  -  [TPS22961DNYR_WSON8]  186.1 43.23 0 top
UZ19  -  [MC74VHC1G08DFT2G_SC70-5]  120.24 58.23 0 top
UZ20  -  [MC74VHC1G08DFT2G_SC70-5]  112.67 53.78 180 top
UZ21  -  [MC74VHC1G08DFT2G_SC70-5]  111.01 50.71 270 top
UZ22  -  [MC74VHC1G08DFT2G_SC70-5]  122.74 65.14 90 top
UZ23  -  [MC74VHC1G08DFT2G_SC70-5]  105.99 53.86 270 top
UZ24  -  [APE8937GN2_DFN8_2X2]  208.39 50.68 270 top
UZ25  -  [APE8937GN2_DFN8_2X2]  13.98 65.82 0 bottom
UZ26  TC7SZ08FU_SSOP5  [MC74VHC1G08DFT2G_SC70-5]  108.52 48.23 0 top
UZ29  -  [APE8937GN2_DFN8_2X2]  126.62 13.97 90 top
UZ30  -  [APE8937GN2_DFN8_2X2]  245.2 51.45 90 top
UZ31  -  [MC74VHC1G08DFT2G_SC70-5]  251.65 50.53 90 top
UZ32  -  [APE8937GN2_DFN8_2X2]  275.45 10.69 180 top
UZ33  -  [APE8937GN2_DFN8_2X2]  231.76 10.72 270 top
YE1  32.768KHZ_9PF_9H03200033  [Y_CM7V-12520_2P]  288.93 9.17 90 top
YH1  32.768KHZ_X1A000141000300  [Y_CM31532768DZFT_2P]  69.36 2.92 0 bottom
YH2  24MHZ_12PF_8Y24000034  [Y_8Y24000034_4P]  105.58 16.95 90 top
YM1  27MHZ_10PF_XRCGB27M000F2P18R0  [Y_8Y24000034_4P]  13.73 73.82 0 top
YT1  25MHZ_20PF_XRCGB25M000F2P18R0  [Y_8Y24000034_4P]  21.21 32.77 270 bottom
YV1  27MHZ_10PF_XRCGB27M000F2P18R0  [Y_8Y24000034_4P]  218.44 50.39 180 top

## Library data of the parts
ADP100 = ACES_50290-00701-001_7P-T
BAT100 = ACES_50290-01201-P01_12P-T
C2 C4 C135 C280 C1031 C1080 C3003 C3004 C3319 CA1 CA3 CA5 CA8 CA10 CA12 CA16 CA17 CA19 CA23 CA24 CA26 CA28 CA32-CA38 CA40 CA120-CA122 CA124-CA127 CA130 CD3324 CD3325 CE75 CE84 CE85 CH200 CH203-CH205 CH207 CH3320-CH3324 CH3329 CH3331-CH3333 CM1 CM3-CM8 CM10-CM22 CM24-CM26 CM28-CM33 CM35 CM37-CM41 CM45 CM46 CM50 CT25 CT141-CT143 CT145 CT163 CT174-CT187 CV818-CV849 CV857 CV858 CV925 CV928 CV987 CV990 CZ100 CZ101 CZ2157 PC218 PC221 PC502 PC725 PC801 PC902 PC1601 PC2004-PC2009 PC2029-PC2038 PC2042-PC2085 = C_0201
C3 C267 C1033 C1079 C3005 C3320 C3321 CA2 CA4 CA6 CA7 CA9 CA11 CA13-CA15 CA18 CA20 CA21 CA25 CA27 CA29-CA31 CA39 CA41-CA45 CA77 CA78 CA119 CA128 CA129 CA131 CD3326-CD3328 CE2 CE72-CE74 CE77-CE82 CE1501 CE3319 CE3321-CE3323 CH92 CH201 CH202 CH206 CH3327 CH3334 CI3-CI8 CI16 CI20-CI22 CM2 CM9 CM23 CM27 CM34 CM43 CM44 CT144 CT146 CT151 CT152 CT158-CT160 CT189 CV499 CV794 CV796 CV817 CV850-CV856 CV859 CV860 CV862 CV865 CV866 CV871 CV874-CV877 CV885-CV894 CV898-CV906 CV917-CV923 CV926 CV927 CV929-CV936 CV948-CV957 CV969-CV986 CV988 CV989 CV991-CV998 CV1010-CV1019 CV1031-CV1048 CV1050 CV1051 CZ96-CZ99 CZ104-CZ106 CZ588 CZ1501 CZ2155 CZ2156 PC106-PC110 PC114 PC115 PC200 PC204-PC210 PC212-PC217 PC219 PC222 PC223 PC401-PC405 PC407 PC408 PC415 PC416 PC418 PC500 PC501 PC505 PC506 PC511 PC512 PC603 PC604 PC609 PC612-PC614 PC700 PC701 PC704-PC707 PC709-PC716 PC800 PC802 PC805 PC806 PC811 PC812 PC900 PC901 PC905 PC906 PC911 PC912 PC1003-PC1005 PC1015 PC1017 PC1018 PC1030-PC1041 PC1045 PC1046 PC1049 PC1050 PC1054 PC1055 PC1100 PC1101 PC1103-PC1139 PC1201 PC1213 PC1214 PC1237 PC1238 PC1253 PC1254 PC1277 PC1289 PC1291 PC1308 PC1313 PC1317 PC1319 PC1337 PC1345 PC1346 PC1355 PC1357 PC1364 PC1501 PC1504 PC1508 PC1510 PC1511 PC1515-PC1518 PC1520 PC1522 PC1531 PC1532 PC1600 PC1603 PC1605 PC1606 PC1611 PC1612 PC1800 PC1802 PC1804 PC1910-PC1912 PC1923-PC1925 PC1927 PC1928 PC1932-PC1945 = C_0402
CD1-CD4 CD12 CD16-CD18 CD69 CD74-CD79 = C_0402: room: DIMMA
CD5-CD10 CD13-CD15 CD70-CD73 = C_0603: room: DIMMA
CD11 = C_EEFSS0D221R: room: DIMMA
CD19-CD22 CD29-CD32 CD34 CD35 CD80-CD83 = C_0402: room: DIMMB
CD23-CD28 CD84-CD90 = C_0603: room: DIMMB
CD33 = C_EEFSS0D221R: room: DIMMB
CD36 = C_0603: room: NGFF SSD
CD37-CD46 CD51 CD53 = C_0402: room: NGFF SSD
CE11 = C_0201: room: TPM
CE15 CE16 = C_0201: room: LID
CE17 CE18 CE20 CE23-CE27 CE29-CE39 CE42 CE44 CE48 CE51 CE70 CE71 = C_0402: room: EC5085
CE19 CE22 CE40 = C_0603: room: EC5085
CE41 CE45-CE47 CE49 CE50 CE52 CE68 CE69 = C_0402: room: THERMAL
CE43 = C_0201: room: EC5085
CE65 = C_0402: room: TOUCH PAD
CE66 CE67 = C_0402: room: FAN
