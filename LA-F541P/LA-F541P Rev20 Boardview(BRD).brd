# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3V_ROM on IN3 (solid shape): 84.01,1.53 84.01,1.14 83.88,1.02 81.85,1.02 81.73,1.14 81.73,1.53 82.51,1.53 82.51,1.48 82.52,1.42 82.54,1.37 82.56,1.32 82.59,1.28 82.63,1.24 82.67,1.21 82.71,1.18 82.76,1.16 82.82,1.15 82.87,1.15 82.92,1.15 82.97,1.16 83.02,1.18 83.07,1.21 83.11,1.24 83.15,1.28 83.18,1.32 83.2,1.37 83.22,1.42 83.22,1.48 83.22,1.53 83.22,1.58 83.2,1.63 83.18,1.68 83.15,1.72 83.11,1.76 83.07,1.8 83.02,1.82 82.97,1.84 82.92,1.85 82.87,1.86 82.82,1.85 82.76,1.84 82.71,1.82 82.67,1.8 82.63,1.76 82.59,1.72 82.56,1.68 82.54,1.63 82.52,1.58 82.51,1.53 81.73,1.53 81.73,1.56 81.96,1.8 82.38,2.22 83.31,2.22
+3V_ROM on BOTTOM: 112.24,6.22 111.48,6.22 111.42,6.29 111.42,7.02 111.29,7.15 110.87,7.15 110.66,6.94 110.66,4.95 110.44,4.74 109.86,4.74 109.73,4.61 109.73,3.77 109.23,3.28 109.23,2.11 109.07,1.94 108.32,1.94 107.94,2.33 107.94,4.86 108.89,5.81 108.89,7.29 109.47,7.87 112.11,7.87 112.24,7.73
+3V_TBT on BOTTOM: 17.53,41.46 17.53,41.78 17.21,42.1 16.43,42.1 16.32,42.21 16.32,42.77 16.32,42.77 16.32,43.83 16.77,44.28 17.31,44.28 17.46,44.44 17.46,45.48 17.54,45.56 18.55,45.56 18.66,45.68 18.66,45.89 18.82,46.05 19.16,46.05 19.45,45.76 20.06,45.76 20.28,45.54 20.29,45.54 21.22,44.62 22.13,44.62 22.17,44.57 22.17,44.4 22.32,44.26 22.54,44.26 22.68,44.12 22.68,43.95 22.6,43.88 22.37,43.88 22.31,43.93 21.81,43.93 21.65,43.77 20.77,43.77 20.13,44.41 18.66,44.41 18.34,44.08 18.34,41.57 18.34,41.5 18.22,41.38 17.61,41.38
+3V_TBT on IN3: 24.9,40.63 21.06,40.63 19.97,41.72 19.97,44.57 20.33,44.92 21.61,44.92 22,45.31 23.56,45.31 23.74,45.13 23.74,44.8 22.62,43.67 22.62,42.34 22.99,41.97 24.71,41.97 25.02,41.66 25.02,40.76
+3V_TBT_S0 on TOP: 30.48,35.56 31.47,35.56 31.55,35.48 31.55,33.35 31.45,33.25 30.1,33.25 29.92,33.43 27.26,33.43 27.13,33.55 27.13,33.86 27.46,34.19 29.11,34.19
+3V_TBT_S0 on IN3: 30.58,39.24 31.93,37.9 31.93,36.75 30.05,34.88 30.05,33.71 29.82,33.48 26.67,33.48 26.29,33.86 26.29,35.23 27.13,36.07 27.89,36.07 28.3,36.48 28.3,39.07 28.47,39.24
+3V_VC on TOP: 16.89,28.39 16.89,27.94 16.51,27.56 16,27.56 15.88,27.43 15.88,26.16 15.62,25.91 15.11,25.91 14.99,26.04 14.99,26.67 15.24,26.93 15.24,28.45 15.49,28.7 15.94,29.14 16.92,29.14 17.11,28.95 17.11,28.61
+3V_VC on TOP: 62.15,16.22 62.53,15.84 62.53,14.97 62.49,14.92 62.49,14.86 62.23,14.61 60.96,14.61 60.81,14.76 60.81,17.23 59.89,18.15 59.89,19.44 60.08,19.63 60.67,19.63 62.01,18.29 62.01,17.39 62.15,17.25
+3V_VC on BOTTOM: 60.94,16.09 61.72,16.09 62.01,16.38 62.01,17.27 61.95,17.33 60.91,17.33 60.84,17.25 60.84,16.19
+3V_VC on BOTTOM: 54.34,15.24 56.74,15.24 56.86,15.11 56.86,14.61 56.77,14.51 56.4,14.51 56.2,14.31 56.2,13.75 56.15,13.69 54.73,13.69 54.31,14.12 54.31,15.21
+3V_VC on IN3: 57.86,22.4 58.93,22.4 62.38,18.94 62.38,16.87 61.98,16.46 57.63,16.46 55.72,18.37 54.54,18.37 52.03,20.88 52.03,21.7 52.23,21.91 53.49,21.91 53.95,22.36 57.83,22.36
+3VA_TBT on TOP: 23.42,49.01 23.74,48.69 24.59,48.69 24.79,48.89 24.79,50.33 24.75,50.37 24.75,51.13 25.22,51.6 25.52,51.6 25.88,51.97 25.88,52.34 26.53,52.98 27.56,52.98 27.99,53.41 27.99,54.09 27.42,54.66 27.42,55.03 27.02,55.43 26.27,55.43 26.16,55.32 26.16,53.67 26.06,53.57 25.15,53.57 24.9,53.32 24.14,53.32 24.14,53.32 23.65,53.32 23.21,53.76 23.05,53.76 23.04,53.75 22.42,53.75 22.2,53.96 21.43,53.96 21.23,53.77 21.23,52.02 21.77,51.48 21.77,49.42 22.18,49.01
+3VA_TBT on BOTTOM: 17.45,46.65 17.45,45.78 17.57,45.66 18.38,45.66 18.62,45.9 18.62,47.37 18.63,47.38 18.63,47.41 18.74,47.53 18.94,47.53 18.94,47.52 19.28,47.52 19.75,48 19.99,48 20.22,48.22 20.22,49.08 20.2,49.1 20.29,49.19 20.29,50.45 20.22,50.51 19.83,50.51 19.56,50.79 19.55,50.79 18.97,50.79 18.92,50.83 18.92,52.59 18.64,52.86 17.86,52.86 17.59,52.59 17.15,52.59 17.04,52.49 17.04,52.02 17.28,51.78 17.28,48.45 17.4,48.34 17.89,48.34 17.94,48.28 17.94,47.79 17.76,47.61 17.76,46.96
+3VA_TBT on IN1: 19.56,47.66 19.56,50.39 20.69,51.52 23.33,51.52 24.42,50.44 24.42,43.38 24.47,43.38 25.24,42.61 25.24,41.89 24.9,41.55 22.77,41.55 22.76,41.55 22.57,41.55 21.52,40.49 20.39,40.49 19.71,41.18 19.71,47.09 19.71,47.09 19.71,47.81 19.71,47.81
+3VA_TBT_LC on TOP: 35.59,42.57 35.07,42.57 34.89,42.39 34.89,42.06 34.84,42.01 34.48,42.01 34.37,42.12 34.37,43.17 34.25,43.3 34.25,44.72 34.32,44.78 34.64,44.78 34.71,44.85 35.11,44.85 35.11,44.85 36.06,44.85 36.37,44.54 36.37,44.26 35.65,43.54 35.65,42.63
+3VALW on TOP (solid shape): 11.48,5.71 11.99,5.71 12,5.7 12,5.32 11.7,5.01 10.94,5.01 10.18,5.77 10.18,6.34 10.26,6.42 10.76,6.42
+3VALW on TOP (solid shape): 59.51,6.73 59.51,5.73 59.48,5.68 59.45,5.62 59.3,5.46 58.79,5.46 58.79,5.46 58.64,5.31 57.2,5.31 57,5.51 57,5.88 56.58,6.3 55.96,6.3 55.8,6.45 55.8,7.09 55.88,7.16 59.08,7.16
+3VALW on TOP (solid shape): 339.53,102.49 341,102.49 341.25,102.24 341.25,101.6 340.93,101.28 339.14,101.28 339.05,101.2 339.05,100.67 338.96,100.59 338.72,100.59 338.72,100.59 338.52,100.79 338.52,101.92 338.11,102.32 337.77,102.32 337.52,102.58 337.52,103.42 337.6,103.5 338.52,103.5
+3VALW on TOP (solid shape): 323.49,28.94 323.49,27.94 324.34,27.09 324.34,26.84 324.36,26.83 324.36,26.3 323.82,26.3 323.81,26.29 323.81,25.56 323.82,25.55 324.36,25.55 324.36,25.1 324.36,25.1 323.82,25.1 323.81,25.08 323.81,24.37 323.83,24.35 323.87,24.35 324.36,24.35 324.37,24.34 324.37,23.88 323.53,23.04 321.21,23.04 320.91,23.35 320.91,25.34 321.23,25.34 321.23,25.29 321.24,25.24 321.25,25.18 321.27,25.14 321.3,25.09 321.34,25.05 321.38,25.02 321.43,24.99 321.48,24.97 321.53,24.96 321.58,24.96 321.64,24.96 321.69,24.97 321.74,24.99 321.78,25.02 321.83,25.05 321.86,25.09 321.89,25.14 321.92,25.18 321.93,25.24 321.94,25.29 321.94,25.34 321.93,25.39 321.92,25.44 321.89,25.49 321.86,25.54 321.83,25.58 321.78,25.61 321.74,25.64 321.69,25.66 321.64,25.67 321.58,25.67 321.53,25.67 321.48,25.66 321.43,25.64 321.38,25.61 321.34,25.58 321.3,25.54 321.27,25.49 321.25,25.44 321.24,25.39 321.23,25.34 320.91,25.34 320.91,27.81 320.94,27.84 320.94,27.95 322.31,29.32 323.12,29.32
+3VALW on IN4 (solid shape): 258.26,20.07 258.26,19.69 258.19,19.62 258.19,18.61 257.94,18.35 257.11,18.35 256.73,18.73 256.73,19.62 257.56,20.45 257.87,20.45
+3VALW on TOP: 346.63,86.9 346.06,86.9 346,86.84 346,86.62 346.01,86.61 346.01,86.26 345.88,86.13 345.57,86.13 345.05,86.65 344.35,86.65 343.75,87.25 343.21,87.25 341.55,88.91 340.98,88.91 340.55,88.47 340.55,88.04 340.55,88.04 340.55,87.8 341.58,86.77 341.58,86.39 342.02,85.95 342.81,85.95 343.04,85.72 343.04,84.75 343.29,84.5 345.03,84.5 345.22,84.69 345.22,84.69 345.99,84.69 346.01,84.66 346.01,83.72 346.16,83.58 346.43,83.58 346.68,83.83 346.68,84.53 346.84,84.68 346.84,84.7 346.88,84.75 347.45,84.75 347.55,84.65 348.29,84.65 348.4,84.55 348.4,84.35 348.51,84.24 348.54,84.24 348.54,83.78 348.72,83.61 349.07,83.61 349.22,83.76 349.22,86.12 349.06,86.29 348.57,86.29 348.27,85.99 347.54,85.99
+3VALW on TOP: 141.66,13.82 141.19,13.34 141.19,12.29 140.04,11.14 137.56,11.14 137.16,11.55 137.16,11.56 137.16,12.7 137.42,12.96 139.32,12.96 140.21,13.84 140.21,15.11 140.46,15.37 141.48,15.37 141.66,15.19
+3VALW on TOP: 324.94,54.29 324.28,54.29 323.67,53.68 323.67,52.41 323.81,52.27 324.42,52.27 324.94,52.79 324.94,52.91 325.03,53 325.03,54.2
+3VALW on TOP: 276.1,9.91 275.72,10.29 274.96,10.29 274.83,10.42 274.83,11.56 274.58,11.81 274.38,11.81 274.07,11.49 274.07,10.35 274,10.29 273.88,10.29 273.81,10.35 273.81,10.92 273.31,11.43 273.31,12.26 273.88,12.83 275.46,12.83 275.85,12.45 276.99,12.45 277.24,12.19 277.24,10.08 277.07,9.91
+3VALW on TOP: 75.1,33.16 75.79,33.16 76.4,33.77 77.2,33.77 78.22,34.79 79.63,34.79 80.77,33.64 80.77,32.81 80.46,32.49 80.46,31.55 80.49,31.51 81.84,31.51 82.03,31.7 82.03,33.85 80.23,35.65 76.29,35.65 74.78,34.14 74.78,33.48
+3VALW on TOP: 191.26,6.35 192.15,6.35 192.28,6.22 192.28,4.95 192.79,4.45 192.79,4.32 192.66,4.19 191.26,4.19 191.01,4.45 191.01,6.1
+3VALW on TOP: 262.06,39.63 262.01,39.68 262.01,39.89 262.01,39.89 262.01,40.46 261.5,40.98 261.5,41.55 261.63,41.68 262.37,41.68 263.48,40.58 263.48,39.75 263.35,39.63
+3VALW on TOP: 20.99,53.73 21.01,53.72 21.01,52.91 20.91,52.81 19.55,52.81 19.22,53.13 19.22,53.79 19.51,54.08 20.3,54.08 20.47,53.9 20.84,53.9 20.99,53.75
+3VALW on TOP: 68.58,31.12 68.94,31.47 68.94,32.28 68.45,32.77 60.58,32.77 60.07,32.26 59.06,32.26 57.41,30.61 57.41,30.23 57.53,30.1 62.49,30.1 63.5,31.12
+3VALW on TOP: 181.64,11.77 181.72,11.69 181.72,10.65 182.17,10.19 182.17,9.83 182.09,9.75 179.94,9.75 179.68,10.01 179.68,10.23 180.08,10.63 180.21,10.63 180.35,10.77 180.35,11.68 180.44,11.77
+3VALW on BOTTOM: 341.2,62.03 341.2,60.07 341.17,60.05 341.17,56.9 340.97,56.69 340.03,56.69 339.8,56.92 339.8,61.98 339.93,62.1 341.12,62.1
+3VALW on BOTTOM: 328.73,34.77 326.1,34.77 325.41,34.07 325.41,32.28 322.8,29.67 322.28,29.67 320.17,27.56 320.17,26.42 320.55,26.04 326.26,26.04 328.67,28.45 328.67,31.24 329.07,31.63 329.07,34.43
+3VALW on BOTTOM: 179.99,11.22 182.2,11.22 182.33,11.09 182.33,9.93 182.19,9.79 179.87,9.79 179.82,9.83 179.82,11.05
+3VALW on IN1: 16.07,50.02 16.07,45.51 15.43,44.86 15.43,40.92 14.24,39.74 14.24,35.63 14.26,35.61 14.26,35.46 12.69,33.89 12.69,32.36 13.38,31.67 16.42,31.67 16.59,31.85 16.59,33.17 16.04,33.72 16.04,34.38 16.51,34.84 18.78,34.84 19.4,35.46 19.4,38.78 18.33,39.85 18.33,51.29 19.36,52.32 19.36,52.9 19.75,53.29 19.75,53.93 19.35,54.33 17.28,54.33 15.68,52.72 15.68,50.41
+3VALW on IN2: 81.19,31.49 82.09,31.49 82.23,31.63 82.23,32.74 81.87,33.1 81.23,33.1 80.84,32.71 80.84,31.85
+3VALW on IN2: 67.95,31.38 68.87,31.38 69.27,31.78 69.27,32.58 68.95,32.89 67.98,32.89 67.86,32.77 67.86,31.47
+3VALW on IN2: 251.72,51.31 252.83,51.31 254.71,49.43 254.71,43.18 254.38,42.85 253.32,42.85 252.59,43.57 252.59,43.7 251.46,44.83 251.46,51.06
+3VALW on IN4: 80.25,32.23 81.87,32.23 82.04,32.06 82.04,31.41 81.84,31.2 80.14,31.2 80.04,31.31 80.04,32.02
+3VALW on IN4: 66.22,20.3 67.21,20.3 67.3,20.21 67.3,19 67.15,18.85 66.24,18.85 66.14,18.95 66.14,20.22
+3VALW on IN4: 258.42,42.39 261.57,42.39 261.6,42.42 262.08,42.42 263.5,41.15 263.5,39.88 263.27,39.65 255.4,39.65 252.99,42.06 252.99,43.61 253.45,44.08 254.57,44.08 256.93,41.72 257.75,41.72
+3VALW on VCC: outline of 182 points within 1.17,1.17 351.53,122.13 ; 1 cut-out
+3VALW on IN5: 329.5,109.05 348.32,109.05 348.91,108.46 348.91,92.07 348.53,91.68 345.86,91.68 340.18,86.01 337.14,86.01 336.5,86.65 336.5,100.91 336.57,100.97 334.17,103.37 329.47,103.37 328.73,104.11 328.73,108.28
+3VALW on IN5: 15.62,57.15 15.29,56.82 15.29,51.26 15.69,50.86 16.63,50.86 16.77,51 16.77,56.01
+3VALW_5105 on TOP (solid shape): 312.55,16.26 312.55,14.11 312.55,14.1 312.55,13.21 312.55,13.19 312.55,12.7 312.42,12.57 311.97,12.57 311.89,12.61 311.86,12.68 311.6,13.06 311.19,12.86 311.11,12.8 311.02,12.83 310.9,12.96 310.9,13.49 311.02,13.62 311.04,13.62 311.36,13.99 311,14.33 310.93,14.36 310.9,14.43 310.9,16.13 311.15,16.38 312.42,16.38
+3VALW_5105 on TOP (solid shape): 309.69,17.08 309.69,16.31 309.69,14.9 309.25,14.46 308.57,14.46 308.23,14.8 308.23,15.37 308.04,15.56 307.47,15.56 307.4,15.62 307.4,15.9 308.35,15.9 308.35,15.85 308.36,15.8 308.38,15.75 308.4,15.7 308.43,15.65 308.47,15.61 308.51,15.58 308.55,15.55 308.6,15.53 308.65,15.52 308.71,15.52 308.76,15.52 308.81,15.53 308.86,15.55 308.91,15.58 308.95,15.61 308.99,15.65 309.02,15.7 309.04,15.75 309.06,15.8 309.06,15.85 309.06,15.9 309.06,15.95 309.04,16.01 309.02,16.05 308.99,16.1 308.95,16.14 308.91,16.17 308.86,16.2 308.81,16.22 308.76,16.23 308.71,16.23 308.65,16.23 308.6,16.22 308.55,16.2 308.51,16.17 308.47,16.14 308.43,16.1 308.4,16.05 308.38,16.01 308.36,15.95 308.35,15.9 307.4,15.9 307.4,16.19 307.79,16.19 308.19,16.6 308.24,16.61 308.29,16.62 308.34,16.64 308.38,16.67 308.42,16.71 308.46,16.75 308.48,16.79 308.5,16.84 308.52,16.89 308.52,16.95 308.52,17 308.51,17.04 308.52,17.07 308.53,17.1 308.55,17.12 308.57,17.14 308.6,17.15 308.62,17.15 309.63,17.15
+3VALW_5105 on TOP: 306.63,28.63 313.31,28.63 313.44,28.5 313.44,27.38 313.23,27.18 306.73,27.18 306.48,27.43 306.48,28.47
+3VALW_5105 on BOTTOM: 307.02,27.94 307.47,28.39 312.99,28.39 313.44,27.94 313.44,25.53 312.04,24.13 312.04,13.51 311.4,12.87 310.96,12.87 310.66,12.58 310.66,11.88 311.47,11.08 311.47,3.56 311.09,3.18 289.76,3.18 289.35,3.59 289.35,4.89 288.55,5.68 287.81,5.68 286.57,6.92 286.57,7.84 286.4,8.01 283.27,8.01 283.27,9.97 281.94,11.3 281.94,14.48 282.33,14.86 284.73,14.86 287.66,11.93 287.66,8.54 287.88,8.33 289.94,8.33 290.96,7.3 290.96,5.7 291.27,5.4 292.99,5.4 296.36,8.76 297.31,8.76 297.56,8.51 297.56,6.92 297.75,6.73 299.4,6.73 299.4,7.87 299.35,7.91 299.35,8.41 301.5,10.56 301.5,11.04 301.64,11.18 302.78,11.18 305.28,8.69 306.49,8.69 307.02,9.22
+3VALW_5105 on IN2: 287.52,15.89 283.38,11.75 283.38,11.24 283.54,11.08 285.47,11.08 287.54,13.15 289.51,13.15 289.78,13.41 292.57,13.41 292.9,13.74 292.9,16.16 292.51,16.54 292.51,16.54 290.55,16.54 289.89,15.88 289.43,15.88 289.42,15.89
+3VALW_5105 on IN4: 296.73,26.45 296.75,26.47 299.47,26.47 300.31,27.31 304.46,27.31 305.73,28.58 313.18,28.58 314.23,27.53 314.23,26.26 310.05,22.08 291.7,22.08 291.43,22.35 288.61,22.35 288.38,22.58 288.38,23.47 291.36,26.45
+3VALW_5105 on IN6: 308.94,17.46 305.32,17.46 304.98,17.12 304.98,16.13 305.22,15.89 308.52,15.89 309.22,16.59 309.22,17.18
+3VALWP on TOP (solid shape): 332.67,30.21 332.67,26.54 332.33,26.19 329.99,26.19 328.87,25.07 326.41,25.07 325.04,23.71 324.62,23.71 324.51,23.82 324.51,23.88 324.51,23.88 324.51,24.49 324.5,24.5 323.95,24.5 323.95,24.95 324.5,24.95 324.51,25.69 324.5,25.7 323.96,25.7 323.95,25.7 323.95,26.15 324.49,26.15 324.5,26.16 324.5,27.07 327.81,30.38 332.5,30.38
+3VS on BOTTOM (solid shape): 349.77,37.42 349.77,36.59 349.66,36.48 348.11,36.48 348.05,36.54 348.05,37.46 348.19,37.6 349.59,37.6
+3VS on TOP: 241.49,18.52 241.72,18.75 244.84,18.75 245.75,17.84 245.76,17.84 247.82,17.84 248.25,18.28 248.25,19.5 248.4,19.65 249.15,19.65 249.23,19.57 249.23,18.11 249.43,17.91 249.43,17.27 252.18,14.52 253.21,14.52 256.55,11.19 256.55,3.87 256.17,3.5 253.05,3.5 252.84,3.71 252.84,5.41 251.97,6.28 251.97,8.41 252.65,9.09 252.65,11.31 251.89,12.06 247.94,12.06 246.82,13.19 242.1,13.19 241.49,13.79
+3VS on TOP: 260.02,39.61 259.53,40.09 259.53,40.96 259.3,41.2 257.71,41.2 256.81,42.09 256.81,43.58 257.35,44.12 257.35,45.09 257.51,45.24 258.04,45.24 258.12,45.16 258.12,44.76 258.83,44.04 258.83,43.06 259.14,42.74 259.9,42.74 260.2,42.45 260.2,40.65 260.55,40.3 260.62,40.3 260.73,40.19 260.73,39.64 260.7,39.61
+3VS on TOP: 85.33,9.97 84.56,9.97 84.45,9.86 81.26,9.86 80.67,9.27 80.67,8.13 79.45,6.91 79.45,6.3 79.33,6.17 78.74,6.17 78.26,6.66 78.26,7.88 78.46,8.08 78.46,8.99 79.55,10.08 79.76,10.08 80.32,10.64 80.6,10.64 81.05,11.1 83.26,11.1 83.26,11.08 83.67,10.68 84.13,10.68 84.16,10.65 84.59,10.65 84.7,10.77 84.7,11.05 84.58,11.17 84.58,11.74 84.68,11.84 85.32,11.84 85.85,11.3 86.14,11.3 86.25,11.41 86.25,12.07 86.44,12.26 87.04,12.26 87.1,12.2 87.1,11.6 87.22,11.48 87.22,10.34 87,10.11 85.47,10.11
+3VS on TOP: 328.3,41.16 325.3,41.16 323.47,42.99 323.47,43.82 323.72,44.07 324.45,44.07 326.2,42.32 328.28,42.32 328.42,42.18 328.42,41.29
+3VS on TOP: 102.57,10.13 102.57,12.76 102.76,12.94 108.41,12.94 110.29,11.06 111.07,11.06 111.4,10.74 111.4,10.24 111.2,10.03 105.26,10.03 104.07,8.85 102.85,8.85 102.57,8.57 102.57,8.14 102.4,7.97 101.74,7.97 101.56,8.15 101.56,8.52 101.73,8.69 101.73,9.27 101.98,9.52 101.98,9.53
+3VS on TOP: 69.78,20.96 70.57,21.75 71.08,21.75 71.31,21.52 71.31,19.97 71.06,19.72 71.06,16.96 70.23,16.13 68.58,16.13 68.09,16.62 67.04,16.62 66.69,16.27 66.69,13.08 66.55,12.94 65.45,12.94 65.03,13.36 65.03,15.32 65.76,16.05 65.76,16.87 66.91,18.01 66.91,20.27 67.6,20.96
+3VS on TOP: 173.57,26.35 173.89,26.04 173.89,23.1 173.62,22.84 173.15,22.36 173.15,21.64 172.56,21.06 172.56,21.02 172.3,20.77 171.82,20.77 171.74,20.68 171.74,20.15 171.53,19.94 170.97,19.94 170.83,19.79 170.83,18.01 170.72,17.9 168.46,17.9 168.4,17.96 168.4,18.83 168.26,18.97 168.26,20.16 169.76,21.66 169.76,24.27 171.43,25.94 171.43,29.24 171.76,29.57 173,29.57 173.35,29.22 173.35,26.58 173.53,26.39 173.53,26.35
+3VS on BOTTOM: 70.36,18.35 70.36,20.19 70.49,20.32 70.49,21.24 71,21.76 71.91,21.76 72.07,21.59 72.07,21.27 72.03,21.23 71.49,21.23 71.27,21.01 71.27,20.01 71.18,19.93 71.18,18.35 71.1,18.26 70.45,18.26
+3VS on BOTTOM: 53.45,24.66 52.41,24.66 52.14,24.38 52.14,23.64 51.92,23.42 50.1,23.42 49.77,23.1 49.77,22.46 50.02,22.21 53.12,22.21 53.7,22.79 53.7,24.41
+3VS on BOTTOM: 283.95,10.18 284.11,10.01 284.11,9.73 283.53,9.15 283.53,8.08 283.75,7.86 286.3,7.86 286.43,7.73 286.43,6.89 287.79,5.52 288.52,5.52 289.17,4.88 289.17,3.94 289.02,3.8 288,3.8 287.88,3.92 287.88,4.23 287.75,4.36 284.57,4.36 283.47,5.46 283.47,5.98 282.85,6.6 282.85,6.6 282.67,6.78 282.67,9.89 282.96,10.18
+3VS on BOTTOM: 111.25,11.3 111.71,11.3 112.02,11 112.02,10.61 111.57,10.16 111.38,10.16 111.13,9.91 110.24,9.91 110.11,10.03 110.11,10.29 110.24,10.42 110.75,10.42 110.87,10.54 110.87,10.92
+3VS on BOTTOM: 84.46,2.07 86.68,2.07 86.88,2.27 87.74,2.27 87.98,2.03 88.7,2.03 89.29,2.63 89.29,3.09 89.36,3.16 89.71,3.16 89.94,2.92 89.94,1.77 89.38,1.2 82.81,1.2 82.61,1.4 82.61,1.63 82.82,1.84 84.23,1.84
+3VS on BOTTOM: 15.6,43.46 15.6,44.38 16.1,44.88 16.1,45.22 16.19,45.32 17.25,45.32 17.38,45.19 17.38,44.55 17.24,44.41 16.69,44.41 16.18,43.9 16.18,43.46 16.07,43.34 15.72,43.34
+3VS on BOTTOM: 300.97,31.37 298.96,31.37 298.83,31.5 298.83,32.45 298.84,32.45 298.93,32.54 300.81,32.54 301.07,32.28 301.07,31.47
+3VS on IN1: 189.99,115.83 189.99,117.22 190.37,117.6 191.01,117.6 191.26,117.86 192.66,117.86 192.91,117.6 192.91,116.33 192.79,116.21 191.52,116.21 190.88,115.57 190.25,115.57
+3VS on IN2: 51.03,23.18 49.93,23.18 49.59,22.85 49.59,21.95 49.89,21.66 50.67,21.66 51.25,22.23 51.25,22.96
+3VS on IN2: 17.04,44.54 15.75,44.54 15.46,44.25 15.46,42.53 15.74,42.26 16.72,42.26 17.13,42.66 17.13,44.45
+3VS on IN2: 85.81,2.65 86.31,2.15 87.74,2.15 87.92,1.97 87.92,1.49 87.79,1.36 82.6,1.36 82.45,1.51 82.45,2.01 83,2.55 83.44,2.55 83.54,2.65
+3VS on IN2: 267.16,35.62 263.15,35.62 256.68,42.09 256.68,43.69 257.79,44.79 259.59,44.79 270.58,36.55 284,33.63 294,33.63 297.84,33.86 301.63,34.54 301.63,32.02 300.98,31.37 300.31,31.37 298.62,29.68 273.1,29.68
+3VS on IN4: 241.76,17.96 241.76,18.45 246.14,22.84 246.14,26.1 246.76,26.72 252.59,26.72 255.02,29.15 255.02,32.51 246,41.53 238.35,41.53 238.11,41.78 238.11,46.67 238.32,46.88 256.78,46.88 258.05,45.61 258.05,42.41 257.56,41.91 256.92,41.91 256.73,42.1 256.73,42.56 254.99,44.3 252.83,44.3 252.05,43.51 252.05,41.14 258.19,34.99 258.19,27.94 254.64,24.39 254.64,19.43 253.91,18.7 252.83,18.7 252.08,17.96
+3VS on IN4: 71.43,22.46 71.31,22.46 67.92,19.06 67.92,19.05 67.5,18.63 67.5,18.04 67.95,17.59 75.65,17.59 83.6,25.54 93.72,25.54 96.12,27.95 96.12,30.22 94.7,31.65 93.99,31.65 93.9,31.56 92.95,31.56 92.85,31.66 82.5,31.66 81.93,31.09 80.06,31.09 79.33,30.36
+3VS on IN4: 49.99,22.7 51.21,22.7 51.34,22.83 51.34,23.6 51.17,23.77 50.09,23.77 49.85,23.53 49.85,22.84
+3VS on IN4: 295.95,27.22 294.39,27.22 293.85,27.75 293.85,29.44 294.06,29.64 295,29.64 296.22,30.86 297.18,30.86 298.45,32.13 303.71,32.13 304.7,33.12 305.93,33.12 306.65,33.84 306.65,34.17 306.9,34.42 308.81,34.42 309.01,34.22 309.01,31.4 306.95,29.34 300.36,29.34 300.25,29.44 299.24,29.44 298.79,29 298.79,27.9 298.32,27.43 296.17,27.43
+3VS on VCC: 153.9,18.16 152.53,19.54 152.53,26.78 150.73,28.58 111.78,28.58 110.39,27.18 107.2,27.17 105.32,27.17 105.08,27.41 105.08,29.32 104.2,30.2 109.41,35.41 109.83,35.41 111.07,34.16 243.74,34.16 253.49,24.41 253.49,21.32 253.01,20.83 249.66,20.83 242.55,27.94 174.39,27.94 172.98,26.52 172.98,18.39 172.74,18.16
+3VS on IN5: 61.98,3.68 62.1,3.81 63.63,3.81 64.39,4.57 64.9,4.57 64.98,4.49 64.99,4.49 64.99,3.29 65.5,2.78 66.91,2.78 67.79,1.91 74.68,1.91 75.06,2.29 75.08,2.29 75.41,2.62 77.24,2.62 77.57,2.29 82.81,2.29 83.19,1.91 83.19,1.27 82.93,1.02 62.61,1.02 61.98,1.65
+3VS on IN5: 51.95,24.01 50.03,24.01 49.72,23.7 49.72,22.75 49.89,22.57 51.56,22.57 52.08,23.09 52.08,23.87
+3VS on IN5: 210.76,45.15 212.09,43.82 256.67,43.82 257.81,42.67 257.81,42.29 257.05,41.53 212.22,41.53 210.12,43.63 210.12,44.83 210.44,45.15
+3VS on IN5: 102.78,37.3 101.62,37.3 93.41,29.1 93.41,27.58 94.46,26.54 95.81,26.54 97.68,28.41 100.46,28.41 101.22,27.65 105.44,27.65 106.1,28.31 106.1,29.81 103.2,32.71 102.92,32.71 102.65,32.44 101.77,32.44 101.69,32.52 101.69,33.3 102.68,34.28 102.7,34.28 102.7,34.29 103.13,34.72 103.13,36.96
+3VS on IN5: 348.84,40.06 350.11,40.06 350.62,39.55 350.62,36.88 350.24,36.5 348.97,36.5 348.59,36.88 348.59,39.8
+3VS on IN5: 307.21,35.43 309.63,35.43 314.58,40.39 319.66,40.39 320.68,41.4 320.68,45.98 320.98,46.28 321.84,46.28 326.14,41.98 326.14,40.13 323.47,37.47 321.31,37.47 320.42,36.58 320.42,35.82 318.64,34.04 309.37,34.04 308.99,33.66 307.21,33.66 306.83,34.04 306.83,35.05
+3VS_AUDIO on TOP (solid shape): 12.93,9.73 12.93,7.16 12.65,6.88 12.37,6.88 12.14,7.11 12.14,7.98 11.99,8.13 11.47,8.13 11.02,7.68 10.24,7.68 10.19,7.74 10.19,9.91 10.29,10.01 12.65,10.01
+3VS_AUDIO on TOP: 16.02,18.19 16.02,16 15.85,15.83 13.29,15.83 13.06,16.05 13.06,16.44 13.29,16.66 13.29,18.27 13.48,18.46 15.75,18.46
+3VS_AUDIO on TOP: 5.12,29.35 4.16,29.35 4.04,29.23 4.04,27.66 4.3,27.4 4.76,27.4 5.25,27.89 5.25,29.23
+3VS_AUDIO on BOTTOM: 4.76,26.3 3.73,26.3 3.55,26.48 3.55,29.18 3.69,29.32 4.16,29.32 4.26,29.22 4.26,28.86 4.85,28.27 4.85,26.39
+3VS_AUDIO on IN5: 11.78,18.38 14.84,18.38 16.04,17.18 16.04,15.7 15.87,15.53 13.46,15.53 12.95,15.01 12.95,6.75 12.84,6.64 11.71,6.64 10.47,7.88 10.47,17.07 9.86,17.68 9.86,18.9 7.51,21.25 7.51,22.94 3.99,26.46 3.99,28.32 4.16,28.5 5.17,28.5 11.22,22.44 11.22,18.93
+3VS_CR on BOTTOM (solid shape): 334.24,37.64 334.87,37.64 335.05,37.47 335.76,37.47 335.87,37.36 335.87,37.14 336.07,36.93 336.47,36.93 336.68,36.73 336.68,36.27 336.55,36.15 335.87,36.15 335.61,36.4 333.74,36.4 333.3,36.84 332.28,36.84 332.22,36.87 332.15,36.9 332,37.05 332,37.86 332.1,37.96 333.92,37.96
+3VS_CR on BOTTOM (solid shape): 345.06,38.04 345.95,38.04 346.46,37.53 347.35,37.53 347.41,37.47 347.41,36.51 347.22,36.32 347.22,34.93 346.9,34.61 346.14,34.61 345.78,34.96 345.78,37 345.57,37.21 344.43,37.21 343.81,37.83 342.79,37.83 342.56,38.06 341.64,38.06 341.58,38.13 341.58,38.28 341.66,38.36 344.74,38.36
+3VS_CR on IN6: 333.35,34.4 332.47,35.28 332.47,35.84 332.53,36.56 331.91,36.95 331.88,36.96 331.86,37 331.86,37.78 332.16,38.07 333.92,38.07 334.49,37.5 335.5,37.5 336.3,36.7 337.11,36.7 337.14,36.74 338.58,38.17 345.49,38.17 347.03,36.64 347.03,35.31 346.71,34.99 343.95,34.99 343.35,35.59 341.54,35.59 340.78,34.84 339.03,34.84 338.59,34.4
+3VS_DTH on TOP: 28.31,66.93 28.31,66.67 27.94,66.3 27.94,65.99 27.53,65.58 26.06,65.58 25.91,65.74 25.91,66.04 25.68,66.27 25.68,66.7 25.82,66.84 26.12,66.84 26.29,66.68 26.67,66.68 26.8,66.8 26.8,67.18 26.93,67.31 27.31,67.31 27.43,67.44 27.43,67.82 27.63,68.02 27.63,68.47 28.16,69 28.64,69 28.73,68.91 28.73,67.84 28.32,67.44 28.32,66.94
+3VS_DTH on BOTTOM: 19.5,94.21 19.5,95.95 19.81,96.27 23.95,96.27 24.04,96.18 24.04,95.46 23.97,95.39 21.63,95.39 21.46,95.56 20.45,95.56 20.4,95.51 20.4,95.04 20.06,94.7 20.06,94.18 20.04,94.16 19.54,94.16
+3VS_DTH on BOTTOM: 27,78.41 28.58,78.41 28.7,78.28 28.7,77.88 28.55,77.73 28.22,77.73 27.53,77.04 26.47,77.04 26.37,77.14 26.37,77.78
+3VS_FFS on TOP (solid shape): 240.59,48.88 240.59,48.21 241.31,47.6 242.15,47.19 242.16,47.18 242.22,47.13 242.22,46.14 242.09,46.01 241.14,46.01 241.03,45.91 240.07,45.91 239.8,45.65 239.8,44.77 239.66,44.63 238.94,44.63 238.88,44.69 238.88,45.68 238.65,45.91 238.08,45.91 238.02,45.96 238.02,46.46 238.11,46.55 239.22,46.55 239.43,46.76 239.43,48.88 239.61,49.06 240.4,49.06
+3VS_FFS on IN1: 241.24,47.56 240.98,47.31 239.71,47.31 239.27,46.86 234.82,46.86 234.44,47.25 234.44,49.79 234.95,50.29 240.41,50.29 241.24,49.47
+3VS_FP on BOTTOM: 314.01,36.13 314.71,36.13 314.77,36.07 314.77,32.96 315.85,31.88 315.85,31.5 315.72,31.37 314.33,31.37 313.69,32.01 313.69,35.82
+3VS_FP_R on BOTTOM: 315.72,26.04 315.47,26.29 315.47,26.93 314.58,27.81 314.58,30.86 314.83,31.12 315.6,31.12 315.85,30.86 315.85,28.58 316.61,27.81 319.15,27.81 319.41,27.56 319.41,26.16 319.28,26.04
+3VS_TP on TOP (solid shape): 191.1,11.85 191.1,11.38 191.1,10.97 192.27,9.8 192.27,7.7 192.2,7.62 191.54,7.62 191.28,7.88 191.28,7.88 191.03,8.13 190.27,8.13 190.26,8.12 190.05,8.12 189.93,8 189.93,6.74 189.81,6.62 189.29,6.62 189.03,6.88 189.03,6.91 189,7.03 188.94,7.13 188.94,7.33 188.95,7.35 189.01,7.48 189.03,7.62 189.03,7.79 189.01,7.94 188.94,8.07 188.94,8.75 188.71,8.98 188.71,11.44 189.28,12 190.95,12
+3VS_TS on BOTTOM (solid shape): 350.84,60.26 350.84,57.72 350.78,57.66 350.01,57.66 349.82,57.85 349.82,58.23 350.33,58.74 350.33,59.63 350.2,59.75 349.89,59.75 349.76,59.88 349.76,60.2 349.89,60.33 350.78,60.33
+3VS_TS on BOTTOM: 345.85,47.73 345.62,47.96 345.62,48.85 343.21,51.26 343.21,60.55 342.87,60.88 342.72,60.88 342.6,61.01 342.6,61.95 342.7,62.05 344.97,62.05 345.11,61.91 345.11,60.55 345.27,60.39 346.71,60.39 346.77,60.33 346.77,58.99 346.28,58.5 346.28,47.91 346.1,47.73
+3VS_TS on IN1: 343.43,54.18 343.43,59.06 344.22,59.84 345.49,59.84 346.74,58.6 346.74,42.29 345.95,41.5 339.95,41.5 338.41,43.05 338.41,49.15
+3VS_WLAN on TOP: 346.22,87.37 346.05,87.54 346.05,87.88 346.03,87.89 346.03,88.35 345.91,88.47 345.64,88.47 345.63,88.47 345.52,88.47 345.08,88.91 345.08,89.5 343.44,91.14 332.64,91.14 329.94,93.83 329.94,101.6 331.86,103.52 336.08,103.52 336.2,103.4 336.2,102.38 336.2,102.38 336.2,101.62 336.48,101.35 336.48,101.14 338.1,101.14 338.36,100.88 338.36,100.36 338.3,100.3 337.55,100.3 337.37,100.47 336.92,100.47 336.87,100.42 336.87,100.02 336.53,99.69 336.53,97.04 336.81,96.76 338.45,96.76 339.98,95.23 339.98,95.13 340.06,95.13 341.5,93.69 343.97,93.69 346.57,91.09 346.57,89.18 347.19,88.56 347.71,88.56 347.89,88.38 347.89,87.52 347.74,87.37
+3VS_WLAN on BOTTOM: 345.32,88.22 344.97,88.57 344.97,90.11 346.12,91.25 346.12,93.02 346.38,93.28 347.1,93.28 347.45,92.93 347.45,90.84 346.84,90.23 346.84,89.06 346,88.22
+3VS_WLAN on BOTTOM: 326.16,95.23 327.23,96.29 331.87,96.29 331.87,94.25 331.55,93.93 330.45,93.93 329.48,92.97 329.48,91.23 329.37,91.12 326.52,91.12 326.16,91.48
+5V_CHGUSB_1 on BOTTOM: 330.77,66.97 330.77,67.76 330.65,67.88 330.65,70.45 330.87,70.68 332.47,70.68 332.59,70.56 332.59,66.09 331.85,65.36 330.53,65.36 330.43,65.46 330.43,66.63
+5V_CHGUSB_1 on IN1: 332.36,70.58 331.25,69.47 331.25,66.91 331.79,66.36 333.92,66.36 335.76,68.2 337.37,68.2 338.28,69.11 338.28,72.15 337.69,72.73 333.17,72.73 332.36,71.92
+5V_CHGUSB_1 on IN3: 331.34,65.43 331.03,65.73 331.03,69.85 334.07,72.9 334.49,72.9 334.49,72.73 335.13,72.09 335.21,72.03 335.19,71.93 335.82,70.66 336.44,71.93 336.43,72.04 336.52,72.1 336.61,72.1 336.98,71.74 337.48,71.68 337.51,71.69 337.82,71.38 337.82,69.41 337.59,69.18 337.16,69.22 336.8,68.99 336.67,68.72 336.68,68.42 336.68,68.39 333.72,65.43
+5V_CHGUSB_1 on VCC: 332.06,65.78 331.57,66.27 331.57,68.89 331.71,69.04 332.73,69.04 334.45,70.75 334.45,72.01 335.38,72.94 338.13,72.95 338.13,68.21 336.57,68.21 334.14,65.78
+5V_CHGUSB_1 on IN5: 331.03,69.85 334.07,72.9 336.75,72.9 337.82,71.83 337.82,69.41 337.59,69.18 336.86,69.06 336.71,68.32 336.72,68.3 334.07,65.66 331.38,65.66 331.03,66.01
+5V_CHGUSB_2 on TOP (solid shape): 19.26,110.04 19.26,109.5 19.49,109.27 19.49,109.1 19.54,109.05 20.98,109.05 20.98,107.67 20.93,107.62 20.4,107.62 20.29,107.63 20.18,107.6 20.17,107.6 19.87,107.6 19.86,107.6 19.72,107.63 19.58,107.6 19.57,107.6 18.59,107.6 18.11,108.08 17.27,108.08 17.02,108.33 16.65,108.33 15.59,108.22 15.62,107.15 15.62,106.68 15.37,106.43 14.35,106.43 14.03,106.74 14.03,108.04 14.1,108.13 14.21,108.11 15.05,108.02 15.29,108.83 15.28,108.86 15.28,109.06 16.32,110.1 19.2,110.1
+5V_CHGUSB_2 on BOTTOM: 26.93,100.38 28.07,100.38 28.42,100.74 28.42,101.68 28.04,102.06 27.61,102.06 27.36,102.31 27.03,102.31 26.85,102.13 26.85,100.46
+5V_CHGUSB_2 on IN1: 22.15,109.55 22.18,109.52 23.21,109.52 25.64,107.1 25.64,105.63 28.45,102.81 28.45,100.33 28.44,100.32 28.44,99.51 28.42,99.49 28.42,98.95 27.95,98.48 24.5,98.48 23.46,99.52 20.8,99.52 14,106.33 14,107.21 16.33,109.55
+5V_CHGUSB_2 on VCC: 12.21,94.87 12.42,94.97 12.63,95.04 13.53,95.63 13.87,96.65 13.87,112.33 28.83,112.33 28.83,108.59 27.83,108 26.68,106 27.83,104 28.83,103.41 28.83,100.48 21.51,100.48 15.9,94.87
+5VALW on TOP (solid shape): 183.73,11.53 183.73,9.87 183.62,9.75 182.98,9.75 181.89,10.85 181.89,11.62 182,11.74 183.53,11.74
+5VALW on TOP (solid shape): 232.16,12.13 232.16,10.16 232.09,10.1 231.33,10.1 230.82,10.61 229.3,10.61 228.98,10.92 228.98,12.07 229.24,12.32 231.97,12.32
+5VALW on TOP (solid shape): 8.79,6.35 8.79,5.71 8.68,5.61 8.68,4.93 8.72,4.9 8.72,4.05 9.29,3.48 9.62,3.48 10.02,3.88 10.02,4.03 10.14,4.15 10.51,4.15 10.59,4.07 10.59,2.59 10.3,2.3 9.25,2.3 7.76,3.79 7.76,6.16 8.02,6.42 8.73,6.42
+5VALW on TOP (solid shape): 317.68,7.35 317.68,6.69 317.65,6.67 317.16,6.67 317.14,6.67 317.14,5.96 317.16,5.94 317.66,5.94 317.67,5.94 317.67,5.48 317.65,5.47 317.16,5.47 317.14,5.47 317.14,4.76 317.16,4.74 317.67,4.74 317.67,4.74 317.67,3.14 317.4,2.87 315.17,2.87 314.98,3.06 314.98,7.05 314.98,7.05 314.98,7.13 315.35,7.49 317.53,7.49
+5VALW on BOTTOM (solid shape): 28,52.98 28,52.65 28.14,52.51 28.58,52.51 28.9,52.19 28.9,52.06 28.9,52.06 28.9,50.49 28.74,50.33 28.01,50.33 27.17,51.18 26.19,51.18 26.07,51.3 26.07,51.62 26.06,51.63 26.06,52.27 26.1,52.3 27.49,52.3 27.51,52.33 27.51,52.92 27.59,53 27.61,53.02 27.62,53.03 27.66,53.06 27.92,53.06
+5VALW on IN5 (solid shape): outline of 165 points within 249.81,52.83 252.48,56.45
+5VALW on TOP: 208.08,49.32 208.71,49.32 208.81,49.22 208.81,49.05 209.09,48.77 209.55,48.77 209.73,48.59 209.73,48.05 209.6,47.92 208.84,47.92 207.95,48.81 207.95,49.19
+5VALW on TOP: 262.13,38.28 264.58,38.28 264.68,38.18 264.68,37.31 264.68,37.3 264.68,37.09 264.49,36.91 262.15,36.91 262.01,37.05 262.01,38.17
+5VALW on BOTTOM: 26.98,98.22 28.45,98.22 28.5,98.17 28.83,98.17 28.84,98.17 28.95,98.06 28.95,96.31 28.86,96.22 28.05,96.22 27.86,96.41 27.86,96.75 27.31,97.29 26.97,97.29 26.88,97.39 26.88,98.12
+5VALW on BOTTOM: 249.19,46.54 248.74,46.09 247.84,46.09 244.38,49.55 237.17,49.55 236.67,49.04 234.5,49.04 232.56,47.1 222.61,47.1 220.09,44.58 211.46,44.58 208.41,47.63 208.41,48.9 208.54,49.02 210.57,49.02 212.43,47.16 218.06,47.16 218.06,47.17 219.13,47.17 221.72,49.76 230.98,49.76 232.23,51.01 236.48,51.01 237.58,52.11 245.2,52.11 249.19,48.12
+5VALW on BOTTOM: 330.15,60.75 330.15,61.42 330.45,61.72 330.45,62.71 330.45,62.87 330.44,62.88 330.44,63.08 330.59,63.23 331.92,63.23 332.42,62.73 332.42,62.72 332.8,62.35 332.8,60.39 332.26,59.85 332.26,59.75 332.26,59.74 332.26,59.5 332.11,59.35 331.24,59.35 331.01,59.58 331.01,60.39 330.83,60.58 330.32,60.58
+5VALW on IN4: outline of 255 points within 7.49,1.27 349.03,116.66 ; 3 cut-outs
+5VALW on VCC: 333.48,58.55 331.73,60.3 331.73,64.11 330.43,65.41 330.43,65.41 330.09,65.77 330.09,71.21 330.37,71.44 331.6,72.67 331.6,91.08 339.98,99.46 339.98,102.71 339.52,103.38 338.14,103.38 337.82,103.59 337.82,105.48 338.11,105.67 349.14,105.67 349.21,105.34 349.34,105.03 349.6,104.04 349.34,103.05 349.13,102.24 349.34,101.43 349.6,100.44 349.34,99.45 349.13,98.64 349.34,97.83 349.6,96.84 349.13,95.04 349.6,93.24 349.34,92.25 349.14,91.3 349.49,90.4 349.93,89.85 349.93,81.67 341.11,81.67 340.64,81.94 338.97,81.95 338.13,80.5 338.13,73.45 335.17,73.45 333.94,72.22 333.94,70.97 332.52,69.55 331.5,69.55 331.06,69.11 331.06,66.06 331.85,65.27 334.35,65.27 336.78,67.7 338.13,67.7 338.13,66.4 338.97,64.95 340.64,64.96 341.11,65.23 349.62,65.23 349.98,63.66 350.25,63.03 350.72,62.52 351.53,61.92 351.53,58.55
+5VALW on IN5: outline of 274 points within 12.32,4.57 47.37,99.18
+5VALW on IN5: 208.66,49.02 212.22,49.02 213.55,47.69 256.8,47.69 264.61,39.88 264.61,36.7 264.35,36.45 261.88,36.45 258.07,40.26 258.07,42.74 256.6,44.2 212.28,44.2 211.71,44.77 211.71,44.83 210.63,45.91 209.23,45.91 208.34,46.8 208.34,48.71
+5VALWP on TOP (solid shape): 331.47,9.22 331.47,4.32 330.26,3.11 322.97,3.11 322.89,3.02 320.48,3.02 320.46,3.04 318.91,3.04 317.82,4.13 317.82,7.26 317.9,7.34 318.17,7.34 319.51,6.01 326.05,6.01 326.67,6.63 326.67,9.38 327.01,9.72 330.97,9.72
+5VALWP on IN2 (solid shape): 331.45,9.22 331.45,4.29 330.28,3.13 318.82,3.13 318.69,3.25 318.69,5.64 319,5.94 325.98,5.94 326.67,6.63 326.67,9.35 327.03,9.7 330.96,9.7
+5VS on BOTTOM (solid shape): 167.69,110.62 167.69,109.55 167.54,109.4 166.47,109.4 166.32,109.55 166.32,110.64 166.4,110.72 167.59,110.72
+5VS on TOP: 255.84,37.59 255.84,37.99 256.15,38.29 259.55,38.29 259.61,38.23 260.7,38.23 260.74,38.19 260.74,37.47 260.15,36.88 260.15,36.09 259.59,35.54 257.89,35.54
+5VS on TOP: 112.73,95.19 114.06,95.19 114.11,95.14 114.11,94.58 113.24,93.71 113.24,93.66 112.69,93.11 112.19,93.11 112.13,93.17 112.13,93.68 112.52,94.07 112.52,94.98
+5VS on TOP: 93.7,33.95 93.5,34.15 93.5,38.01 96.79,41.3 100.06,41.3 100.73,41.97 104.14,41.97 104.78,41.33 104.78,40.37 103.31,38.9 97.48,38.9 95.19,36.61 95.19,35.38 95.62,34.95 97.52,34.95 97.67,34.8 98.06,34.8 98.2,34.67 98.2,34.09 98.06,33.95
+5VS on BOTTOM: 138.35,109.63 138.53,109.81 138.53,111.55 138.48,111.6 138.24,111.6 138.15,111.51 138.15,111.1 137.85,110.8 136.53,110.8 135.54,109.81 135.54,108.21 135.69,108.05 135.89,108.05 136.15,108.31 136.15,109.48 136.3,109.63
+5VS on BOTTOM: 336.83,48.92 331.83,48.92 331.52,49.23 331.52,50.37 331.75,50.6 335.03,50.6 335.26,50.37 336.65,50.37 336.88,50.14 336.88,48.97
+5VS on IN1: 141.8,114.24 143,115.44 144.02,115.44 146.13,117.55 146.13,118.75 147.71,120.33 153.07,120.33 153.51,119.89 172.34,119.89 173.48,121.03 189.41,121.03 190.2,120.24 190.2,120.19 190.88,119.51 191.52,119.51 191.9,119.13 191.9,118.62 191.52,118.24 190.63,118.24 190.57,118.3 187.52,118.3 187.52,118.3 185.89,118.3 185.88,118.31 183.39,118.31 182.14,117.07 176,117.07 175.03,118.03 169.32,118.03 166.42,115.14 166.42,111.93 167.56,110.78 167.56,109.48 167.44,109.35 164.87,109.35 163.6,110.62 161.82,110.62 161.29,110.08 137.92,110.08 137.67,109.83 137.67,108.38 137.26,107.98 136.37,107.98 136.32,108.03 135.79,108.03 135.21,108.61 135.21,109.35 133.99,110.57 133.99,113.82 134.65,114.48 135.35,114.48 135.38,114.5 136.48,114.5 136.7,114.28 136.7,113.39 136.68,113.36 136.68,112.42 137.21,111.89 140.41,111.89 141.8,113.27 ; 1 cut-out
+5VS on IN1: 253.71,35.34 251.72,37.34 243.78,37.34 243.46,37.66 243.46,40.26 244.03,40.83 253.84,40.83 256.24,38.44 257.07,38.44 258.42,37.09 258.42,35.84 257.92,35.34
+5VS on IN1: 119.79,36.52 118.17,38.15 107.04,38.15 106.06,39.12 103.01,39.12 102.45,39.69 102.45,40.04 103.7,41.29 105.97,41.29 107.16,40.1 118.05,40.1 118.05,40.1 118.71,40.1 120.84,37.97 120.84,37.19 120.85,37.17 120.85,36.77 120.6,36.52
+5VS on IN2: 20.87,93.15 18.44,93.15 14.71,89.42 14.71,78.02 11.14,74.45 10.31,73.62 10.31,63.95 10.91,63.35 10.91,60.93 11.41,60.44 12.82,60.44 15.62,63.24 15.62,65.38 16.25,66 16.25,68.6 17.71,70.06 17.71,73.91 20.25,76.45 20.25,90.36 21.35,91.46 21.35,92.67
+5VS on IN3: 22.64,32.7 23.14,32.21 23.14,32.21 23.53,31.82 24.19,31.82 25.12,30.89 25.19,30.89 25.63,30.45 25.63,29.34 25.07,28.79 23.33,28.79 22.97,29.15 22.97,29.53 18.13,29.53 16.51,31.15 16.51,37.02 14.76,38.77 14.76,44.78 15.66,45.68 15.66,58.83 14.3,60.19 12.6,60.19 11.93,60.86 11.93,62.63 12.57,63.27 14.81,63.27 15.08,63 15.26,63 16.54,61.72 16.54,61.71 16.83,61.42 16.83,54.79 17.57,54.05 17.57,47.84 16.98,47.26 16.98,45.44 17.52,44.91 17.52,42.74 21.59,38.67 21.59,38.1 22.64,37.05
+5VS on IN4: 104.66,40.34 102.6,40.34 101.44,41.5 101.44,46.15 101.09,46.5 100.32,46.5 99.61,45.8 99.61,42.24 97.21,39.84 96.81,39.84 96.67,39.97 96.67,40.67 96.5,40.84 95.89,40.84 94.05,39.01 94.05,37.51 91.46,34.92 86.6,34.92 85.5,36.03 85.5,36.92 86.15,37.57 87.85,37.57 90.53,40.25 91.64,40.25 98.6,47.2 98.61,47.18 98.81,47.38 100.33,47.38 101.73,48.78 102.39,48.78 105.09,46.08 105.09,40.77
+5VS on IN4: 30.38,28.5 29.01,29.87 24.26,29.87 24.03,30.1 24.03,30.83 24.22,31.03 26.89,31.03 26.95,31.09 37.22,31.09 38.41,32.28 54.61,32.28 55.12,31.78 55.12,29.59 54.03,28.5
+5VS on VCC: 255,19.69 254,20.68 254,24.62 243.95,34.67 113.04,34.67 112.78,34.7 112.75,34.67 111.28,34.67 110.26,35.69 110.26,36.26 112.48,38.48 244.77,38.48 260.65,22.61 260.63,22.61 260.22,22.2 260.22,20.05 259.86,19.69
+5VS on IN5: 67.37,32.26 85.07,32.26 88.18,35.36 88.18,37.34 87.93,37.59 87.29,37.59 87.12,37.43 86.61,37.43 85.75,36.57 85.14,36.57 84.94,36.37 54.53,36.37 53.47,35.31 53.47,31.75 53.98,31.24 66.35,31.24
+5VS on IN5: 305.25,32.64 305.25,31.18 305.27,31.16 305.27,30.18 305.88,29.56 308.44,29.56 309.35,28.65 314.04,28.65 315.35,29.96 315.35,30.67 315.6,30.92 315.6,31.62 315.28,31.94 312.19,31.94 311.42,32.7 308.17,32.7 308.1,32.77 305.37,32.77
+5VS on IN5: 331.27,51.21 331.27,49.62 331.28,49.61 331.28,49.26 331.42,49.12 332.38,49.12 333.15,49.9 333.15,50.47 332.91,50.72 332.91,51.03 332.54,51.4 331.46,51.4
+5VS on IN6: 307.02,34.09 307.02,32.06 306.76,31.8 303.43,31.8 302.54,32.69 301.45,32.69 300.41,31.65 296.93,31.65 296.37,31.09 296.37,26.49 295.38,25.51 292.55,25.51 291.21,24.16 290.43,24.16 290.16,23.89 289.92,23.89 288.72,25.08 288.72,25.42 293.35,30.04 293.35,32.49 294.53,33.67 299.48,33.67 300.08,34.27 300.74,34.27 300.94,34.47 306.64,34.47
+5VS on IN6: 257.11,22.35 258.03,23.27 258.03,24.35 258.32,24.64 260.16,24.64 261.41,23.38 261.41,21.2 260.26,20.04 258.64,20.04 257.11,21.57
+5VS_AUDIO on TOP (solid shape): 6.95,9.17 8.38,9.17 8.77,8.78 8.77,7.76 8.72,7.71 7.02,7.71 6.71,8.03 5.41,8.03 5.21,8.23 4.73,8.23 4.32,8.64 4.32,9.18 4.87,9.73 6.39,9.73
+5VS_AUDIO on BOTTOM (solid shape): 15.42,39.28 15.42,38.68 15.32,38.58 15.32,37.33 15.24,37.26 14.82,37.26 14.57,37.5 14.2,37.5 14.12,37.58 14.12,37.58 14.01,37.69 14.01,38.48 14.16,38.63 14.64,38.63 14.75,38.74 14.75,39.28 14.83,39.35 15.35,39.35
+5VS_AUDIO on TOP: 12.81,35.06 12.47,35.4 12.47,36.25 12.49,36.25 12.8,36.56 12.8,37.01 12.97,37.17 13.49,37.17 13.71,37.39 13.71,39.09 13.31,39.49 13.31,40.4 13.45,40.55 15.05,40.55 15.06,40.53 15.05,40.51 15.05,37.61 14.81,37.36 14.56,37.36 14.56,37.35 14.51,37.35 14.28,37.12 14.28,36.19 14.25,36.16 14.25,36.04 13.79,35.58 13.79,35.19 13.66,35.06
+5VS_AUDIO on IN3: 7.05,15.75 7.05,17.59 8.64,19.18 8.64,22.99 14.7,29.05 14.7,36.48 14.03,37.15 14.03,38.61 14.16,38.74 14.61,38.74 16.26,37.09 16.26,25.27 10.99,20 10.99,15.75 9.27,14.03 8.38,14.03 7.97,13.62 7.97,12.54 6.22,10.8 6.22,9.53 5.65,8.95 3.62,8.95 3.24,9.34 3.24,11.94
+5VS_AUDIO_PVDD1 on BOTTOM (solid shape): 15.38,40.16 15.38,39.71 15.28,39.62 14.02,39.62 13.72,39.32 13.34,39.32 13.25,39.4 13.25,39.6 12.73,40.13 11.79,40.13 11.75,40.17 11.75,40.3 11.78,40.33 15.2,40.33
+5VS_AUDIO_PVDD2 on TOP (solid shape): 13.52,38.57 13.52,38.05 13.45,37.97 13.02,37.97 12.89,37.85 12.89,37.29 12.65,37.05 12.65,36.68 12.55,36.58 12.09,36.58 12.09,37.16 12.39,37.47 12.39,38.14 12.46,38.21 12.46,38.68 12.53,38.75 13.34,38.75
+5VS_AUDIO_PVDD2 on BOTTOM (solid shape): 13.66,38.49 13.66,38.07 13.54,37.94 13.17,37.94 12.99,38.13 11.76,38.13 11.71,38.17 11.71,38.28 11.76,38.33 12.74,38.33 12.99,38.57 13.58,38.57
+5VS_HDD on TOP: 236.86,9.27 236.62,9.51 236.62,9.95 236.47,10.1 233.68,10.1 233.55,10.22 233.55,11.24 234,11.69 236.13,11.69 236.89,12.45 238.76,12.45 239.02,12.19 239.02,10.54 238.76,10.29 237.75,10.29 237.49,10.03 237.49,9.4 237.36,9.27
+5VS_HDD on BOTTOM: 238.52,11.57 238.52,10.37 238.47,10.31 237.24,10.31 237.19,10.36 237.19,13.04 237.43,13.27 240.6,13.27 240.79,13.08 240.79,12.51 240.6,12.32 239.27,12.32 239.02,12.07 239.02,11.86 238.87,11.71 238.66,11.71
+AVDD1 on TOP (solid shape): 15.05,42.04 15.05,41.02 14.99,40.96 14.99,40.95 13.46,40.95 13.16,40.65 12.86,40.65 12.78,40.73 12.78,41.22 13.17,41.61 13.17,41.92 13.36,42.11 14.99,42.11
+AVDD1 on BOTTOM (solid shape): 15.19,41.89 15.37,41.89 15.46,41.8 15.46,41.26 15.41,41.2 13.75,41.2 13.06,40.51 11.79,40.51 11.74,40.57 11.74,40.67 11.8,40.74 12.6,40.74 12.66,40.8 12.74,40.8 13.21,41.27 13.21,41.72 13.25,41.76 13.72,41.76 13.86,41.9 15.18,41.9
+AVDD2 on TOP (solid shape): 4.08,42.17 4.08,40.98 4.58,40.47 4.58,39.24 4.49,39.15 4.12,39.15 3.94,39.22 3.75,39.15 2.97,39.15 2.85,39.27 2.85,42.16 3.04,42.34 3.91,42.34
+DVDD on BOTTOM (solid shape): 8.97,35.69 8.97,34.66 9.61,34.02 9.61,32.72 9.53,32.63 8.99,32.63 8.93,32.69 8.93,33.39 8.86,33.46 8.86,34.29 8.83,34.32 8.83,34.36 8.81,34.57 8.71,34.71 8.71,35.7 8.75,35.75 8.92,35.75
+DVDD on BOTTOM: 5.1,26.33 6.17,26.33 6.38,26.53 6.38,27.57 6.17,27.77 5.26,27.77 5.02,27.53 5.02,26.41
+DVDD on IN2: 8.66,32.14 6.85,30.34 6.85,27 6.32,26.46 4.12,26.46 3.68,26.91 3.68,30.72 3.97,31.01 3.97,32.56 6.53,35.12 10.69,35.12 11.57,34.24 11.57,32.3 11.4,32.14
+DVDD on IN3: 10.81,34.86 6.25,34.86 5.2,33.81 5.2,31.77 4.34,30.9 4.34,27.05 4.92,26.47 6.9,26.47 11.73,31.31 11.73,33.95
+DVDDIO on BOTTOM (solid shape): 5.55,37.91 5.55,37.76 5.5,37.71 4.63,37.71 4.55,37.62 4.29,37.62 3.94,37.27 3.62,37.27 3.48,37.41 3.48,37.72 3.67,37.91 4.63,37.91 4.67,37.95 5.51,37.95
+VBUS_1 on TOP (solid shape): 6.95,65.28 8.62,65.28 8.71,65.37 9.15,65.37 9.36,65.16 9.4,65.16 9.75,64.81 10.05,64.81 10.11,64.76 10.11,64.46 10.04,64.4 9.61,64.4 9.39,64.62 9.04,64.62 8.84,64.82 6.82,64.82 6.75,64.76 6.39,64.76 6.27,64.89 6.24,64.96 6.27,65.04 6.41,65.21 6.48,65.43 6.49,65.47 6.75,65.47
+VBUS_1 on TOP: 32,27.3 32.33,26.98 32.33,25.73 32.32,25.73 32.32,25.3 32.32,25.3 32.32,25.13 32.04,24.85 30.42,24.85 30.33,24.94 30.33,25.24 30.33,26.13 30.33,26.15 30.49,26.32 30.49,27.14 30.4,27.23 30.4,30.3 30.4,30.3 30.4,30.7 30.58,30.87 32.37,30.87 32.5,30.75 32.5,30.53 32,30.04
+VBUS_1 on TOP: 6.31,67.47 6.31,67.79 6.39,67.87 6.71,67.87 6.82,67.77 8.64,67.77 8.73,67.86 8.94,67.86 8.94,67.87 9.27,68.2 9.36,68.2 9.74,68.58 10.04,68.58 10.12,68.5 10.12,68.19 9.65,67.73 9.25,67.73 8.87,67.35 6.89,67.35 6.74,67.2 6.58,67.2
+VBUS_1 on BOTTOM: 8.41,65.02 8.41,65.08 7.65,65.08 7.39,64.81 6.4,64.81 6.22,64.99 6.22,65.25 6.24,65.27 6.38,65.41 7.11,65.41 7.37,65.66 7.37,66.8 6.99,67.18 6.44,67.18 6.22,67.4 6.22,67.65 6.35,67.79 8.61,67.79 8.7,67.88 8.83,67.88 9.54,68.59 9.98,68.59 10.09,68.48 10.09,68.14 10.1,68.14 10.1,68.01 10.67,67.44 10.67,66.91 10.8,66.78 11.9,66.78 11.94,66.74 12.32,66.74 12.5,66.92 12.5,67.51 12.12,67.88 12.12,68.51 11.86,68.77 11.37,68.77 11.05,69.09 11.05,69.85 11.18,69.98 11.18,70.88 11.25,70.96 12.04,70.96 12.17,70.83 12.17,70.03 12.22,69.98 12.32,69.98 12.57,69.72 15.56,69.72 15.9,69.39 15.9,67.95 15.89,67.94 15.89,67.75 15.04,66.9 13.24,66.9 12.72,66.38 12.72,66.07 13.06,65.74 13.06,65.41 13.27,65.19 13.55,65.19 13.69,65.06 13.69,64.29 13.55,64.15 13.21,64.15 12.69,63.63 9.8,63.63
+VBUS_1 on BOTTOM: 25.53,58.68 25.4,58.8 25.4,58.93 25.27,59.06 25.02,59.06 24.89,59.18 24.89,59.44 25.02,59.56 25.15,59.56 25.27,59.69 25.27,59.82 25.53,60.07 25.55,60.07 26.06,60.58 26.06,61.54 26.48,61.97 26.48,61.97 26.48,63.02 25.26,64.24 25.26,67.2 25.7,67.64 27.85,67.64 28.41,68.2 28.65,68.2 28.76,68.09 28.76,66.2 28.79,64.67 28.9,63.14 28.9,62.6 28.33,62.02 28.33,59.05 28.09,58.81 25.79,58.81 25.66,58.68
+VBUS_1 on VCC: 20.39,25.35 18.21,27.53 18.21,32.35 18.62,32.76 18.62,35 17.21,36.41 17.21,39.74 15.89,41.07 15.89,44.73 16.54,45.39 16.54,50.22 16.15,50.62 16.15,58.35 15.58,58.92 14.15,60.35 13.81,60.35 13.57,60.6 4.45,60.6 4.02,60.16 2.07,60.16 2.07,75.41 8.24,75.41 8.71,75.14 10.16,75.03 11.15,76.09 28.83,76.09 28.83,63.69 27.54,63.69 26.65,62.79 26.65,56.49 27.58,55.55 27.58,52.26 29.9,49.94 29.9,49.5 31.11,48.3 31.11,46.43 34.68,42.85 34.68,37.07 35.59,36.16 37.05,36.16 37.05,33.76 32.45,29.17 32.45,25.35
+VBUS_1 on IN5: 13.11,68.9 7.28,68.9 6.29,67.92 6.29,67.25 6.41,67.13 6.85,67.13 6.87,67.15 7.05,66.96 7.05,65.84 6.73,65.52 6.54,65.52 6.22,65.2 6.22,64.55 6.77,64 13.4,64 13.71,64.32 13.71,68.3
+VBUS_1 on IN6: 6.21,64.4 6.21,64.53 6.22,64.54 6.26,64.71 6.22,64.88 6.21,64.89 6.21,65.28 6.25,65.36 6.28,65.45 6.33,65.52 6.41,65.53 6.9,65.7 6.82,66.22 6.78,66.3 6.82,66.37 6.92,66.93 6.39,67.11 6.3,67.12 6.25,67.19 6.24,67.23 6.21,67.29 6.21,67.73 6.22,67.74 6.26,67.9 6.23,68.07 6.21,68.1 6.78,68.67 13.31,68.67 13.5,68.48 13.5,68.45 13.84,68.11 13.84,64.39 13.59,64.14 12.6,64.14 12.59,64.15 6.47,64.15
+VBUS_DC_SS on BOTTOM: 20.45,26.3 20.72,26.04 21.15,26.04 21.66,25.53 25.66,25.53 25.78,25.4 25.78,23.37 25.53,23.12 18.27,23.12 18.04,23.35 18.04,25 17.87,25.17 17.87,28.67 18.07,28.87 20.29,28.87 20.45,28.71
+VCC0V9_CIO on BOTTOM (solid shape): 28.31,41.93 28.36,41.95 28.41,41.95 28.54,41.86 28.7,41.85 28.72,41.85 28.75,41.82 28.77,41.75 28.8,41.71 28.83,41.67 28.89,41.64 28.89,41.42 28.82,41.36 28.7,41.23 28.7,40.73 28.54,40.58 28.54,39.93 28.4,39.78 28.05,39.78 27.91,39.92 27.91,39.94 27.87,40.03 27.81,40.09 27.81,40.36 27.91,40.55 27.81,40.74 27.81,40.85 28.25,41.3 28.26,41.31 28.34,41.52 28.26,41.73 28.25,41.75 28.25,41.87
+VCC0V9_CIO on IN6: 28.32,41.89 27.66,41.23 27.66,40.2 27.9,39.96 28.41,39.96 29.09,40.65 32.61,40.65 32.97,41.01 32.97,41.92 32.76,42.13 30.16,42.13 29.91,41.89
+VCC0V9_DP on BOTTOM (solid shape): 26.57,42.49 26.84,42.49 26.99,42.63 27.06,42.63 27.24,42.46 27.41,42.46 27.52,42.34 27.58,42.28 27.58,42.09 27.22,41.74 26.28,41.74 26.24,41.78 26.24,42.55 26.34,42.64 26.42,42.64
+VCC0V9_DP on BOTTOM (solid shape): 29.17,40.56 29.44,40.56 29.68,40.69 29.71,40.66 29.74,40.63 29.78,40.6 29.78,40.5 29.63,40.22 29.78,39.95 29.78,39.86 29.63,39.69 29.63,39.46 29.64,39.43 29.7,39.35 29.78,39.29 29.74,39.17 29.68,39.11 29.55,39.11 29.36,39.31 29.23,39.31 29.19,39.34 29.19,39.35 29.14,39.41 29.08,39.45 29.08,39.46 28.76,39.78 28.76,40.6 28.85,40.69 29.05,40.69
+VCC0V9_DP on TOP: outline of 124 points within 26.32,37.09 32.64,45.16
+VCC0V9_DP on IN3: 29.43,39.34 28.76,39.34 28.47,39.63 28.47,40.46 28.2,40.72 27.57,40.72 26.48,41.81 26.48,42.32 26.59,42.43 27.45,42.43 27.67,42.2 27.67,41.57 27.82,41.42 28.92,41.42 29.64,40.7 29.64,39.56
+VCC0V9_DP on IN6: 26.59,42.43 27.45,42.43 27.67,42.2 27.67,41.57 27.58,41.48 27.58,40.07 27.8,39.85 28.45,39.85 29.07,40.48 29.58,40.48 29.64,40.42 29.64,39.56 29.63,39.55 29.63,39.18 29.48,39.03 27.66,39.03 27.48,39.2 26.68,39.2 26.41,39.47 26.41,42.24
+VCC0V9_PCIE on TOP (solid shape): outline of 143 points within 25.79,34.88 29.19,39.19
+VCC0V9_PCIE on BOTTOM (solid shape): 27.17,39.33 27.2,39.27 27.19,39.21 27.03,38.92 27.21,38.63 27.24,38.62 27.24,38.3 27.24,38.3 27.16,38.22 27.16,37.9 27.03,37.76 27.03,37.49 27.23,37.29 27.49,37.29 27.63,37.43 27.72,37.43 27.76,37.39 27.81,37.35 27.81,36.59 27.77,36.56 27.73,36.51 27.59,36.51 27.35,36.74 27.27,36.74 27.13,36.89 26.94,36.89 26.78,36.73 26.65,36.73 26.45,36.53 26.32,36.53 26.28,36.57 26.28,36.73 26.39,36.97 26.28,37.22 26.28,37.38 26.36,37.49 26.39,37.63 26.39,37.65 26.48,37.74 26.54,37.78 26.58,37.83 26.6,38.01 26.48,38.15 26.44,38.23 26.47,38.31 26.54,38.38 26.54,38.43 26.61,38.6 26.54,38.77 26.54,39.08 26.6,39.17 26.61,39.29 26.64,39.36 26.71,39.39 27.11,39.39
+VCC0V9_PCIE on IN3: 26.5,39.42 27.74,39.42 27.89,39.26 27.89,36.95 27.56,36.61 26.54,36.61 26.29,36.87 26.29,39.2
+VCC0V9_PCIE on IN6: 27.89,38.68 27.89,36.95 27.56,36.61 26.54,36.61 26.29,36.87 26.29,38.98 26.45,39.14 27.43,39.14
+VCC_CORE on BOTTOM (solid shape): outline of 2522 points within 143.06,79.97 170.33,107.72
+VCC_CORE on TOP: outline of 119 points within 143.54,68.01 171.54,107.61 ; 1 cut-out
+VCC_CORE on BOTTOM: outline of 183 points within 153.27,67.75 173.17,69.71
+VCC_CORE on IN1: 170.27,88.96 170.45,88.79 170.45,84.55 170.2,84.31 170.2,78.91 170.39,78.72 170.39,73.93 170.41,73.91 170.41,73.79 171.93,72.26 171.93,69.09 172.64,68.38 172.64,68.01 172.39,67.76 172,67.76 171.63,68.13 167.7,68.13 167.23,68.59 166.97,68.59 166.75,68.68 166.52,68.59 165.12,68.59 164.88,68.7 164.63,68.59 163.74,68.59 163.27,68.13 158.88,68.13 158.4,67.65 153.93,67.65 153.6,67.98 153.6,68.41 154.08,68.89 153.92,69.05 153.92,81.77 153.6,82.09 153.6,88.25 154.32,88.96
+VCC_CORE on IN2: 161.58,67.7 161.11,68.17 158.82,68.17 158.82,68.17 158.75,68.1 153.8,68.1 153.6,68.29 153.6,69.13 153.67,69.2 153.67,84.77 153.68,84.78 153.43,85.04 153.43,86.87 151.97,88.33 150.65,88.33 147.23,91.75 147.23,99.05 147.78,99.59 147.78,107.36 148.13,107.71 149.2,107.71 149.55,107.36 160.68,107.36 162.13,105.91 162.13,93.85 167.36,88.62 168.86,88.62 169.74,87.75 169.74,87.21 170.53,86.42 170.53,81.79 170.56,81.76 170.56,78.51 171.2,77.87 173.28,77.87 173.54,77.61 173.53,77.49 173.58,77.37 173.59,77.35 173.59,76.96 173.51,76.74 173.59,76.52 173.59,76.17 173.58,76.15 173.52,75.97 173.58,75.78 173.59,75.76 173.59,73.83 173.58,73.81 173.53,73.64 173.58,73.46 173.59,73.44 173.59,73.04 173.58,73.02 173.52,72.84 173.58,72.65 173.59,72.63 173.59,71.41 173.58,71.39 173.53,71.21 173.58,71.03 173.59,71.01 173.59,69.14 173.55,69.08 173.47,69.03 173.38,69.07 173,69.17 172.79,68.83 173.05,68.54 173.41,68.7 173.49,68.74 173.58,68.71 173.59,68.68 173.59,68.3 173.58,68.28 173.56,68.23 173.55,68.17 173.54,68.15 173.1,67.7
+VCC_CORE on IN4: outline of 81 points within 145.6,67.91 172.77,108.03
+VCC_CORE on VCC: 154.67,53.6 154.18,54.08 154.18,67.67 152.4,69.45 152.4,78.89 153.54,80.03 153.54,85.72 151.26,88 149.92,88 148.75,89.17 146.14,89.17 144.3,91.01 144.3,93.17 133.48,103.99 133.48,104.82 139.91,111.25 154.29,111.25 154.94,110.6 154.94,107.49 156.64,105.79 166.14,105.79 166.69,105.24 166.69,96.54 168.55,94.68 172.04,94.68 172.98,93.75 172.98,87.02 175.01,84.99 175.01,54.34 174.27,53.6
+VCCGT on IN3 (solid shape): 121.82,84.43 121.82,82.68 122.35,82.14 122.95,82.14 123.31,81.79 123.31,80.42 121.73,78.84 121.73,71.82 119.2,69.29 116.89,69.29 116.36,69.83 116.36,70.03 116.89,70.56 116.89,71.22 115.9,72.21 115.9,81.97 116.26,82.32 117.76,82.32 118.03,82.6 118.03,83.26 117.12,84.18 117.12,84.66 117.33,84.87 121.38,84.87
+VCCGT on IN6 (solid shape): outline of 122 points within 115.9,69.29 124.13,85.01
