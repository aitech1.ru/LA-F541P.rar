# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PTX_DRX_N5: length 284.1
  IN3 w0.099: v2(311.67,38.38) 311.44,38.16 311.07,38.16 310.14,37.23 308.74,37.23 307.48,35.96 305.96,35.96 305.36,35.36 304.33,35.36 303.52,34.55 301.73,34.55 301,33.82 300.11,33.82 299.64,33.35 296.3,33.35 294.97,32.02 290.52,32.02 289.98,31.47 289.98,29.37 289.11,28.5 288.58,28.5 288.13,28.05 288.13,27.53 287.44,26.84 283.46,26.84 277.57,20.95 268.78,20.95 267.84,20 265.19,20 264.87,20.32 262.81,20.32 262.49,20 256.46,20 255.7,19.24 232.16,19.24 230.12,17.21 206.46,17.21 206.26,17.4 203,17.4 200.59,19.81 184.74,19.81 183.53,18.61 174.9,18.61 174,17.71 153.95,17.71 151.35,20.32 141.1,20.32 140.46,20.96 123.32,20.96 122.43,21.85 122.43,25.43 119.22,28.64 110.21,28.64 107.81,31.04 92.56,31.04 89.43,27.9 89.43,27.23 89.64,27.02 90.05,27.02 v2(90.18,26.9)
  BOTTOM w0.089: v2(90.18,26.9) 90.04,27.04 89.43,27.04 89.12,26.73 UH2.B21
  BOTTOM w0.152: v2(311.67,38.38) 311.82,38.23 312.42,38.23 312.73,38.53 312.73,39 313.94,40.21 328.98,40.21 330.33,38.86 330.33,36.54 332.11,34.76 332.11,33.69 334.68,31.11 338.89,31.11 339.93,32.15 340.71,32.15 340.87,32.31 340.87,32.84 340.64,33.07 CR9.1
PCIE_PTX_DRX_N09: length 193.6
  IN1 w0.107: v2(82.35,27.12) 82.77,27.53 82.77,27.53 82.87,27.64 84.58,27.64 85.31,28.37 85.87,28.37 86.35,27.89 86.67,27.89 88.6,29.82 89.06,29.82 91.08,31.84 91.89,31.84 93.7,33.66 98.01,33.66 101.46,37.1 104.58,37.1 106.02,35.67 116.66,35.67 118.01,34.31 138.22,34.31 141.58,30.95 141.58,29.22 142.25,28.55 143.24,28.55 144.58,27.21 152.68,27.21 154.34,25.54 154.34,24.46 154.34,23.43 155.23,22.55 155.23,22.54 156.27,21.5 156.88,21.5 159.16,19.22 173.89,19.22 173.95,19.28 180.9,19.28 181.09,19.09 186.95,19.09 187.05,19.19 251.65,19.19 253.59,17.25 v2(253.89,17.25)
  BOTTOM w0.089: UH2.C34 82.67,26.04 82.67,26.5 82.51,26.65 82.51,26.96 v2(82.35,27.12)
  BOTTOM w0.152: CD43.1 256.62,20.23 256.62,19.87 256.5,19.75 255.8,19.75 255.59,19.53 254.96,19.53 254.23,18.81 254.23,17.43 254.05,17.25 v2(253.89,17.25)
PCIE_PTX_DRX_N10: length 195.9
  IN1 w0.107: v2(256.49,18.38) 256.29,18.18 256.29,17.88 256.07,17.65 254.28,17.65 251.53,20.41 251.06,20.41 250.54,19.88 186.5,19.88 186.15,19.53 181.9,19.53 181.33,20.11 173.86,20.11 173.51,19.75 159.27,19.75 157.15,21.87 157.15,25.64 156.6,26.19 154.28,26.19 152.83,27.64 144.75,27.64 143.46,28.93 143.46,30.13 138.86,34.72 118.28,34.72 116.3,36.7 105.57,36.7 104.75,37.51 101.27,37.51 97.84,34.09 93.53,34.09 92.08,32.64 91.28,32.64 89,30.35 87.93,30.35 86.4,28.83 84.73,28.83 83.79,27.88 82.8,27.88 82.55,27.63 82.07,27.63 81.87,27.84 81.87,28.16 v2(81.72,28.3)
  BOTTOM w0.089: v2(81.72,28.3) 81.72,26.93 81.89,26.69 82.06,26.52 82.06,26.5 82.08,26.48 82.08,26.05 UH2.C35
  BOTTOM w0.152: v2(256.49,18.38) 256.4,18.29 256.4,17.65 256.57,17.49 256.78,17.49 CD45.1
PCIE_PTX_DRX_N11: length 194.4
  IN1 w0.107: v2(255.48,15.36) 255.38,15.46 255.38,16.04 254.98,16.44 254.4,16.44 253.99,16.03 253.14,16.03 252.9,16.27 252.9,17.04 252.06,17.88 176.45,17.88 175.92,18.42 174.57,18.42 174.1,17.95 159.22,17.95 156.48,20.69 155.88,20.69 155.08,21.49 152.81,21.49 151.69,22.62 151.69,25.92 151.01,26.6 144.25,26.6 142.98,27.86 141.91,27.86 140.67,29.11 140.67,30.84 138.52,33 118.35,33 116.39,34.95 100.18,34.95 98.25,33.02 93.97,33.02 92.18,31.23 91.36,31.23 87.24,27.12 85.46,27.12 84.84,26.49 82.45,26.49 v2(81.56,25.6)
  BOTTOM w0.089: v2(81.56,25.6) 81.39,25.98 81.39,26.12 81.47,26.28 81.52,26.33 UH2.B36
  BOTTOM w0.152: CD53.1 256.69,14.69 256.17,14.17 255.73,14.17 255.13,14.77 255.13,15.23 255.25,15.36 v2(255.48,15.36)
PCIE_PTX_DRX_P1: length 313.9
  IN1 w0.107: v2(330.74,80.37) 330.96,80.6 331.11,80.6 331.34,80.36 331.34,75.44 329.28,73.38 329.28,66.64 332.5,63.42 332.5,59.53 331.56,58.59 331.56,56.47 329.74,54.65 329.74,52.16 328.98,51.39 328.98,40.28 326.89,38.19 326.89,37.49 324.53,35.13 315.38,35.13 312.94,32.69 312.94,30.57 311.77,29.4 311.12,29.4 306.52,24.79 305.17,24.79 302.9,22.52 295,22.52 294.31,21.83 294.31,20.53 293.59,19.81 290.47,19.81 289.37,18.72 287.95,18.72 287.34,18.11 284.8,18.11 284.16,18.75 276.17,18.75 275.49,19.43 271.87,19.43 270.12,17.68 266.11,17.68 265.51,17.08 265.51,16.66 265.76,16.41 265.97,16.41 v2(266.17,16.2)
  IN3 w0.089: v2(91.53,27.13) 91.73,27.33 91.89,27.33 91.98,27.24 91.98,25.72 93.05,24.65 93.05,24.09 94.28,22.86 96.38,22.86 100.06,26.54 101.95,26.54 101.96,26.53 101.98,26.53
  IN3 w0.099: 101.98,26.53 106.53,26.53 107.04,27.05 107.91,27.05 109.36,25.6 109.36,21.8 109.93,21.23 114.68,21.23 117.17,18.74 120.52,18.74 122.24,17.02 126.92,17.02 127.56,16.38 138.54,16.38 138.81,16.11 144.36,16.11 145.1,15.37 152.08,15.37 152.3,15.15 177.94,15.15 178.52,15.72 200.51,15.72 201.43,14.8 204.78,14.8 205.04,14.54 231.6,14.54 232.15,15.09 244.99,15.09 246.07,14.01 248.93,14.01 249.93,15 252.22,15 253.22,14.01 256.07,14.01 256.83,14.77 260.2,14.77 261.77,16.34 263.8,16.34 264.05,16.6 265.78,16.6 v2(266.17,16.2)
  BOTTOM w0.089: UH2.B17 91.32,26.92 v2(91.53,27.13)
  BOTTOM w0.152: v2(330.74,80.37) 330.88,80.52 331.18,80.52 CN21.1
PCIE_PTX_DRX_P5: length 284.2
  IN3 w0.099: v2(90.2,27.49) 90.2,27.47 89.94,27.21 89.72,27.21 89.62,27.31 89.62,27.82 92.64,30.85 107.74,30.85 110.14,28.45 119.14,28.45 122.24,25.35 122.24,21.77 123.25,20.77 140.38,20.77 141.02,20.13 151.27,20.13 153.87,17.52 174.08,17.52 174.97,18.42 183.61,18.42 184.82,19.62 200.51,19.62 202.92,17.21 206.19,17.21 206.38,17.02 230.2,17.02 232.24,19.05 255.78,19.05 256.54,19.81 262.57,19.81 262.89,20.13 264.79,20.13 265.11,19.81 267.91,19.81 268.86,20.76 277.65,20.76 283.54,26.65 287.52,26.65 288.32,27.45 288.32,27.97 288.66,28.31 289.19,28.31 290.17,29.3 290.17,31.4 290.6,31.83 295.04,31.83 296.38,33.16 299.72,33.16 300.19,33.63 301.08,33.63 301.81,34.36 303.6,34.36 304.41,35.17 305.44,35.17 306.04,35.77 307.56,35.77 308.82,37.04 310.22,37.04 311.14,37.97 311.44,37.97 v2(311.67,37.75)
  BOTTOM w0.089: UH2.A22 89.04,27.1 89.22,27.1 89.35,27.23 89.94,27.23 v2(90.2,27.49)
  BOTTOM w0.152: v2(311.67,37.75) 311.82,37.9 312.56,37.9 313.06,38.4 313.06,38.86 314.07,39.88 328.84,39.88 330,38.73 330,36.4 331.78,34.62 331.78,33.55 334.55,30.78 v3(335.17,30.78) 339.03,30.78 340.06,31.82 340.84,31.82 341.2,32.18 341.2,32.8 CR7.1
PCIE_PTX_DRX_P09: length 193.5
  IN1 w0.107: v2(82.93,27.09) 82.86,27.17 82.86,27.34 82.95,27.43 84.66,27.43 85.4,28.17 85.78,28.17 86.27,27.69 86.75,27.69 88.69,29.62 89.15,29.62 91.17,31.64 91.97,31.64 93.79,33.45 98.1,33.45 101.54,36.9 104.5,36.9 105.93,35.46 116.57,35.46 117.93,34.11 138.13,34.11 141.38,30.86 141.38,29.13 142.16,28.35 143.16,28.35 144.49,27.01 152.59,27.01 154.14,25.46 154.14,24.46 154.14,23.35 156.19,21.3 156.8,21.3 159.08,19.02 173.97,19.02 174.03,19.08 180.82,19.08 181.01,18.89 187.03,18.89 187.13,18.99 251.56,18.99 v2(253.89,16.66)
  BOTTOM w0.089: v2(82.93,27.09) 82.78,26.94 82.78,26.76 82.93,26.61 82.93,25.84 82.78,25.69 UH2.D34
  BOTTOM w0.152: CD44.1 257.03,19.81 256.64,19.42 255.94,19.42 255.73,19.2 255.09,19.2 254.56,18.67 254.56,17.29 253.93,16.66 v2(253.89,16.66)
PCIE_PTX_DRX_P10: length 195.9
  IN1 w0.107: v2(82.29,28.3) 82.21,28.3 82.07,28.16 82.07,27.93 82.16,27.84 82.47,27.84 82.72,28.09 83.7,28.09 84.65,29.03 86.32,29.03 87.85,30.56 88.91,30.56 91.2,32.84 92,32.84 93.45,34.29 97.76,34.29 101.18,37.71 104.84,37.71 105.65,36.9 116.39,36.9 118.36,34.93 138.95,34.93 143.66,30.21 143.66,29.02 144.83,27.85 152.91,27.85 154.37,26.39 156.69,26.39 157.35,25.72 157.35,21.96 159.36,19.96 173.42,19.96 173.78,20.31 181.41,20.31 181.99,19.74 186.07,19.74 186.42,20.09 250.45,20.09 250.98,20.61 251.61,20.61 254.37,17.86 255.98,17.86 256.09,17.96 256.09,18.31 256.01,18.38 v2(255.86,18.38)
  BOTTOM w0.089: v2(82.29,28.3) 82.24,28.3 81.99,28.05 81.99,27.01 82.09,26.86 82.32,26.63 UH2.B35
  BOTTOM w0.152: CD46.1 256.95,17.01 256.8,17.16 256.43,17.16 256.07,17.51 256.07,18.26 255.95,18.38 v2(255.86,18.38)
PCIE_PTX_DRX_P11: length 194.5
  IN1 w0.107: v2(254.7,15.36) 254.9,15.36 255.18,15.64 255.18,15.96 254.9,16.24 254.49,16.24 254.08,15.83 253.05,15.83 252.69,16.19 252.69,16.96 251.98,17.68 176.37,17.68 175.83,18.21 174.65,18.21 174.18,17.74 159.14,17.74 156.4,20.49 155.8,20.49 155,21.29 152.73,21.29 151.49,22.53 151.49,25.84 150.93,26.39 144.16,26.39 142.89,27.66 141.83,27.66 140.46,29.02 140.46,30.76 138.43,32.79 118.26,32.79 116.31,34.75 100.26,34.75 98.33,32.82 94.06,32.82 92.27,31.03 91.44,31.03 87.33,26.91 85.55,26.91 84.92,26.29 82.53,26.29 81.94,25.7 81.94,25.21 v2(81.89,25.16)
  BOTTOM w0.089: UH2.C36 81.98,25.76 81.98,25.25 v2(81.89,25.16)
  BOTTOM w0.152: v2(254.7,15.36) 254.8,15.26 254.8,14.64 255.59,13.84 CD51.1
PCIE_PTX_TRX_N17: length 59.9
  IN6 w0.089: 75.2,27.11 75.22,27.09 75.22,27.08 75.42,26.88 75.62,26.68 78.83,26.68 79.18,26.34 81.49,26.34 81.69,26.54 81.69,27.3 81.39,27.6 80.1,27.6 79.62,28.09 79.56,28.09 79.37,28.09 79.32,28.04 79.32,27.79 79.25,27.73 v2(79.06,27.73)
  IN6 w0.107: v2(35.56,33.44) 35.66,33.54 35.79,33.54 35.91,33.41 35.91,33.08 35.99,33.01 36.11,33.01 36.87,33.77 37.53,33.77 38.33,32.97 39.46,32.97 42.07,30.35 42.27,30.35 42.39,30.48 42.39,30.77 42.64,31.01 43.17,31.01 43.42,30.77 43.42,30.48 43.54,30.35 43.83,30.35 43.96,30.48 43.96,31.18 44.21,31.42 44.74,31.42 44.98,31.18 44.98,30.48 45.11,30.35 55.2,30.35 55.39,30.55 64.59,30.55 66.13,29.01 68.32,29.01 68.53,29.22 73.09,29.22 75.2,27.11
  BOTTOM w0.089: v2(79.06,27.73) 79.06,27.87 78.98,27.95 78.73,27.95 78.65,27.87 78.65,27.1 78.75,27 78.95,27 79.03,27.09 79.03,27.14 UH2.A42
  BOTTOM w0.152: v2(35.56,33.44) 35.36,33.23 35,33.23 CT177.2
PCIE_PTX_TRX_N18: length 63
  IN6 w0.107: v2(31.7,31.95) 31.7,32.3 31.55,32.45 31.33,32.45 30.96,32.82 30.96,32.93 31.11,33.07 31.79,33.07 31.92,32.94 34.48,32.94 35.75,34.21 37.74,34.21 38.09,33.86 39.64,33.86 40.34,33.17 40.34,32.95 41.06,32.23 43.05,32.23 43.41,31.86 44.93,31.86 45.59,31.2 49.11,31.2 49.56,31.66 51.99,31.66 52.68,30.96 64.9,30.96 66.4,29.47 68.17,29.47 68.38,29.67 73.25,29.67 75.93,26.99 78.07,26.99 78.49,27.4 78.49,28.37 79.3,29.19 80.75,29.19 80.91,29.02 80.91,28.79 80.66,28.53 80.5,28.53 80.39,28.64 v2(80.39,28.77)
  BOTTOM w0.076: 79.42,27.24 79.41,27.22 79.41,27.16 79.04,26.79 79.04,26.16 78.89,26.01 78.81,26.01 78.76,26.06 UH2.C42
  BOTTOM w0.089: v2(80.39,28.77) 79.96,28.77 79.87,28.67 79.87,28.35 79.49,27.97 79.49,27.31 79.42,27.24
  BOTTOM w0.152: CT174.2 31.23,32.51 31.7,32.04 v2(31.7,31.95)
PCIE_PTX_TRX_N19: length 67.1
  IN6 w0.089: v2(77.77,26.05) 77.77,25.89 77.28,25.4 76.64,25.4 76.36,25.12 76.36,24.56 76.88,24.04 78.32,24.04 80.27,22.08 80.27,21.14 80.01,20.88 79.46,20.88 78.72,21.62 77.71,21.62 77.32,22.02 76.57,22.02 75.3,23.29 75.22,23.37 75.22,23.39 75.2,23.4
  IN6 w0.107: v2(28.66,31.93) 28.45,31.72 28.45,31.5 28.6,31.35 29.06,31.35 29.56,30.86 37.75,30.86 38.79,29.82 39.9,29.82 41.25,28.48 55.27,28.48 55.64,28.11 56.83,28.11 57.43,27.51 63.45,27.51 63.88,27.08 63.88,26.18 64.2,25.85 71.92,25.85 73.83,23.94 74.66,23.94 75.2,23.4
  BOTTOM w0.089: UH2.C44 78.16,26.03 78.04,25.91 77.9,25.91 v2(77.77,26.05)
  BOTTOM w0.152: v2(28.66,31.93) 28.56,32.03 28.56,32.4 CT8.2
PCIE_PTX_TRX_N20: length 61.7
  IN6 w0.107: v2(26.29,31.93) 25.91,32.31 25.91,32.71 26.21,33.01 29.89,33.01 30.57,33.69 33.71,33.69 35,34.98 37.99,34.98 38.45,34.52 39.9,34.52 41.12,33.3 42.93,33.3 43.74,32.49 45.2,32.49 45.87,31.82 48.8,31.82 49.25,32.27 54.78,32.27 55.38,31.68 55.78,31.68 56.37,32.27 57.43,32.27 57.81,31.89 58.15,31.89 58.53,32.27 59.3,32.27 59.55,32.01 60.21,32.01 60.52,32.32 60.8,32.32 61.22,31.9 61.6,31.9 62.02,32.32 62.44,32.32 62.8,31.96 63.29,31.96 63.65,32.32 64.44,32.32 66.66,30.1 67.87,30.1 68.05,30.28 75.65,30.28 77.12,28.81 77.12,28.44 77.65,27.91 77.65,27.82 v2(77.8,27.67)
  BOTTOM w0.089: UH2.A44 77.85,27.09 77.71,26.95 77.62,26.95 77.57,27.01 77.57,27.36 77.43,27.49 77.43,27.65 77.55,27.76 77.72,27.76 v2(77.8,27.67)
  BOTTOM w0.152: CT4.2 26.18,32.47 26.1,32.39 26.1,32.12 v2(26.29,31.93)
PCIE_PTX_TRX_P17: length 60
  IN6 w0.089: 75.06,26.97 75.07,26.95 75.09,26.95 75.54,26.5 78.75,26.5 79.1,26.15 81.57,26.15 81.88,26.46 81.88,27.38 81.47,27.79 80.18,27.79 79.66,28.31 v2(79.07,28.31)
  IN6 w0.107: 75.06,26.97 73.01,29.01 68.61,29.01 68.4,28.8 66.05,28.8 64.51,30.35 55.48,30.35 55.28,30.15 45.02,30.15 44.78,30.4 44.78,31.09 44.65,31.22 44.29,31.22 44.16,31.09 44.16,30.4 43.92,30.15 43.46,30.15 43.21,30.4 43.21,30.68 43.09,30.81 42.72,30.81 42.6,30.68 42.6,30.4 42.35,30.15 41.99,30.15 39.37,32.77 38.25,32.77 37.45,33.56 36.96,33.56 36.2,32.81 v2(35.56,32.81)
  BOTTOM w0.089: UH2.B42 78.77,26.74 78.64,26.74 78.38,26.99 78.38,27.98 78.62,28.22 78.98,28.22 v2(79.07,28.31)
  BOTTOM w0.152: CT176.2 34.9,32.9 35.46,32.9 v2(35.56,32.81)
PCIE_PTX_TRX_P18: length 63
  IN6 w0.107: v2(31.12,31.95) 31.12,32.38 30.76,32.73 30.76,33.01 31.03,33.28 31.88,33.28 32.01,33.14 34.4,33.14 35.67,34.42 37.82,34.42 38.18,34.06 39.73,34.06 40.54,33.25 40.54,33.03 41.14,32.43 43.14,32.43 43.5,32.07 45.01,32.07 45.68,31.4 49.02,31.4 49.48,31.86 52.07,31.86 52.76,31.17 64.98,31.17 66.48,29.67 68.09,29.67 68.29,29.87 73.33,29.87 76.01,27.19 77.99,27.19 78.28,27.49 78.28,28.46 79.22,29.39 80.84,29.39 81.12,29.11 81.12,28.71 80.74,28.33 80.51,28.33 v2(80.37,28.18)
  BOTTOM w0.076: 79.76,27.31 79.76,27.26 79.21,26.71 79.21,26.09 UH2.D42
  BOTTOM w0.089: v2(80.37,28.18) 80.08,28.18 79.76,27.86 79.76,27.31
  BOTTOM w0.152: v2(31.12,31.95) 31.06,31.95 30.57,32.44 CT175.2
PCIE_PTX_TRX_P19: length 67.1
  IN6 w0.089: 75.06,23.26 75.07,23.24 75.09,23.24 76.5,21.83 77.24,21.83 77.63,21.44 78.64,21.44 79.38,20.69 80.09,20.69 80.46,21.06 80.46,22.16 78.39,24.22 76.96,24.22 76.54,24.64 76.54,25.04 76.72,25.22 77.36,25.22 77.65,25.51 v2(77.93,25.51)
  IN6 w0.107: v2(28.08,31.93) 28.25,31.75 28.25,31.41 28.51,31.15 28.98,31.15 29.47,30.66 37.66,30.66 38.7,29.62 39.82,29.62 41.16,28.28 55.19,28.28 55.56,27.91 56.74,27.91 57.34,27.31 63.36,27.31 63.68,26.99 63.68,26.09 64.12,25.65 71.84,25.65 73.75,23.74 74.58,23.74 75.06,23.26
  BOTTOM w0.089: v2(77.93,25.51) 78.33,25.75 UH2.D43
  BOTTOM w0.152: CT6.2 28.23,32.41 28.23,32.08 v2(28.08,31.93)
PCIE_PTX_TRX_P20: length 61.7
  IN6 w0.107: v2(77.8,28.3) 77.55,28.3 77.33,28.52 77.33,28.89 75.73,30.49 67.97,30.49 67.79,30.3 66.75,30.3 64.53,32.52 63.57,32.52 63.2,32.16 62.89,32.16 62.52,32.52 61.93,32.52 61.52,32.11 61.3,32.11 60.89,32.52 60.43,32.52 60.13,32.22 59.64,32.22 59.38,32.47 58.45,32.47 58.07,32.09 57.89,32.09 57.51,32.47 56.29,32.47 55.7,31.88 55.46,31.88 54.86,32.48 49.17,32.48 48.71,32.02 45.95,32.02 45.28,32.69 43.82,32.69 43.01,33.5 41.21,33.5 39.99,34.72 38.53,34.72 38.08,35.18 34.92,35.18 33.63,33.89 30.49,33.89 29.81,33.22 26.12,33.22 25.71,32.8 v2(25.71,31.93)
  BOTTOM w0.089: v2(77.8,28.3) 78.17,27.93 78.17,27.03 UH2.B44
  BOTTOM w0.152: CT2.2 25.76,32.44 25.76,31.99 v2(25.71,31.93)
PCIE_RCOMPN: length 2.8
  TOP w0.381: RH108.1 92.95,28.82 v2(93.56,28.82)
  BOTTOM w0.089: 93.54,27.81 93.54,26.74 UH2.B12
  BOTTOM w0.14: 93.56,27.98 93.54,27.93 93.54,27.81
  BOTTOM w0.381: 93.56,27.98 v2(93.56,28.82)
PCIE_RCOMPP: length 1.5
  TOP w0.381: v2(92.8,27.81) 92.5,28.11 RH108.2
  BOTTOM w0.178: UH2.A13 92.8,27.74 v2(92.8,27.81)
PCIE_WAKE#: length 363.1
  TOP w0.14: v2(271.48,9.53) 271.48,9.44 270.74,8.7 v1(270.47,8.7) 268.55,8.7 RD59.2 ; RT5849.1 71.97,4.36 72.21,4.13 72.51,4.13 72.73,3.9 72.73,3.64 v2(72.8,3.57)
  IN2 w0.099: v2(106.92,5.87) 106.49,5.44 105.92,5.44 104.18,3.71 102.35,3.71 102.11,3.95 100.47,3.95 99.35,2.83 98.2,2.83 96.89,4.14 91.94,4.14 90.78,5.29 90.04,5.29 89.33,4.58 87.71,4.58 87.53,4.77 85.2,4.77 84.9,5.07 84.18,5.07 83.36,4.26 82.67,4.26 82.31,4.61 82.31,4.83 82.07,5.07 80.41,5.07 80.31,4.97 79.87,4.97 78.12,3.22 77.57,3.22 77.03,2.68 74.8,2.68 74.3,3.19 73.63,3.19 73.25,3.57 v2(72.8,3.57)
  IN3 w0.091: v2(305.18,22.88) 304.62,22.88 304.42,23.08 299.89,23.08 299.76,22.95 295.05,22.95 294.51,22.41 291.77,22.41 289.84,20.47 289.24,20.47 286.24,17.47 284.66,17.47 283.49,16.31 283.49,15.43 281.18,13.12 281.18,9.91 280.93,9.65 271.61,9.65 v2(271.48,9.53) 270.46,8.51 257.3,8.51 256.67,9.15 240.79,9.15 240.29,8.64 235.46,8.64 235.08,9.02 214.76,9.02 213.36,10.42 204.6,10.42 202.78,8.6 199.99,8.6 199.38,7.99 189.02,7.99 188.63,7.6 184.04,7.6 183.55,8.09 179.3,8.09 179.25,8.14 168.03,8.14 167.92,8.02 160.73,8.02 159.92,7.21 151.69,7.21 150.88,8.03 150.34,8.03 149.66,8.71 147.73,8.71 147.43,8.42 146.86,8.42 146.17,9.11 145.59,9.69 141.53,9.69 140.7,8.86 136.8,8.86 136.38,9.27 133.84,9.27 133.48,9.64 130.65,9.64 128.89,11.41 126.54,11.41 126.17,11.04 123.12,11.04 121.99,9.91 121.02,9.91 117.8,6.69 117,6.69 116.28,5.97 115.98,5.97 115.84,5.83 115.84,5.39 115.48,5.03 111.73,5.03 111.44,5.32 107.18,5.32 106.92,5.58 v2(106.92,5.87)
  IN6 w0.099: v2(334.84,88.08) 334.84,87.55 331.95,84.66 331.95,76.35 330.68,75.08 330.68,65.73 331.35,65.05 331.35,63.25 331.57,63.03 331.57,57.92 330.05,56.4 330.05,51.05 328.94,49.94 328.94,44.16 327.87,43.09 327.87,40.22 326.52,38.86 320.04,38.86 318.39,37.21 317.35,37.21 311.66,31.52 311.66,30.79 311.43,30.56 311.43,30 309.47,28.04 309.47,26.77 305.58,22.88 v2(305.18,22.88)
  BOTTOM w0.14: v2(334.84,88.08) 335.46,88.7 340.52,88.7 340.95,89.12 341.7,89.12 342.54,88.29 342.54,86.72 342.15,86.34 342.15,85.37 342.05,85.27 JNGFF1.47 ; RE323.1 RE322.2 305.84,28.59 305.32,28.07 305.32,26.16 306.11,25.36 306.11,23.81 v2(305.18,22.88)
PCIE_WAKE#_R: length 13.2
  TOP w0.14: RE19.1 306.11,23.96 v2(305.67,23.96) 304.67,22.97 304.67,21.08 UE3.N13
  BOTTOM w0.14: v2(305.67,23.96) 304.87,24.76 304.87,27.77 304.53,28.11 v1(304.53,29.81) 305.09,30.37 RE323.2
PD_DEBUG_CTRL1: length 3.1
  TOP w0.14: v2(21.65,57.56) 21.63,57.56 21.21,57.98 21.21,59.44 21.25,59.48 RT226.2
  BOTTOM w0.081: UT4.E4 21.96,57.53 21.68,57.53 v2(21.65,57.56)
PD_DEBUG_CTRL2: length 11.7
  TOP w0.14: v2(23.12,63.07) 23.78,63.07 v1(24.21,62.64) 24.68,62.17 24.68,61.81 24.87,61.62 24.87,60.99 25.44,60.41 RT227.2
  IN2 w0.099: v2(22.18,56.53) 22.24,56.59 22.24,58.9 22.07,59.07 22.07,60.41 22.47,60.81 22.47,61.94 23.12,62.59 v2(23.12,63.07)
  BOTTOM w0.081: v2(22.18,56.53) 22.52,56.87 UT4.D5
PD_EE_CLK: length 49.2
  TOP w0.14: UT5.6 47.13,27.23 v2(47.14,27.24) 47.14,27.23 v1(47.88,26.49)
  IN2 w0.089: 27.38,46.36 27.38,45.73 27.96,45.15 30.06,45.15 30.44,44.77
  IN2 w0.099: v2(47.14,27.24) 44.91,29.47 44.91,32.77 43.67,34.01 41.74,34.01 39.88,32.16 38.69,32.16 35.25,35.6 34.8,35.6 34.52,35.88 33.91,35.88 33.4,36.39 33.4,40.51 33.71,40.82 33.71,41.75 32.96,42.5 32.72,42.5 30.44,44.77 ; 27.38,46.36 27.38,47.8 25.78,49.4 25.78,51.56 22.99,54.36 v2(21.85,54.36)
  BOTTOM w0.081: UT4.A3 21.54,55.3 21.54,54.66 21.75,54.45
  BOTTOM w0.14: 21.75,54.45 v2(21.85,54.36)
PD_EE_CS#: length 40.2
  TOP w0.14: UT5.1 39.5,29.77 v2(38.92,30.35)
  IN2 w0.099: v2(38.92,30.35) 37.56,30.35 36.04,31.86 36.04,33.86 35.08,34.83 34.89,34.83 34.22,35.5 33.69,35.5 33.08,36.1 33.08,40.68 33.4,41 33.4,41.8 32.89,42.31 32.52,42.31 29.9,44.93 27.63,44.93 25.69,46.87 25.69,47.59 24.64,48.64 24.64,51.82 23.52,52.93 22.17,52.93 v2(21.51,52.28)
  BOTTOM w0.081: UT4.B3 21.86,55.63 21.86,55.18 22.3,54.74 22.3,54.45
  BOTTOM w0.14: v2(21.51,52.28) 21.46,52.33 21.46,53.42 21.59,53.54 21.72,53.54 RT168.2 21.85,53.75 22.3,54.2 22.3,54.45
PD_EE_DI: length 52.5
  TOP w0.14: UT5.5 46.94,25.96 v2(47.17,26.19) 47.4,25.96 v1(47.4,25.08)
  IN2 w0.089: 25.66,46.18 27.29,44.55 28.74,44.55 29.06,44.24 29.06,43.85 28.84,43.64 28.84,43.31 29.72,42.43 31.48,42.43 32.37,41.55 32.37,36.58 ; 33.66,33.53 33.27,33.53 32.37,34.43 32.37,36.25
  IN2 w0.099: 33.66,33.53 34.08,33.53 34.78,32.83 34.78,32.56 37.99,29.35 37.99,28.29 39.01,27.26 46.14,27.26 47.17,26.24 v2(47.17,26.19) ; 25.66,46.18 24.68,47.17 24.32,47.17 24,47.49 24,50.93 23.5,51.44 21.78,51.44 21.11,52.11 21.11,52.77 21.43,53.08 21.43,53.91 21.33,54.01 21.33,54.6 21.82,55.08 21.82,56.23 v2(21.6,56.45) ; 32.37,36.58 32.37,36.25
  BOTTOM w0.081: UT4.B4 21.6,56.39 v2(21.6,56.45)
PD_EE_DO: length 39.4
  TOP w0.14: v2(38.91,28.54) 40.27,28.54 UT5.2
  IN2 w0.099: v2(22.19,51.96) 23.86,51.96 24.39,51.44 24.39,48.5 25.17,47.71 25.17,47.1 27.55,44.73 29.85,44.73 32.45,42.13 32.81,42.13 33.1,41.85 33.1,41.07 32.83,40.81 32.83,34.42 33.4,33.85 34.05,33.85 34.98,32.91 34.98,32.64 38.26,29.37 38.26,29.19 v2(38.91,28.54)
  BOTTOM w0.14: v2(22.19,51.96) 22.3,52.07 22.63,52.07 22.91,52.36 22.91,53.47 22.71,53.67 RT169.2 22.48,53.87 22.58,53.98 22.58,54.76 22.41,54.94 22.41,55.08 UT4.A4
PD_EE_WP#: length 43.8
  TOP w0.14: UT5.3 41.06,27.98 41.06,30 40.9,30.16 40.9,32.68 v1(40.4,33.17) 40.25,33.33 39.35,33.33 v2(39.28,33.39) ; v2(26.09,61.09) 26.09,60.65 25.85,60.41 25.85,59.79 RT170.2
  IN2 w0.099: v2(26.09,61.09) 26.09,60.8 25.69,60.4 25.69,55.14 25.83,55 25.83,52.29 28.71,49.4 29.15,49.4 29.83,48.72 29.83,47.31 30.74,46.41 30.74,45.53 32.01,44.26 32.01,44.03 32.6,43.44 33.14,43.44 34.48,42.1 34.48,38.7 36.57,36.61 37.46,36.61 38.31,35.77 38.31,34.57 39.28,33.59 v2(39.28,33.39)
PD_GPIO2: length 3.4
  TOP w0.14: RT437.1 26.93,56.14 26.72,56.34 v2(26.72,56.64) 26.48,56.88 26.29,56.88 v1(26.24,56.94)
  BOTTOM w0.081: UT4.D10 25.37,57.13 26.24,57.13 26.56,56.8
  BOTTOM w0.14: 26.56,56.8 v2(26.72,56.64)
PD_HOLD#: length 2.4
  TOP w0.14: UT5.7 46.85,28.5 47.07,28.72 RT171.2 47.88,28.33 v1(47.88,27.88)
PD_PGPIO7: length 3.5
  TOP w0.14: v1(24.99,56.64) 25.11,56.64 25.4,56.35 RT182.1 24.58,55.75 v2(23.92,56.41)
  BOTTOM w0.081: UT4.D7 23.92,56.57 v2(23.92,56.41)
PD_PMRESET: length 4.1
  TOP w0.14: RT186.1 RT245.1 ; RT245.1 27.27,57.48 27.57,57.78 28.58,57.78 v1(28.73,57.63) ; RT245.1 26.8,57.41 v2(26.67,57.27)
  BOTTOM w0.081: 26.56,57.33 25.77,57.33 25.72,57.37 UT4.E11
  BOTTOM w0.14: 26.56,57.33 26.61,57.33 v2(26.67,57.27)
PD_SS: length 2.1
  TOP w0.14: v1(23.7,60) v2(23.7,59.38) 23.7,59.31 CT158.1
  BOTTOM w0.081: UT4.H7 23.62,59.29 v2(23.7,59.38)
PD_VDDIO_VIN_3V3: length 9.9
  IN2 w0.254: v2(19.1,59.11) 18.8,58.8 18.8,55.96 v2(19.7,55.06)
  BOTTOM w0.254: v2(19.1,59.11) 19.13,59.13 19.58,59.13 19.64,59.18 19.97,59.18 20.27,58.88 UT4.H1 ; UT4.B1 20.56,55.87 19.75,55.06 v2(19.7,55.06) 19.59,55.06 19.34,54.81 18.54,54.81 18.42,54.69 17.74,54.69 RT1095.2
PECI_EC_R: length 8.7
  TOP w0.076: UE3.K13 301.5,20.31 301.5,20.83
  TOP w0.14: 301.5,20.83 301.5,21.72 301.81,22.03 302.19,22.03 302.39,22.23 302.39,23.62 303.18,24.41 303.33,24.41 304.17,25.24 RE48.1 CE39.1 v1(305.18,24.32)
PEG_GTX_C_HRX_N0: length 17.3
  TOP w0.076: 180.23,64.57 180.21,64.57 180.12,64.66 178,64.66 177.29,65.37 176.54,65.37 176.37,65.54 176.12,65.54 175.93,65.36 175.61,65.36 175.52,65.44 175.52,65.59 175.67,65.74 v2(175.81,65.74)
  TOP w0.152: CV819.2 190.65,65.5 190.29,65.5 189.36,64.57 v3(187.73,64.57) 180.23,64.57
  BOTTOM w0.076: UH1.E10 v2(175.81,65.74)
PEG_GTX_C_HRX_N1: length 18.1
  TOP w0.076: v2(175.77,66.53) 175.96,66.53 176.34,66.15 176.66,66.15 176.82,65.99 177.59,65.99 178.08,65.5 179.91,65.5 180,65.41 180.02,65.41
  TOP w0.152: 180.02,65.41 v3(185.33,65.41) 188.88,65.41 189.9,66.43 192.39,66.43 CV821.2
  BOTTOM w0.076: UH1.E11 v2(175.77,66.53)
PEG_GTX_C_HRX_N2: length 17.5
  TOP w0.076: 180.1,66.7 180.08,66.7 179.99,66.61 178.16,66.61 177.63,67.14 176.07,67.14 175.47,67.74 175.26,67.74 175.16,67.84 v2(175.16,68.1)
  TOP w0.152: 180.1,66.7 v3(186.48,66.7) 188.14,66.7 189.31,67.87 190.73,67.87 CV823.2
  BOTTOM w0.076: v2(175.16,68.1) 175.16,68.03 UH1.E12
PEG_GTX_C_HRX_N3: length 18.4
  TOP w0.076: v2(175.77,68.1) 176,67.88 176,67.77 176.23,67.54 177.91,67.54 178.28,67.16 179.61,67.16 179.81,67.36 180.78,67.36 180.86,67.27 180.88,67.27
  TOP w0.152: CV825.2 192.35,68.5 189.16,68.5 187.92,67.27 v3(184.8,67.27) 180.88,67.27
  BOTTOM w0.076: UH1.E13 175.48,68.42 175.77,68.14 v2(175.77,68.1)
PEG_GTX_C_HRX_N4: length 18
  TOP w0.076: v2(175.16,68.89) 175.16,69.19 175.25,69.28 175.43,69.28 175.52,69.19 175.52,68.78 175.65,68.65 177.37,68.65 177.73,68.29 179.08,68.29 179.38,68.59 180.07,68.59 180.16,68.68 180.18,68.68
  TOP w0.152: 180.18,68.68 v3(186.69,68.68) 187.66,68.68 188.86,69.87 190.69,69.87 CV827.2
  BOTTOM w0.076: UH1.E14 175.38,69.28 175.16,69.05 v2(175.16,68.89)
PEG_GTX_C_HRX_N5: length 18.5
  TOP w0.076: v2(175.75,69.67) 175.91,69.67 175.97,69.61 175.97,69.36 176.17,69.17 177.96,69.17 178.31,68.82 178.87,68.82 179.33,69.28 179.87,69.28 179.96,69.19 179.98,69.19
  TOP w0.152: 179.98,69.19 187.26,69.19 188.55,70.47 v3(189.43,70.47) 192.41,70.47 CV829.2
  BOTTOM w0.076: UH1.E15 175.48,70 175.75,69.73 v2(175.75,69.67)
PEG_GTX_C_HRX_N6: length 17.5
  TOP w0.076: v2(175.16,71.25) 175.16,71.02 175.24,70.94 175.4,70.94 176.12,70.22 178.48,70.22 178.61,70.35 179.22,70.35 179.31,70.44 179.33,70.44
  TOP w0.152: 179.33,70.44 v3(185.87,70.44) 186.56,70.44 188,71.87 190.67,71.87 CV831.2
  BOTTOM w0.076: v2(175.16,71.25) 175.16,71.18 UH1.E16
PEG_GTX_C_HRX_N7: length 18.6
  TOP w0.076: v2(175.81,71.25) 175.94,71.25 176.01,71.18 176.01,70.97 176.28,70.7 177.95,70.7 178.47,71.22 178.94,71.22 179.13,71.03 179.59,71.03 179.68,70.94 179.7,70.94
  TOP w0.152: 179.7,70.94 186.14,70.94 187.7,72.5 v3(189.05,72.5) 192.41,72.5 CV833.2
  BOTTOM w0.076: UH1.E17 175.81,71.32 v2(175.81,71.25)
PEG_GTX_C_HRX_N8: length 18
  TOP w0.076: 180.45,71.94 180.44,71.94 180.35,72.03 179.89,72.03 179.69,71.83 176.28,71.83 176.06,71.61 175,71.61 174.88,71.66 v2(174.51,72.04)
  TOP w0.152: CV835.2 190.68,73.59 187.34,73.59 185.69,71.94 v3(184.56,71.94) 180.45,71.94
  BOTTOM w0.076: v2(174.51,72.04) 174.83,72.36 UH1.F18
PEG_GTX_C_HRX_N9: length 19.1
  TOP w0.076: 180.71,73.18 180.69,73.18 180.6,73.09 180.26,73.09 180.12,72.95 177.11,72.95 176.62,72.47 175.69,72.47 175.64,72.52 175.55,72.61 175.55,72.69 175.69,72.83 v2(175.84,72.83)
  TOP w0.152: 180.71,73.18 185.08,73.18 186.76,74.86 v3(189.66,74.86) 192.26,74.86 CV837.2
  BOTTOM w0.076: UH1.D19 175.97,73.22 175.84,73.09 v2(175.84,72.83)
PEG_GTX_C_HRX_N10: length 17.5
  TOP w0.076: 180.52,73.89 180.5,73.89 180.41,73.98 180.26,73.98 179.82,73.54 175.96,73.54 175.57,73.93 175.47,73.93 v2(175.16,73.61)
  TOP w0.152: CV839.2 190.68,75.63 186.52,75.63 184.77,73.89 180.52,73.89
  BOTTOM w0.076: v2(175.16,73.61) 175.16,73.68 UH1.F20
PEG_GTX_C_HRX_N11: length 19.3
  TOP w0.076: 178.82,74.7 178.81,74.7 178.72,74.79 176.32,74.79 176.2,74.66 176.2,74.45 176.26,74.38 v2(176.48,74.38)
  TOP w0.152: CV841.2 193.22,76.65 185.9,76.65 184.09,74.84 179.88,74.84 179.74,74.7 178.82,74.7
  BOTTOM w0.076: UH1.D21 176.48,74.44 v2(176.48,74.38)
PEG_GTX_C_HRX_N12: length 18.7
  TOP w0.076: 179.66,75.73 179.64,75.73 179.55,75.82 179.13,75.82 178.97,75.98 177.97,75.98 177.37,75.38 175.68,75.38 175.56,75.5 175.47,75.5 v2(175.16,75.19)
  TOP w0.152: 179.66,75.73 183.66,75.73 185.6,77.67 191.75,77.67 CV843.2
  BOTTOM w0.076: v2(175.16,75.19) 175.16,75.25 UH1.F22
PEG_GTX_C_HRX_N13: length 19.6
  TOP w0.076: 179.7,76.62 179.68,76.62 179.59,76.71 179.18,76.71 179.07,76.6 176.47,76.6 176.16,76.28 176.16,76.04 176.23,75.97 v2(176.5,75.97)
  TOP w0.152: CV845.2 193.27,78.69 185.33,78.69 183.26,76.62 179.7,76.62
  BOTTOM w0.076: UH1.D23 176.5,75.99 v2(176.5,75.97)
PEG_GTX_C_HRX_N14: length 18.8
  TOP w0.076: v2(175.16,76.76) 175.36,76.96 175.36,77.21 175.62,77.48 177.97,77.48 178.18,77.69 180.4,77.69 180.5,77.79 180.79,77.79 180.88,77.88 180.9,77.88
  TOP w0.152: 180.9,77.88 182.57,77.88 184.66,79.97 v3(188.3,79.97) 191.77,79.97 CV847.2
  BOTTOM w0.076: UH1.F24 175.16,76.83 v2(175.16,76.76)
PEG_GTX_C_HRX_N15: length 19.8
  TOP w0.076: v2(176.51,78.32) 176.25,78.32 176.12,78.19 176.12,78.06 176.22,77.96 177.04,77.96 177.35,78.27 180.05,78.27 180.47,78.69 180.89,78.69 180.98,78.78 180.99,78.78
  TOP w0.152: 180.99,78.78 181.96,78.78 184.17,80.99 v3(184.86,80.99) 193.3,80.99 CV849.2
  BOTTOM w0.076: UH1.D25 v2(176.51,78.32)
PEG_GTX_C_HRX_P0: length 17.3
  TOP w0.076: 180.23,64.9 180.21,64.9 180.12,64.81 178.06,64.81 177.35,65.52 176.61,65.52 176.4,65.73 176.14,65.99 176.01,66.05 175.89,66.1 175.67,66.1 175.4,65.98 v2(175.16,65.74)
  TOP w0.152: 180.23,64.9 189.22,64.9 190.15,65.83 190.72,65.83 CV818.2
  BOTTOM w0.076: UH1.F10 v2(175.16,65.74)
PEG_GTX_C_HRX_P1: length 18.1
  TOP w0.076: 180.02,65.74 180,65.74 179.91,65.65 178.14,65.65 177.65,66.14 176.88,66.14 v2(176.49,66.53)
  TOP w0.152: CV820.2 192.28,66.76 189.76,66.76 188.74,65.74 180.02,65.74
  BOTTOM w0.076: v2(176.49,66.53) 176.53,66.56 176.53,66.79 176.49,66.82 176.49,67.08 176.36,67.21 176.22,67.21 176.13,67.12 UH1.D11
PEG_GTX_C_HRX_P2: length 17.5
  TOP w0.076: 180.1,66.37 180.08,66.37 179.99,66.46 178.1,66.46 177.57,66.99 176.01,66.99 175.41,67.58 175.23,67.58 175.16,67.51 v2(175.16,67.31)
  TOP w0.152: CV822.2 190.64,67.54 189.45,67.54 188.28,66.37 v3(183.08,66.37) 180.1,66.37
  BOTTOM w0.076: v2(175.16,67.31) 175.11,67.31 174.83,67.59 UH1.F12
PEG_GTX_C_HRX_P3: length 18.4
  TOP w0.076: v2(176.49,68.11) 176.25,68.11 176.15,68 176.15,67.83 176.29,67.69 177.97,67.69 178.35,67.32 179.55,67.32 179.75,67.51 180.78,67.51 180.86,67.6 180.88,67.6
  TOP w0.152: 180.88,67.6 187.79,67.6 189.02,68.83 192.32,68.83 CV824.2
  BOTTOM w0.076: v2(176.49,68.11) 176.45,68.11 176.13,68.42 UH1.D13
PEG_GTX_C_HRX_P4: length 18
  TOP w0.076: 180.18,68.35 180.16,68.35 180.07,68.43 179.44,68.43 179.15,68.14 177.67,68.14 177.31,68.5 174.83,68.5 v2(174.45,68.87)
  TOP w0.152: CV826.2 190.68,69.54 188.99,69.54 187.8,68.35 180.18,68.35
  BOTTOM w0.076: UH1.F14 174.83,69.25 v2(174.45,68.87)
PEG_GTX_C_HRX_P5: length 18.5
  TOP w0.076: v2(176.48,69.69) 176.2,69.69 176.13,69.62 176.13,69.43 176.23,69.32 178.03,69.32 178.37,68.97 178.81,68.97 179.27,69.43 179.87,69.43 179.96,69.52 179.98,69.52
  TOP w0.152: CV828.2 192.26,70.8 188.41,70.8 187.13,69.52 179.98,69.52
  BOTTOM w0.076: UH1.D15 176.13,70 176.44,69.69 v2(176.48,69.69)
PEG_GTX_C_HRX_P6: length 17.5
  TOP w0.076: 179.33,70.11 179.31,70.11 179.22,70.2 178.68,70.2 178.54,70.06 176.06,70.06 175.34,70.79 175.24,70.79 175.16,70.7 v2(175.16,70.46)
  TOP w0.152: CV830.2 190.7,71.54 188.14,71.54 186.7,70.11 179.33,70.11
  BOTTOM w0.076: UH1.F16 175.16,70.53 v2(175.16,70.46)
PEG_GTX_C_HRX_P7: length 18.6
  TOP w0.076: 179.7,71.27 179.68,71.27 179.59,71.18 179.19,71.18 179.01,71.37 178.41,71.37 177.89,70.85 176.35,70.85 176.16,71.04 176.16,71.18 176.23,71.25 v2(176.5,71.25)
  TOP w0.152: CV832.2 192.26,72.83 187.56,72.83 186,71.27 179.7,71.27
  BOTTOM w0.076: v2(176.5,71.25) 176.5,71.25 176.45,71.25 176.13,71.57 UH1.D17
PEG_GTX_C_HRX_P8: length 18
  TOP w0.076: 180.45,72.27 180.44,72.27 180.35,72.18 179.83,72.18 179.63,71.98 176.21,71.98 176,71.76 175.58,71.76 175.51,71.83 175.51,72.18 175.29,72.4 175.21,72.4 175.16,72.35 v2(175.16,72.04)
  TOP w0.152: 180.45,72.27 185.55,72.27 187.2,73.92 190.68,73.92 CV834.2
  BOTTOM w0.076: v2(175.16,72.04) 175.16,72.1 UH1.E18
PEG_GTX_C_HRX_P9: length 19.1
  TOP w0.076: 180.71,72.85 180.69,72.85 180.6,72.94 180.32,72.94 180.18,72.8 177.17,72.8 176.68,72.31 175.63,72.31 175.53,72.41 175.4,72.54 175.4,72.58 v2(175.16,72.82)
  TOP w0.152: CV836.2 192.41,74.53 v3(187.91,74.53) 186.9,74.53 185.22,72.85 180.71,72.85
  BOTTOM w0.076: v2(175.16,72.82) 175.48,73.15 UH1.E19
PEG_GTX_C_HRX_P10: length 17.5
  TOP w0.076: v2(175.16,74.4) 175.48,74.08 175.64,74.08 176.02,73.69 179.76,73.69 180.2,74.13 180.41,74.13 180.5,74.22 180.52,74.22
  TOP w0.152: 180.52,74.22 184.64,74.22 186.38,75.96 v3(187.71,75.96) 190.69,75.96 CV838.2
  BOTTOM w0.076: v2(175.16,74.4) 175.16,74.33 UH1.E20
PEG_GTX_C_HRX_P11: length 19.3
  TOP w0.076: 178.82,75.03 178.81,75.03 178.72,74.94 176.26,74.94 176.05,74.72 176.05,74.64 v2(175.81,74.4)
  TOP w0.152: 178.82,75.03 179.6,75.03 179.74,75.17 183.96,75.17 185.76,76.98 v3(189.09,76.98) 193.35,76.98 CV840.2
  BOTTOM w0.076: v2(175.81,74.4) 175.81,74.46 UH1.E21
PEG_GTX_C_HRX_P12: length 18.7
  TOP w0.076: 179.66,76.06 179.64,76.06 179.55,75.98 179.2,75.98 179.04,76.14 177.91,76.14 177.31,75.53 175.74,75.53 175.63,75.65 175.48,75.65 v2(175.16,75.97)
  TOP w0.152: 179.66,76.06 183.53,76.06 185.47,78 v3(187.68,78) 191.78,78 CV842.2
  BOTTOM w0.076: UH1.E22 175.16,75.9 v2(175.16,75.97)
PEG_GTX_C_HRX_P13: length 19.6
  TOP w0.076: 179.7,76.95 179.68,76.95 179.59,76.86 179.12,76.86 179,76.75 176.41,76.75 176,76.34 176,76.17 v2(175.81,75.97)
  TOP w0.152: CV844.2 193.3,79.02 v3(186.03,79.02) 185.19,79.02 183.13,76.95 179.7,76.95
  BOTTOM w0.076: v2(175.81,75.97) 175.81,76.04 UH1.E23
PEG_GTX_C_HRX_P14: length 18.8
  TOP w0.076: v2(175.81,76.76) 175.58,76.76 175.51,76.83 175.51,77.15 175.69,77.32 178.03,77.32 178.25,77.54 180.47,77.54 180.57,77.64 180.79,77.64 180.88,77.55 180.9,77.55
  TOP w0.152: CV846.2 191.75,79.64 v3(190.31,79.64) 184.79,79.64 182.71,77.55 180.9,77.55
  BOTTOM w0.076: v2(175.81,76.76) 175.67,76.76 175.48,76.95 UH1.E24
PEG_GTX_C_HRX_P15: length 19.8
  TOP w0.076: v2(175.79,78.32) 175.97,78.14 175.97,78 176.15,77.81 177.11,77.81 177.41,78.12 180.11,78.12 180.53,78.54 180.89,78.54 180.98,78.45 180.99,78.45
  TOP w0.152: 180.99,78.45 182.1,78.45 184.3,80.66 v3(186.7,80.66) 193.27,80.66 CV848.2
  BOTTOM w0.076: UH1.E25 175.48,77.99 175.79,78.3 v2(175.79,78.32)
PEG_GTX_HRX_N0: length 9.9
  TOP w0.076: v2(198.98,68.8) 198.79,68.61 198.79,68.36 198.58,68.15 198.58,68.02 198.57,68.01
  TOP w0.152: 198.57,68.01 197.8,67.23 196.01,67.23 194.23,65.45 191.56,65.45 CV819.1
  BOTTOM w0.102: v2(198.98,68.8) 198.98,69.1 UV18.AJ14
PEG_GTX_HRX_N1: length 8.9
  TOP w0.076: v2(199.89,68.99) 199.59,69.3 196.76,69.3 196.1,68.63 196.1,68.51 196.08,68.49
  TOP w0.152: 196.08,68.49 v3(194.22,66.64) 194.08,66.49 193.23,66.49 CV821.1
  BOTTOM w0.102: v2(199.89,68.99) 200.3,69.4 UV18.AG14
PEG_GTX_HRX_N2: length 8.7
  TOP w0.076: v2(198.26,70.56) 198.26,70.32 198.19,70.25 197.84,70.25 197.66,70.25 197.54,70.12 196.23,70.12 195.5,69.39 195.37,69.39 195.36,69.38
  TOP w0.152: CV823.1 191.57,67.84 193.82,67.84 195.36,69.38
  BOTTOM w0.102: UV18.AJ15 198.62,70.2 v2(198.26,70.56)
PEG_GTX_HRX_N3: length 6.2
  TOP w0.076: 194.99,69.65 195,69.67 195,69.79 195.13,69.92 195.5,69.92 196.52,70.93 197.17,70.93 v2(197.45,70.64)
  TOP w0.152: 194.99,69.65 193.85,68.51 193.22,68.51 CV825.1
  BOTTOM w0.102: UV18.AK16 197.45,70.67 v2(197.45,70.64)
PEG_GTX_HRX_N4: length 9.5
  TOP w0.076: 195.29,71.07 195.3,71.09 195.43,71.09 196.38,72.03 v3(197.23,72.03) 198.52,72.03 198.77,71.78 198.77,71.57 198.84,71.5 v2(199.09,71.5)
  TOP w0.152: CV827.1 191.57,69.86 193.6,69.86 194.48,70.73 194.95,70.73 195.29,71.07
  BOTTOM w0.102: v2(199.09,71.5) UV18.AJ17
PEG_GTX_HRX_N5: length 8.7
  TOP w0.076: v2(199.95,71.51) 199.64,71.82 199.3,71.82 198.78,72.34 196.17,72.34 195.63,71.8 195.23,71.8 195.06,71.62 195.06,71.5 195.04,71.49
  TOP w0.152: 195.04,71.49 194.78,71.22 194.31,71.22 193.63,70.55 193.22,70.55 CV829.1
  BOTTOM w0.102: v2(199.95,71.51) 199.95,71.51 UV18.AG17
PEG_GTX_HRX_N6: length 8.2
  TOP w0.076: 194.64,72.6 194.65,72.62 194.77,72.62 194.92,72.76 195.15,72.76 195.21,72.82 195.85,72.82 195.96,72.93 196.73,72.93 197.23,73.43 197.59,73.43 197.95,73.07 v2(198.29,73.07)
  TOP w0.152: 194.64,72.6 194.4,72.37 193.87,72.37 193.47,71.97 191.5,71.97 CV831.1
  BOTTOM w0.102: UV18.AJ18 198.66,72.7 198.29,73.07 198.29,73.07 v2(198.29,73.07)
PEG_GTX_HRX_N7: length 5.5
  TOP w0.076: 194.96,73.18 194.98,73.18 195.07,73.27 196.74,73.27 197.38,73.91 v2(197.41,73.91)
  TOP w0.152: 194.96,73.18 194.59,73.18 194.27,72.86 v3(194.01,72.86) 193.7,72.86 193.46,72.63 193.27,72.63 CV833.1
  BOTTOM w0.102: UV18.AK19 197.47,73.91 v2(197.41,73.91)
PEG_GTX_HRX_N8: length 9.5
  TOP w0.076: 195.2,73.99 195.22,73.99 195.31,74.08 196.03,74.08 196.28,74.33 197.55,74.33 197.79,74.09 197.79,73.78 198.1,73.46 198.63,73.46 v2(199.16,74)
  TOP w0.152: 195.2,73.99 v3(194.87,73.99) 194.01,73.99 193.67,73.65 191.63,73.65 CV835.1
  BOTTOM w0.102: UV18.AJ20 198.76,74.4 v2(199.16,74)
PEG_GTX_HRX_N9: length 9
  TOP w0.076: 194.88,75.17 194.9,75.17 194.98,75.08 195.62,75.08 195.81,74.89 197.35,74.89 197.4,74.94 197.99,74.94 198.37,74.56 200.33,74.56 200.53,74.37 200.53,74.21 v2(200.74,74)
  TOP w0.152: 194.88,75.17 v3(194.08,75.17) 193.61,75.17 193.38,74.94 193.22,74.94 CV837.1
  BOTTOM w0.102: UV18.AG20 v2(200.74,74)
PEG_GTX_HRX_N10: length 8.2
  TOP w0.076: 195.09,75.68 195.11,75.68 195.2,75.77 195.49,75.77 v3(195.8,75.46) 196.1,75.16 197.88,75.16 198.06,75.34 198.06,75.48 v2(198.28,75.7)
  TOP w0.152: CV839.1 191.63,75.68 195.09,75.68
  BOTTOM w0.102: v2(198.28,75.7) 198.69,75.29 UV18.AJ21
PEG_GTX_HRX_N11: length 4.5
  TOP w0.076: v2(197.39,76.49) 196.97,76.07 195.91,76.07 195.33,76.65 195.18,76.65 195.09,76.56
  TOP w0.152: 195.09,76.56 v3(194.9,76.56) 194.16,76.56 CV841.1
  BOTTOM w0.102: v2(197.39,76.49) 197.84,76.05 UV18.AK22
PEG_GTX_HRX_N12: length 7
  TOP w0.076: v2(198.26,76.47) 197.98,76.75 197.74,76.75 197.46,77.03 196.22,77.03 195.51,77.75 195.3,77.75 195.21,77.66
  TOP w0.152: 195.21,77.66 192.66,77.66 CV843.1
  BOTTOM w0.102: UV18.AJ23 v2(198.26,76.47)
PEG_GTX_HRX_N13: length 9.3
  TOP w0.076: 194.9,78.67 194.99,78.76 195.08,78.76 195.86,77.98 195.86,77.91 196.28,77.5 197.84,77.5 197.94,77.6 198.57,77.6 198.81,77.36 198.81,76.69 199.5,75.99 200.23,75.99 v2(200.73,76.5)
  TOP w0.152: CV845.1 194.18,78.67 194.9,78.67
  BOTTOM w0.102: UV18.AG23 v2(200.73,76.5)
PEG_GTX_HRX_N14: length 7.4
  TOP w0.076: v2(198.25,78.13) 198.25,78.13 197.73,78.66 196.45,78.66 196.02,79.08 196.02,79.26 195.74,79.54 195.74,79.66 195.73,79.68
  TOP w0.152: 195.73,79.68 195.44,79.96 192.65,79.96 CV847.1
  BOTTOM w0.102: UV18.AJ24 v2(198.25,78.13)
PEG_GTX_HRX_N15: length 5.9
  TOP w0.076: v2(197.42,79.03) 197.22,79.24 197.22,79.45 197.33,79.56 197.33,79.74 197.42,79.82 197.42,79.84
  TOP w0.152: 197.42,79.84 197.42,80.38 196.82,80.98 v3(195.58,80.98) 194.17,80.98 CV849.1
  BOTTOM w0.102: UV18.AK25 197.84,78.62 v2(197.42,79.03)
PEG_GTX_HRX_P0: length 10
  TOP w0.076: 198.34,68.24 198.35,68.25 198.48,68.25 198.64,68.42 198.64,68.64 198.51,68.78 v2(198.31,68.78)
  TOP w0.152: CV818.1 191.44,65.95 191.6,65.78 194.1,65.78 195.88,67.57 v3(196.32,67.57) 197.66,67.57 198.34,68.24
  BOTTOM w0.102: UV18.AK14 198.09,69.4 198.31,69.19 v2(198.31,68.78)
PEG_GTX_HRX_P1: length 8.9
  TOP w0.076: v2(199.92,69.81) 199.92,69.55 199.82,69.45 196.7,69.45 195.99,68.74 195.86,68.74 195.85,68.73
  TOP w0.152: CV820.1 193.22,66.82 193.94,66.82 194.11,66.99 195.85,68.73
  BOTTOM w0.102: v2(199.92,69.81) 199.54,69.42 UV18.AH14
PEG_GTX_HRX_P2: length 8.8
  TOP w0.076: v2(198.27,69.83) 198,70.1 197.72,70.1 197.6,69.97 196.3,69.97 195.6,69.28 195.6,69.16 195.59,69.14
  TOP w0.152: 195.59,69.14 v3(194.5,68.05) 193.96,67.51 191.58,67.51 CV822.1
  BOTTOM w0.102: UV18.AK15 197.9,70.2 v2(198.27,69.83)
PEG_GTX_HRX_P3: length 6.2
  TOP w0.076: v2(197.42,71.44) 197.42,71.19 197.33,71.1 196.47,71.1 195.44,70.07 195.06,70.07 195.01,70.02 194.9,69.9 194.77,69.9 194.76,69.89
  TOP w0.152: CV824.1 193.23,68.84 193.71,68.84 v3(194.2,69.34) 194.76,69.89
  BOTTOM w0.102: UV18.AL16 197.04,71.06 v2(197.42,71.44)
PEG_GTX_HRX_P4: length 9.5
  TOP w0.076: v2(198.24,71.5) 198.55,71.5 198.62,71.57 198.62,71.72 198.47,71.87 197.6,71.87 197.55,71.82 196.93,71.82 196.86,71.88 196.44,71.88 195.54,70.98 195.54,70.85 195.52,70.84
  TOP w0.152: 195.52,70.84 v3(195.29,70.6) 195.09,70.4 194.61,70.4 193.74,69.53 191.57,69.53 CV826.1
  BOTTOM w0.102: UV18.AK17 v2(198.24,71.5)
PEG_GTX_HRX_P5: length 8.7
  TOP w0.076: v2(199.94,72.3) 199.94,72.07 199.84,71.97 199.37,71.97 198.84,72.5 196.1,72.5 195.56,71.96 195.17,71.96 195.09,71.87 194.95,71.73 194.82,71.73 194.81,71.72
  TOP w0.152: CV828.1 193.22,70.88 193.5,70.88 v3(193.98,71.36) 194.18,71.55 194.64,71.55 194.81,71.72
  BOTTOM w0.102: UV18.AH17 v2(199.94,72.3)
PEG_GTX_HRX_P6: length 8.2
  TOP w0.076: v2(197.44,73.07) 197.66,73.07 197.73,73 197.73,72.81 197.62,72.7 197.28,72.7 197.06,72.92 196.94,72.92 196.8,72.78 196.02,72.78 195.85,72.61 v3(195.5,72.61) 194.98,72.61 194.88,72.51 194.88,72.38 194.87,72.37
  TOP w0.152: 194.87,72.37 194.54,72.04 194.01,72.04 193.6,71.64 191.65,71.64 CV830.1
  BOTTOM w0.102: v2(197.44,73.07) 197.46,73.07 UV18.AK18
PEG_GTX_HRX_P7: length 5.5
  TOP w0.076: 194.96,73.51 194.98,73.51 195.07,73.42 196.68,73.42 197,73.75 197,73.88 196.87,74.01 196.73,74.01 v2(196.63,73.91)
  TOP w0.152: 194.96,73.51 194.45,73.51 194.14,73.19 193.56,73.19 193.32,72.96 193.18,72.96 CV832.1
  BOTTOM w0.102: v2(196.63,73.91) 196.67,73.91 UV18.AL19
PEG_GTX_HRX_P8: length 9.5
  TOP w0.076: v2(198.31,74) 198.69,74 198.76,73.93 198.76,73.81 198.56,73.62 198.17,73.62 197.94,73.84 197.94,74.15 197.61,74.48 196.21,74.48 195.96,74.23 195.31,74.23 195.22,74.32 195.2,74.32
  TOP w0.152: CV834.1 191.52,73.98 193.53,73.98 193.87,74.32 195.2,74.32
  BOTTOM w0.102: UV18.AK20 197.91,74.4 v2(198.31,74)
PEG_GTX_HRX_P9: length 9
  TOP w0.076: 194.88,74.84 194.9,74.84 194.97,74.92 195.55,74.92 195.74,74.73 v3(197.69,74.73) 197.97,74.73 198.3,74.4 200.26,74.4 200.36,74.3 200.36,74.09 200.27,74 v2(199.94,74)
  TOP w0.152: CV836.1 193.23,74.61 193.52,74.61 193.75,74.84 194.88,74.84
  BOTTOM w0.102: UV18.AH20 v2(199.94,74)
PEG_GTX_HRX_P10: length 8.2
  TOP w0.076: 195.09,76.01 195.11,76.01 195.2,75.92 195.65,75.92 196.25,75.31 197.82,75.31 197.91,75.4 197.91,75.56 197.77,75.7 v2(197.43,75.7)
  TOP w0.152: 195.09,76.01 v3(192.41,76.01) 191.52,76.01 CV838.1
  BOTTOM w0.102: UV18.AK21 197.84,75.29 v2(197.43,75.7)
PEG_GTX_HRX_P11: length 4.5
  TOP w0.076: v2(196.59,76.49) 196.59,76.7 196.51,76.79 196.14,76.79 196.05,76.7 196.05,76.57 196.23,76.4 196.23,76.28 196.18,76.24 195.98,76.24 195.39,76.82 195.2,76.82 195.13,76.89 195.07,76.89
  TOP w0.152: CV840.1 194.19,76.89 195.07,76.89
  BOTTOM w0.102: UV18.AL22 197.04,76.05 v2(196.59,76.49)
PEG_GTX_HRX_P12: length 7
  TOP w0.076: 195.24,77.99 195.31,77.92 195.57,77.92 196.29,77.2 197.53,77.2 197.82,76.9 197.95,76.9 v2(198.28,77.22)
  TOP w0.152: CV842.1 192.65,77.99 v3(194.93,77.99) 195.24,77.99
  BOTTOM w0.102: v2(198.28,77.22) 197.95,76.9 UV18.AK23
PEG_GTX_HRX_P13: length 9.3
  TOP w0.076: 194.96,79 194.98,79 195.05,78.93 195.15,78.93 v3(196.22,77.86) 196.42,77.66 197.78,77.66 197.87,77.76 198.64,77.76 198.97,77.43 198.97,76.74 199.56,76.14 200.16,76.14 200.32,76.3 200.32,76.45 200.19,76.58 199.99,76.58 v2(199.94,76.53)
  TOP w0.152: CV844.1 194.18,79 194.96,79
  BOTTOM w0.102: v2(199.94,76.53) 199.9,76.53 UV18.AH23
PEG_GTX_HRX_P14: length 7.4
  TOP w0.076: 195.49,79.44 195.5,79.44 195.51,79.44 195.51,79.44 195.62,79.44 195.64,79.43 195.87,79.19 195.87,79.02 196.38,78.5 197.66,78.5 197.83,78.33 197.83,78.09 197.75,78 197.6,78 v2(197.47,78.13)
  TOP w0.152: CV846.1 192.66,79.63 v3(195.01,79.63) 195.3,79.63 195.49,79.44
  BOTTOM w0.102: v2(197.47,78.13) 197.52,78.13 197.84,77.82 UV18.AK24
PEG_GTX_HRX_P15: length 5.9
  TOP w0.076: 197.09,79.84 197.09,79.82 197.18,79.74 197.18,79.63 197.07,79.52 197.07,78.96 196.99,78.88 196.82,78.88 v2(196.64,79.06)
  TOP w0.152: CV848.1 194.18,80.65 196.68,80.65 197.09,80.24 197.09,79.84
  BOTTOM w0.102: v2(196.64,79.06) 197.04,78.66 UV18.AL25
PEG_HTX_C_GRX_N0: length 7.5
  BOTTOM w0.076: 194.31,68.31 194.33,68.31 194.42,68.22 194.95,68.22 195.1,68.08 195.86,68.08 UV18.AM12
  BOTTOM w0.152: CH36.2 189.95,66.17 191.07,66.17 193.21,68.31 194.31,68.31
PEG_HTX_C_GRX_N1: length 6.5
  BOTTOM w0.076: UV18.AM14 195.74,68.9 194.91,68.9 194.86,68.85 194.49,68.85 194.4,68.77 194.38,68.77
  BOTTOM w0.152: CH34.2 190.78,67.24 191.49,67.24 193.02,68.77 194.38,68.77
PEG_HTX_C_GRX_N2: length 6
  BOTTOM w0.152: UV18.AP15 194.37,69.93 192.52,69.93 191.38,68.78 v3(190.17,68.78) 189.38,68.78 CH32.2
PEG_HTX_C_GRX_N3: length 6.6
  BOTTOM w0.076: 194.29,70.47 194.3,70.47 194.39,70.56 194.95,70.56 195.06,70.44 195.09,70.41 195.09,70 195.24,69.85 195.89,69.85 UV18.AM15
  BOTTOM w0.152: 194.29,70.47 192.01,70.47 191.38,69.84 190.65,69.84 CH30.2
PEG_HTX_C_GRX_N4: length 7.8
  BOTTOM w0.076: 194.14,71.63 194.16,71.63 194.24,71.54 194.94,71.54 195.09,71.69 195.09,72 195.37,72.28 195.85,72.28 196.05,72.09 UV18.AM17
  BOTTOM w0.152: 194.14,71.63 191.52,71.63 191.29,71.4 189.24,71.4 CH28.2
PEG_HTX_C_GRX_N5: length 6
  BOTTOM w0.076: UV18.AP18 194.64,72.84 194.7,72.91 194.85,72.91 194.97,72.79 194.97,72.44 194.75,72.23 194.52,72.23 194.46,72.17 194.36,72.17 194.3,72.22 194.3,72.3 194.36,72.36 194.36,72.43 194.29,72.51 194.21,72.51 193.88,72.19
  BOTTOM w0.152: 193.88,72.19 v3(191.49,72.19) 191,72.19 190.69,71.88 CH26.2
PEG_HTX_C_GRX_N6: length 7.7
  BOTTOM w0.076: 193.88,73.41 193.9,73.41 193.99,73.32 194.06,73.32 194.3,73.56 194.97,73.56 195.31,73.22 195.88,73.22 196.04,73.05 196.04,72.9 UV18.AM18
  BOTTOM w0.152: 193.88,73.41 v3(191.87,73.41) 189.4,73.41 CH24.2
PEG_HTX_C_GRX_N7: length 6.1
  BOTTOM w0.076: 193.89,73.88 193.9,73.88 193.99,73.97 194.32,73.97 194.41,73.89 195.82,73.89 196,74.06 196,74.16 UV18.AM20
  BOTTOM w0.152: 193.89,73.88 191.5,73.88 191.32,74.07 190.76,74.07 CH22.2
PEG_HTX_C_GRX_N8: length 6.1
  BOTTOM w0.076: UV18.AP21 194.64,74.94 194.56,74.86 194.39,74.86 194.24,75.01 194.05,75.01 193.97,75.1 193.95,75.1
  BOTTOM w0.152: CH20.2 189.27,75.44 192.15,75.44 192.49,75.1 193.95,75.1
PEG_HTX_C_GRX_N9: length 6.3
  BOTTOM w0.076: 194.03,75.88 194.05,75.88 194.14,75.79 195.14,75.79 195.23,75.71 195.82,75.71 195.99,75.54 195.99,75.45 UV18.AM21
  BOTTOM w0.152: 194.03,75.88 192.85,75.88 v3(192.55,76.19) 192.3,76.43 190.76,76.43 CH18.2
PEG_HTX_C_GRX_N10: length 8.2
  BOTTOM w0.076: UV18.AM23 195.72,76.38 195.21,76.38 195.1,76.27 194.45,76.27 194.29,76.43 194.09,76.43 194,76.34 193.98,76.34
  BOTTOM w0.152: CH16.2 189,77.01 v3(191.39,77.01) 192.4,77.01 193.07,76.34 193.98,76.34
PEG_HTX_C_GRX_N11: length 5.2
  BOTTOM w0.076: 193.99,77.49 194.01,77.49 194.1,77.4 194.34,77.4 UV18.AP24
  BOTTOM w0.152: CH14.2 190.21,78.31 v3(191.02,78.31) 192.7,78.31 193.52,77.49 193.99,77.49
PEG_HTX_C_GRX_N12: length 8.9
  BOTTOM w0.076: 194.2,77.95 194.22,77.95 194.31,78.04 194.85,78.04 195.08,77.81 195.08,77.61 195.31,77.37 195.91,77.37 UV18.AM24
  BOTTOM w0.152: 194.2,77.95 193.71,77.95 192.28,79.38 v3(190.09,79.38) 189.76,79.38 189.63,79.24 188.72,79.24 CH12.2
PEG_HTX_C_GRX_N13: length 7.6
  BOTTOM w0.076: 194.41,79.03 194.43,79.03 194.52,78.94 194.85,78.94 195.09,79.18 195.09,79.5 195.31,79.72 195.91,79.72 UV18.AM26
  BOTTOM w0.152: CH10.2 190.18,80.68 192.56,80.68 194.21,79.03 194.41,79.03
PEG_HTX_C_GRX_N14: length 7.2
  BOTTOM w0.076: 194.11,80.26 194.12,80.25 194.12,80.12 194.29,79.95 194.55,79.95 194.64,80.04 UV18.AP27
  BOTTOM w0.152: 194.11,80.26 192.7,81.66 190.95,81.66 190.65,81.95 v3(189.56,81.95) 188.72,81.95 CH8.2
PEG_HTX_C_GRX_N15: length 9.5
  BOTTOM w0.076: UV18.AM27 196.08,80.36 196.08,80.51 195.9,80.69 195.08,80.69 194.88,80.9 194.49,80.9 194.32,81.07 194.32,81.2 194.3,81.21
  BOTTOM w0.152: 194.3,81.21 192.48,83.03 190.25,83.03 v3(189.55,83.73) 189.28,84 188.75,84 CH6.2
PEG_HTX_C_GRX_P0: length 7.5
  BOTTOM w0.076: UV18.AN12 195.44,67.41 195.35,67.33 195.13,67.33 195.05,67.4 195.05,67.91 194.89,68.07 194.42,68.07 194.33,67.98 194.31,67.98
  BOTTOM w0.152: CH35.2 190.17,65.84 v3(190.73,65.84) 191.2,65.84 193.34,67.98 194.31,67.98
PEG_HTX_C_GRX_P1: length 6.5
  BOTTOM w0.076: 194.38,69.1 194.4,69.1 194.49,69.01 194.8,69.01 194.85,69.05 195.68,69.05 195.82,69.2 195.82,69.32 195.74,69.4 UV18.AN14
  BOTTOM w0.152: 194.38,69.1 192.88,69.1 v3(191.88,68.09) 191.35,67.57 190.85,67.57 CH33.2
PEG_HTX_C_GRX_P2: length 6
  BOTTOM w0.152: CH31.2 189.46,68.45 191.52,68.45 192.47,69.41 v3(192.47,69.41) 192.66,69.6 194.44,69.6 UV18.AP14
PEG_HTX_C_GRX_P3: length 6.6
  BOTTOM w0.076: 194.29,70.8 194.3,70.8 194.39,70.71 195.01,70.71 195.14,70.58 195.71,70.58 195.91,70.38 195.91,70.17 195.8,70.07 195.57,70.07 UV18.AN15
  BOTTOM w0.152: 194.29,70.8 191.88,70.8 v3(191.44,70.36) 191.24,70.17 190.86,70.17 CH29.2
PEG_HTX_C_GRX_P4: length 7.8
  BOTTOM w0.076: 194.14,71.3 194.16,71.3 194.24,71.39 195,71.39 195.17,71.56 195.6,71.56 195.88,71.84 195.88,71.98 195.77,72.1 195.64,72.1 UV18.AN17
  BOTTOM w0.152: 194.14,71.3 v3(192.42,71.3) 191.65,71.3 191.43,71.07 189.48,71.07 CH27.2
PEG_HTX_C_GRX_P5: length 6
  BOTTOM w0.076: 193.83,72.52 194,72.52 194.54,73.06 194.91,73.06 195.12,72.85 195.12,72.38 UV18.AP17
  BOTTOM w0.152: 193.83,72.52 v3(192.83,72.52) CH25.2
PEG_HTX_C_GRX_P6: length 7.7
  BOTTOM w0.076: 193.88,73.08 193.9,73.08 193.99,73.17 194.13,73.17 194.37,73.41 194.91,73.41 195.25,73.07 195.81,73.07 195.89,72.99 195.89,72.84 195.75,72.7 UV18.AN18
  BOTTOM w0.152: 193.88,73.08 189.32,73.08 CH23.2
PEG_HTX_C_GRX_P7: length 6.1
  BOTTOM w0.076: UV18.AN20 195.75,74.4 195.84,74.3 195.84,74.13 195.75,74.04 194.47,74.04 194.39,74.13 193.99,74.13 193.9,74.21 193.89,74.21
  BOTTOM w0.152: 193.89,74.21 191.64,74.21 191.46,74.4 190.76,74.4 CH21.2
PEG_HTX_C_GRX_P8: length 6.1
  BOTTOM w0.076: UV18.AP20 194.64,74.63 194.56,74.71 194.33,74.71 194.18,74.85 194.05,74.85 193.97,74.77 193.95,74.77
  BOTTOM w0.152: CH19.2 189.32,75.11 v3(191.45,75.11) 192.02,75.11 192.36,74.77 193.95,74.77
PEG_HTX_C_GRX_P9: length 6.3
  BOTTOM w0.076: 194.03,75.55 194.05,75.55 194.14,75.64 195.08,75.64 195.17,75.55 195.76,75.55 195.83,75.48 195.83,75.27 195.76,75.2 UV18.AN21
  BOTTOM w0.152: CH17.2 190.76,76.1 192.17,76.1 192.71,75.55 194.03,75.55
PEG_HTX_C_GRX_P10: length 8.2
  BOTTOM w0.076: UV18.AN23 195.52,76.99 195.69,76.99 195.83,76.85 195.83,76.7 195.65,76.53 195.15,76.53 195.04,76.42 194.51,76.42 194.35,76.58 194.09,76.58 194,76.67 193.98,76.67
  BOTTOM w0.152: 193.98,76.67 193.21,76.67 192.53,77.34 188.82,77.34 CH15.2
PEG_HTX_C_GRX_P11: length 5.2
  BOTTOM w0.076: UV18.AP23 194.29,77.25 194.1,77.25 194.01,77.16 193.99,77.16
  BOTTOM w0.152: 193.99,77.16 193.39,77.16 192.57,77.98 v3(192.33,77.98) 190.16,77.98 CH13.2
PEG_HTX_C_GRX_P12: length 8.9
  BOTTOM w0.076: UV18.AN24 195.57,77.56 195.78,77.56 195.86,77.65 195.86,77.93 195.73,78.06 195.04,78.06 194.91,78.19 194.31,78.19 194.22,78.28 194.2,78.28
  BOTTOM w0.152: CH11.2 188.72,79.57 189.49,79.57 189.62,79.71 v3(192.22,79.71) 192.42,79.71 193.85,78.28 194.2,78.28
PEG_HTX_C_GRX_P13: length 7.6
  BOTTOM w0.076: UV18.AN26 195.6,79.56 195.74,79.56 195.87,79.44 195.87,79.13 195.77,79.02 195.15,79.02 194.91,78.79 194.52,78.79 194.43,78.7 194.41,78.7
  BOTTOM w0.152: 194.41,78.7 194.08,78.7 192.42,80.35 v3(191.06,80.35) 190.18,80.35 CH9.2
