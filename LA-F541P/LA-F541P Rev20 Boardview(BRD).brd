# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Nets (continued)
XDP_PREQ#: JXDP.3 RH156.2 UH1.BL30 UH2.AL2
XDP_PWRGOOD: CD3328.1 JXDP.39 RH481.2 RH482.2
XDP_TDI: JXDP.56 RH477.1 RH541.1
XDP_TDO: JXDP.52 RH478.1 RH540.1
XDP_TMS: JXDP.58 RH12.1 RH542.1
XDP_TRST#: JXDP.54 RH543.1
XTAL24_IN: RA96.2 UH2.U10
XTAL24_IN_R: CH47.1 RA96.1 RH72.1 YH2.1
XTAL24_OUT: RA97.2 UH2.U9
XTAL24_OUT_R: CH48.1 RA97.1 RH72.2 YH2.3
XTAL_25_IN: CT43.1 RA98.2 YT1.1
XTAL_25_IN_R: RA98.1 UT1.D22
XTAL_25_OUT: CT44.1 RA99.2 YT1.3
XTAL_25_OUT_R: RA99.1 UT1.D23
XTAL_OUT: CV858.1 RV1833.2 UV18.H2 YV1.3
XTALIN: CV857.1 RV1833.1 UV18.H3 YV1.1
XTALOUT: RV581.1 UV18.J4
XTALSSIN: RV579.1 UV18.H1
N04748: PC1935.1 PR1922.1 PU1900.3
N16357: CA20.1 UA1.29
N16361: CA21.1 UA1.31
N16389: CA15.1 UA1.25
N16393: CA18.1 UA1.27
N35186: DA14.1 RA29.1
N35194: DA7.1 RA28.1
N48197: PC1103.2 PR1104.2 PU1100.2
N48329: PC1104.2 PR1111.2 PU1100.4
N48371: PC1105.2 PR1111.1
N48789: PC1114.1 PR1129.1 PU1100.28
N48933: PC1117.1 PR1126.2
N48941: PC1115.1 PR1126.1 PU1100.29
N48965: PC1116.1 PR1124.2
N48979: PR1124.1 PR1125.1 PR1128.1 PU1100.30
N49205: PC1113.2 PR1130.2 PU1100.8
N49217: PC1113.1 PR1127.2
N49289: PC1139.2 PR1105.2 PU1100.3
N49471: PC1108.1 PR1117.2
N49551: PC1108.2 PR1115.1 PU1100.33
N49667: PR1103.2 PU1100.46
N49815: PR1116.1 PU1100.36
N50153: PC1101.1 PR1101.2 PU1100.42
N50385: PC1129.1 PR1137.1 PU1100.14
N50425: PH1104.2 PR1138.2 PR1144.1
N50433: PR1144.2 PU1100.15
N50477: PR1110.1 PU1100.40
N50505: PR1109.1 PU1100.39
N50517: PR1108.1 PU1100.38
N50567: PR1107.1 PU1100.37
N50631: PC1134.2 PR1141.2
N50639: PC1131.1 PR1141.1 PU1100.16
N50651: PC1132.1 PR1139.2
N50739: PR1139.1 PR1140.1 PR1142.2 PU1100.17
N51003: PC1128.1 PR1133.1 PU1100.20
N51011: PC1128.2 PR1135.1
N57527: PR1209.1 PR1210.1 PR1222.2
N3514407: PR405.2 PU400.5
N3514423: PC400.1 PR400.2 PU400.3
N3514453: PC419.1 PU400.13
N13272441: PC806.2 PR805.1 PR809.1 PU800.14
N13347359: PR1114.2 PR1119.2 PU1100.47
N13351923: PC1102.1 PR1102.2 PU1100.41
N13352071: PR1118.2 PU1100.48
N13353452: PR1112.2 PR1113.2 PR1143.1 PU1100.5
N16399089: PD1900.1 PD1902.1 PR1907.2
N16404606: PD1903.3 PR1936.1 PR1937.2
N16404788: PD1903.1 PR1943.2 PU1901.1
N17034077: PR406.1 PU400.1
N17034092: PC418.1 PR415.1 PU400.12
N17509431: PC1940.1 PR1927.2 PR1932.1 PR1933.1
N17509921: PD1903.2 PR1939.2
N17522701: PR1941.2 PU1901.2
N17670003: PR1929.1 PR1934.1 PU1900.30
N17765266: PR1926.2 PR1928.2 PU1900.26
N18278782: PC1913.1 PR1905.1
N18278998: PR1917.2 PU1900.22
N18290168: PR1927.1 PU1900.29
N19473413: PC1802.2 PR1803.2 PR1804.1 PU1800.4
N19473637: PC1802.1 PC1803.1 PR1803.1 PR1805.1 PU1800.1 PU1800.2 PU1800.3
N26813293: RV639.2 RV640.2 RV641.2 RV1080.2
N27076067: PC1941.1 PR1930.2
N31483113: PC725.1 PQ701.2 PR717.2
N31483116: PQ701.3 PR713.1
N31483118: PQ701.5 PQ701.6 PR715.2
N32073814: PC711.1 PR710.1 PU700.8
N32073817: PC712.1 PR710.2 PR712.1 PR713.2 PU700.7
N32074224: PC709.1 PR702.2
N32086652: PR711.1 PR718.1 PU700.12
N35924928: RV600.2 UV18.J27
N35928308: RV601.2 UV18.H27
N35950826: RV602.2 UV18.H25
N48708347: PC600.2 PR600.1
N48708367: PC614.1 PR608.2 PR610.1 PU600.7
N48708425: PR605.2 PU600.9
N49570918: PC506.2 PR504.2 PR507.1 PU500.14
N52997531: PD100.1 PL104.1 PR102.2
N52999986: PL104.2 PQ100.1 PR100.1 PR103.1
N55155823: CV168.2 QV11.3 RV119.2 RV120.1
N55155843: QV12.1 RV120.2
N108873638: PR409.1 PU400.20
N109970739: PR410.1 PU400.19
N110703687: PC1024.1 PR1009.2
N116496514: PC1056.1 PR1020.2
N119328643: PC1934.1 PR1923.1 PR1924.2 PU1900.25
N119942216: ADP100.5 ADP100.6 ADP100.7 PC106.1 PL105.1 PL106.1
N120970730: PC1209.1 PR1200.2
N120971346: PC1234.1 PR1204.2
N120971480: PC1255.1 PR1208.2
N121033373: PR408.2 PU400.6
N121033408: PR407.2 PR428.2 PU400.7
N121616283: CE65.1 UE6.6
N121617744: CZ37.1 UZ33.6
N121673930: PC1106.2 PR1112.1
N121674134: PC1130.1 PR1140.2
N121674335: PC1118.1 PR1125.2
N121718437: DE7.1 JFAN1.3 RE82.2
N121718548: DE8.1 JFAN2.3 RE84.2
N121981266: PH1100.2 PR1105.1 PR1106.2
N121981305: PH1102.1 PR1122.2
N121981509: PH1101.2 PR1121.1
N121981539: PH1103.2 PR1136.1
N122282431: RR9.1 UR1.28
N122463812: JXDP.1 RH474.1 RH475.1
N122469543: CH174.1 RH2.2 RH6.1
N122476680: PR1201.1 PR1202.1 PR1218.2
N122477585: PR1205.1 PR1206.1 PR1220.2
N122528028: QF1.5 QF1.6 RF3.2
N122706757: PR809.2 PR810.1 PR811.2
N122712620: JNGFF2.61 RD10.2 RD58.2
N122739099: RZ60.1 RZ86.1 UZ12.1 UZ21.4
N122739340: RZ61.2 UZ12.2
N122774125: PR803.2 PR805.2 PR806.1
N123360127: RT12.1 UT1.H19
N123360144: RT5.1 UT1.Y18
N123983992: PL1301.1 PR1307.1 PR1314.1 PU1301.8
N123984002: PR1305.1 PR1306.1 PR1314.2
N123984012: PC1355.1 PC1356.1 PC1357.1 PC1358.1 PJP1301.1 PL1305.2 PQ1300.2 PQ1300.3 PQ1300.4 PQ1300.10
N123984055: PR1311.1 PU1302.2
N123984061: PC1313.1 PL1306.1 PQ1300.9 PR1308.1 PU1302.8
N123984063: PQ1300.1 PU1302.1
N123984071: PC1313.2 PR1311.2
N123984081: PR1301.1 PR1303.1 PR1312.2
N123984161: PC1365.1 PR1308.2
N123984213: PR1304.1 PR1315.2
N123984281: PL1306.2 PR1309.1
N123984351: PQ1300.8 PU1302.5
N123984423: PC1347.1 PR1307.2
N123984459: PC1318.1 PR1300.2
N123984461: PL1300.1 PR1300.1 PR1312.1 PU1300.8
N123985122: PR1302.2 PR1313.2
N124211085: RT164.2 UT1.F19
N124494273: RT181.1 UT4.C10
N124494892: RT191.1 UT4.G2
N124539694: RT5844.1 UT4.G11
N124607348: QV89.1 RT195.1
N124730498: RT178.1 UT4.C2
N124730527: T185.1(TP-1) UT4.B2
N124752685: CH101.2 RH211.1
N124753277: CH100.2 RH212.1
N124754324: RT189.1 RT199.1 UT4.F10
N124755351: T193.1(TP-1) UT4.G4
N124755352: T194.1(TP-1) UT4.F4
N124817429: RH581.1 UH2.G3
N125173025: RV1845.1 UT4.F1
N125233563: PC1138.2 PR1143.2
N125742089: RH586.1 UH7.5
N125814346: CN22.1 UN3.6
N125960908: RZ81.2 UZ19.2
N126843005: LED6.2 RE3.2
N127291407: CZ31.1 UZ5.6
N128723349: PC1521.1 PR1512.2
N128725561: PC1054.1 PR1016.2 PR1018.2 PU1001.10
N128725563: PC1022.1 PR1010.2
N128725569: PC1047.2 PR1015.2
N128725595: PC1055.1 PR1022.1 PU1001.12
N128725605: PC1041.1 PR1013.1 PR1014.2
N128725802: PR1000.2 PR1001.1 PR1002.1 PU1001.4
N128726001: PC1018.1 PR1005.2 PR1006.2 PR1007.1
N128726023: PR1013.2 PU1001.9
N128726031: PC1030.1 PR1012.1 PU1001.18
N128726049: PR1008.2 PR1011.1
N128726112: PC1054.2 PR1021.2 PR1023.2 PU1001.11
N128727405: PC1519.1 PR1510.2
N128727409: PC1532.1 PR1519.1 PU1501.12
N128727430: PC1517.1 PR1505.2 PR1507.1 PR1508.2
N128727456: PR1509.2 PR1511.1
N128727528: PC1522.1 PR1514.2 PR1515.1
N128727776: PC1531.1 PR1516.2 PR1517.2 PU1501.10
N128727796: PC1531.2 PR1520.2 PR1521.2 PU1501.11
N128727911: PR1515.2 PU1501.9
N128727995: PC1520.1 PR1513.1 PU1501.18
N128735760: CA125.1 UA4.10
N128735764: CA124.1 UA4.12
N128861659: PC1308.2 PU1300.5
N128861671: PC1308.1 PR1320.1
N128861673: PR1320.2 PU1300.3
N128862470: PC1337.2 PU1301.5
N128862480: PC1337.1 PR1321.1
N128862482: PR1321.2 PU1301.3
N128958711: PC906.2 PR904.2 PR908.1 PU900.14
N128958713: PC906.1 PC907.1 PC908.1 PC909.1 PC910.1 PJP900.2 PL901.2 PR904.1
N128967490: BAT100.5 PR106.1
N128967591: BAT100.6 PR108.1
N128967644: BAT100.7 PR111.1
N130300854: CZ98.1 UZ24.6
N130500830: QV21.2 QV21.5 RV1131.1 RV1132.1
N130775721: RT430.2 UT4.E2 UT4.F2
N130798734: QV91.1 RV1083.1
N132000604: PC1929.2 PR1914.1
N132009758: PR1910.2 PR1931.2
N132009765: PR1910.3 PR1935.2
N132121209: CV925.1 RV621.2 RV622.2
N132122697: CV928.1 RV626.2 RV627.2
N132123770: CV987.1 RV628.2 RV629.2
N132124417: CV990.1 RV637.2 RV638.2
N132190190: PR1800.1 PR1851.1 PU1800.5
N132908405: QZ14.5 QZ14.6 QZ18.2 RV103.2
N132908425: QZ14.3 RV1808.2
N132908471: QZ15.5 QZ15.6 RV1809.2
N132908541: QZ17.5 QZ17.6 RV111.2
N132908575: QZ15.3 RV1810.2
N132908582: QZ18.1 RV112.2
N132908588: QZ17.3 RV1811.2
N132951149: QZ6.6 RV8.2
N132951151: QZ6.2 QZ6.3 RV12.2
N132951302: QV3.3 RV11.2
N132958139: RH5893.1 UV28.1
N132958145: CV918.1 RV1128.1 RV1807.2 UV28.4
N132961365: QV103.2 RV590.1
N134346262: QV98.2 RV1112.2
N134965433: CZ100.1 UZ25.6
N134966636: RM4.1 UM1.C6
N134966683: RM19.1 UM1.F2
N134967484: RM10.2 UM2.7
N135073509: T2.1(TP-1) UH2.AN40
N135644152: PC1201.2 PU1200.7
N135654499: PC1289.1 PR1225.2
N135654501: PC1289.2 PU1201.7
N135656021: PC1291.1 PR1226.2
N135656023: PC1291.2 PU1202.7
N135670058: PR500.2 PR521.1 PU500.9
N135673289: PC805.1 PU800.16 PU800.17
N135676145: PC911.1 PR903.2 PR906.1 PU900.11
N135676149: PR902.2 PR903.1 PR905.2 PR907.2
N135676155: PC905.1 PU900.16 PU900.17
N135689071: PR1603.2 PR1605.2
N135689238: PC1606.2 PR1605.1 PR1608.1 PU1600.14
N135689294: PC1611.1 PR1602.2 PR1604.1 PU1600.11
N135689304: PC1605.1 PU1600.16 PU1600.17
N135767612: PC202.2 PQ201.4 PQ202.1 PR201.2 PR205.1
N135767628: PQ202.2 PR200.2 PR204.1
N135767648: PQ203.6 PR204.2
N135767654: PQ204.1 PR205.2
N135767682: PQ203.3 PR206.2 PR210.2
N135767749: PQ204.2 PR213.1
N135767755: PC201.1 PQ200.4 PR202.2 PR209.1
N135767765: PQ205.1 PR209.2
N135767870: PR216.1 PU201.4
N135767884: PQ206.1 PR215.1 PR224.1
N135767963: PQ203.5 PR218.1
N135767967: PQ206.3 PR221.2 PR222.1
N135767977: PQ206.2 PR223.1
N135768200: PQ203.2 PR210.1
N135770596: PQ223.2 PQ223.3 PR274.1
N135770632: PQ220.4 PQ223.6 PR273.1 PR283.2
N135770638: PQ223.5 PR277.2 PR278.2 PR283.1
N135770664: PQ221.2 PR267.1 PR268.2
N135770666: PQ220.5 PR265.1 PR269.2
N135770716: PQ213.2 PR242.1
N135770748: PQ213.5 PR239.2
N135770768: PC206.1 PR207.1 PR211.2 PR219.1 PU200.3
N135770796: PC216.1 PD202.2 PR245.2 PR251.2 PR253.1 PU203.1
N135770798: PR242.2 PU202.4
N135770815: PC211.2 PQ208.4 PQ210.1 PR229.2 PR237.1
N135770837: PC217.1 PQ215.5 PR253.2
N135770888: PC210.1 PQ207.4 PR228.2 PR240.1
N135770896: PQ216.2 PR260.1 PR261.1 PR262.1
N135770915: PQ210.2 PR225.2 PR232.1
N135770919: PQ212.6 PR232.2
N135770992: PQ217.2 PR258.1
N135771010: PC214.1 PD202.1 PQ216.6 PR234.2 PR245.1 PR249.2 PR254.1 PU203.3
N135771120: PC212.2 PQ209.4 PQ211.1 PR230.2 PR235.1
N135771130: PQ217.1 PR252.1 PR259.2
N135771134: PQ217.3 PR256.2 PR257.1
N135771193: PQ215.2 PQ215.3 PR246.1
N135771203: PQ215.6 PR240.2
N135771219: PC215.1 PR244.2 PR255.1 PU203.2
N135771268: PC205.1 PR212.2 PR220.1 PU200.2
N135771321: PQ213.6 PR237.2
N135771386: PQ211.2 PR226.2 PR233.1
N135771412: PQ214.6 PR233.2
N135771419: PQ213.3 PR235.2
N135771459: PQ214.3 PR236.2 PR238.2
N135771494: PQ220.2 PR272.2
N135771851: PQ221.1 PQ227.6 PR279.1 PR285.2
N135772460: PQ227.2 PQ227.3 PR282.1
N135772468: PR250.2 PU202.1
N135772472: PQ214.2 PR238.1
N135772484: PQ214.5 PR243.1
N135772492: PR252.2 PU202.2
N135776099: PR214.2 PU201.1
N135776158: PR215.2 PU201.2
N135776395: PQ205.2 PR216.2
N135782958: PQ227.5 PR284.2
N135788915: PR1913.2 PU1900.21
N135795991: PR1900.3 PR1902.1
N135796052: PR1900.2 PR1901.1
N135896425: QRTC1.1 R276.2
N137529606: QE10.2 RE69.2
N137781553: D74.1 JTS1.5 RR43.2 RR44.2
N137787212: DI1.2 JTS.2
N137827497: T6004.1(TP-1) UE3.H2
N137853671: CZ104.1 UA3.6
N138188578: JEDP1.36 RV110.2
N138408347: T4948.1(TP-1) UE3.D6
N138608845: PR1643.2 PR1651.1 PU1600.9
N138923567: T6000.1(TP-1) UE3.F5
N139113922: T6002.1(TP-1) UH2.BD21
N139274499: PR1940.1 PU1901.4
N139301189: PR851.1 PR852.2 PU800.9
N139308180: PR951.2 PR952.1 PU900.9
N139527854: CZ105.1 UZ29.6
N139871071: QH1.2 R5832.2 RH5868.2
N139871074: QE20.1 RH5868.1
N140262314: RZ1952.2 UZ29.3
N140286428: PC218.1 PQ222.2 PR263.1 PR288.1
N140286440: PQ219.3 PR263.2
N140286558: PQ225.2 PR295.1
N140286564: PC222.1 PQ225.1 PR276.2 PR280.1 PU204.4
N140286576: PC223.1 PR289.1 PU204.5
N140286584: PC218.2 PQ222.3 PQ226.3 PR266.1 PR275.2 PR288.2
N140286624: PC221.1 PQ219.2 PR271.2
N140286634: PQ219.5 PQ226.2 PR275.1 PR290.1
N140583188: QV91.2 RV1084.2 UV29.4
N140796616: T6003.1(TP-1) UE3.L2
N141287628: PQ219.6 PR290.2
N141309349: PR1224.1 PU1200.5
N141310932: PC1201.1 PR1224.2
N141315330: PR1225.1 PU1201.5
N141318175: PR1226.1 PU1202.5
N141348246: PC1601.1 PR1600.2
N142820714: JHDD.16 RD100.2
N143232395: CE48.1 RE62.2
N143234416: CZ2155.1 UZ30.6
N143234582: RZ1964.2 UZ30.3
N143489306: Q5.5 Q5.6 R5842.2
N143489317: Q5.3 R5843.1
N143674886: RZ1953.2 UZ26.2
N144550342: RZ72.2 UZ16.4
N144805281: CZ39.1 UZ32.6
N147476941: JXDP.41 TC287.1(TP-1)
N12449474450: T191.1(TP-1) UT4.B9
N12449474451: T192.1(TP-1) UT4.A9
N14775150118: PR1925.1 PU1900.27

Pads without a net: DV12 4 6; FD1 1; FD2 1; FD3 1; FD4 1; FD5 1; FD6 1; JAPS 16 17 18; JAUDIO 22 35 36 37 38; JDIMM1 87 88 91 92 95 97 100 101 104 105 134 162 165; JDIMM2 87 88 91 92 95 97 100 101 104 105 134 162 165; JEDP1 37; JHDD 1 2 3; JNGFF1 6 8 9 11 12 13 14 17 18 19 20 23 24 26 36 38 40 50 51 52 53 54 56 57 58 59 60 62 63 65; JNGFF2 6 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 59; PQ216 3 4 5; PU200 5 6 7; PU203 5 6 7; PU204 3; PU500 10 12; PU700 6 14 15 16 17; PU800 10 12; PU900 10 12; PU1200 6 13 16 17 18; PU1201 6 13 16 17 18; PU1202 6 13 16 17 18; PU1300 4 9 10 13; PU1301 4 9 10 13; PU1501 14 15 16 17; PU1600 10 12; PU1900 13; RP19 3; SW1 2 3; SW_BOT 2 3; U32 2 3 4 5 6 7 9 10 11 12 13 14 15 25 26 28 30 31 32; U33 2 12 13 14 15 16; UA1 2 4 8 47 48 49 50; UC1 1; UE5 1; UE7 1; UH1 AD2 AD4 AE1 AE5 AE9 AE10 AE11 AF10 AJ10 AJ11 AK3 AL1 AL2 AL3 AM10 AM11 AT3 AT5 AT7 AT11 AW7 AW8 AW9 AW10 AW11 AY1 AY2 AY3 AY4 AY5 AY7 AY8 AY9 AY10 AY11 BA1 BA2 BA3 BA4 BA5 BN1; UH2 A25 AA1 AA45 AC6 AC7 AC9 AC11 AC14 AC15 AD47 AE9 AE11 AE14 AE15 AE43 AE44 AE48 AF47 AG45 AH9 AH10 AH46 AH47 AH48 AJ6 AJ7 AJ46 AL15 AL37 AL48 AM7 AN4 AN35 AN37 AN46 AP2 AP3 AP47 AR13 AR47 AR48 AT10 AT49 AU47 AV3 AV6 AV7 AV13 AV18 AV34 AW2 AW3 AW21 AW32 AY2 B10 B14 B15 B18 B19 B23 B24 B25 B26 B27 B38 B41 BA1 BA2 BA3 BA17 BA20 BA33 BB3 BB4 BB6 BC5 BD4 BD7 BD12 BD34 BD38 BE3 BE6 BE12 BE16 BE17 BE19 BE33 BE34 BF6 BF10 BF17 BF19 BF29 BF33 BF36 BG6 BG8 C10 C14 C15 C16 C17 C18 C19 C20 C21 C23 C24 C26 C27 C38 C39 C41 C45 C46 C47 D20 D21 D29 D39 D46 E5 E28 F6 F11 F14 F24 F26 F46 G4 G5 G12 G14 G24 G26 G45 G46 G47 G48 G49 H2 H3 H47 H48 J13 J15 J18 J21 J24 K3 K4 K6 K7 K13 K16 K18 K21 K29 L24 L26 L41 L47 L48 M26 M29 M40 N2 N3 N18 N47 N48 P9 P21 P24 P47 R10 R18 R21 R24 R44 R46 R47 T1 T2 T43 T45 T46 T47 U2 U3 U40 U41 U47 U48 V2 V3 V48 W43 W44 W46 W47 Y2 Y40 Y41 Y46 Y47 Y48; UH8 9; UM1 C5 D3 D7 F3 F7; UR1 31; UT1 A7 A9 A11 A13 A23 B7 B9 B11 B13 B23 D19 E18 E19 J1 J2 L1 L2 N1 N2 R1 R2 V18 W16 W19 Y16 Y19; UT4 E10 G10 L11; UT5 9; UV18 A9 A26 A27 A30 AB3 AB4 AB8 AC1 AC2 AC3 AC4 AC5 AC6 AC7 AC8 AC28 AC32 AD1 AD2 AD3 AD4 AD5 AD6 AE3 AE4 AF1 AF2 AF3 AF4 AF5 AF6 AF7 AF8 AF30 AF32 AG1 AG2 AG3 AG4 AG5 AG6 AG7 AG8 AG9 AG10 AH3 AH4 AH6 AH8 AH9 AH31 AJ1 AJ2 AJ3 AJ4 AJ5 AJ6 AJ8 AJ9 AJ11 AJ28 AJ31 AJ32 AJ33 AK1 AK2 AK3 AK4 AK5 AK6 AK8 AK9 AK31 AL3 AL4 AL6 AL7 AL8 AL9 AL10 AL11 AM1 AM2 AM3 AM4 AM5 AM6 AM7 AM8 AM9 AM34 AN2 AN3 AN5 AN6 AN8 AN9 AP3 AP5 AP6 AP8 AP9 B2 B6 B23 C6 C12 C15 C20 D6 D7 D9 D19 D20 D22 D23 D26 D28 E1 E4 E26 E34 F2 F26 G14 G20 H30 H31 J30 J31 J32 J33 K3 K4 M30 M34 R28 R32 V32; UV23 A5 U5; UV24 A5 U5; UV25 A5 U5; UV26 A5 U5; UZ8 3

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 909 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 9621 vias
v3: diameter 0.508, hole 0.254, TOP to BOTTOM, 158 vias
v4: diameter 0.432, hole 0.203, TOP to BOTTOM, 21 vias
v5: diameter 0.406, hole 0.203, TOP to BOTTOM, 226 vias
v6: diameter 0.432, hole 0.178, TOP to BOTTOM, 42 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.2V_B+: length 22
  IN1 w0.254: v2(277.76,32.47) v2(277.76,33.11) 277.76,33.12 278.31,33.67 281.94,33.67 282.04,33.57 287.49,33.57 287.63,33.43 291.06,33.43 291.94,32.54 291.94,29.73 293.1,28.58 v2(293.1,28.4)
  BOTTOM w0.254: v2(293.1,28.4) 293.1,27.83 PR605.1
  vias: v2(277.13,33.11) v2(277.13,32.47) v5(274.09,32.89)
1.2V_DDR_EN: length 220.1
  TOP w0.14: v1(127.76,68.07) 127.46,67.77 CZ2156.1 v2(126.37,68.45) 125.77,69.05 DZ59.2 124.09,69.05 RZ1966.2
  IN2 w0.099: v2(126.37,68.45) 127.13,67.69 132.34,67.69 133.1,66.93 133.1,64.64 131.95,63.5 131.95,42.17 135.13,38.99 138.94,38.99 146.56,31.37 152.78,31.37 156.97,27.18 159.39,27.18 161.16,25.4 161.16,21.72 161.55,21.34 173.74,21.34 173.99,21.08 176.28,21.08 177.42,22.23 177.93,22.23 180.47,19.69 185.04,19.69 185.8,20.45 214.76,20.45 214.95,20.26 227.59,20.26 228.16,20.83 230.7,20.83 231.01,21.15 248.29,21.15 248.54,20.89 249.3,20.89 249.49,20.7 250.32,20.7 250.51,20.89 253.87,20.89 255.21,19.56 255.65,19.56 256.54,20.45 260.99,20.45 261.49,20.96 264.54,20.96 265.34,21.76 275.82,21.76 277.9,19.67 280.15,19.67 284.35,23.88 284.35,25.96 284.96,26.56 285.88,26.56 288.24,28.92 291.93,28.92 v2(292.52,28.33)
  BOTTOM w0.14: v2(292.52,28.33) 292.25,28.06 PR606.1
1.2V_FB: length 5.2
  TOP w0.14: PR604.1 v5(292.8,31.62)
  TOP w0.254: PR604.1 291.31,31.62 v2(290.96,31.27)
  BOTTOM w0.203: PR607.1 292.55,31.69 PC612.1 291.37,31.69 v2(290.96,31.27) 290.62,30.94 PU600.6
1.8V_PRIM_PWRGD: length 362.6
  TOP w0.14: v2(253.11,49.09) 252.04,49.09 250.6,50.52 250.6,50.73 250.41,50.93 250.41,52.3 250.6,52.49 250.6,52.89 250.78,53.06 250.78,53.93 249.44,55.26 249.44,56.24 250.73,57.53 250.73,58.12 251.24,58.62 251.24,68.95 250.49,69.7 246.26,69.7 243.8,72.16 243.8,75.6 246.29,78.09 250.98,78.09 251.58,78.69 251.58,95.47 249.24,97.8 249.24,105.54 248.67,106.11 PR1651.2 ; RT5839.2 313.44,17.65 v2(313.61,17.83) 313.78,17.83 v1(314.31,18.37)
  IN3 w0.091: v2(313.61,17.83) 313.6,17.85 313.6,21.5 312.1,23 312.1,27.06 312.38,27.34 312.88,27.34 313.6,28.06 313.6,29.56 313.07,30.09 313.07,30.76 311.21,32.63 v2(310.47,32.63)
  IN5 w0.099: v2(136.09,2.34) 136.81,3.05 139.7,3.05 140.66,2.1 146.21,2.1 147.23,3.12 149.16,3.12 149.6,3.56 168.19,3.56 168.23,3.6 173.02,3.6 177.1,3.6 177.91,3.6 178.36,4.05 182.02,4.05 182.81,4.84 183.91,4.84 184.86,3.9 195.63,3.9 198.49,6.75 204.21,6.75 205.88,8.42 210.01,8.42 214.53,3.9 242.9,3.9 245.06,6.06 256.99,6.06 258.07,4.98 263.41,4.98 264,5.57 267.62,5.57 268.83,4.37 273.3,4.37 273.53,4.14 280.02,4.14 280.6,3.56 288.44,3.56 288.89,4 296.77,4 297.56,4.79 298.32,4.79 299.4,5.87 299.85,5.87 300.33,5.39 301.27,5.39 301.85,4.81 306.84,4.81 307.18,4.47 308.36,4.47 308.88,3.96 311.28,3.96 311.74,4.42 313.24,4.42 314.33,5.51 314.33,7.02 312.48,8.86 312.48,16.7 v2(313.61,17.83)
  IN6 w0.099: v2(253.11,49.09) 255.23,49.09 264.05,40.27 264.44,40.27 267.94,36.78 270.22,36.78 271.4,35.6 273.05,35.6 273.79,34.86 275.35,34.86 275.84,34.36 277.39,34.36 277.94,33.82 280.83,33.82 280.91,33.73 282.13,33.73 282.18,33.68 298.05,33.68 298.3,33.93 300.87,33.93 301.5,34.56 303.47,34.56 304.26,35.35 308.02,35.35 310.47,32.9 v2(310.47,32.63)
  BOTTOM w0.14: v2(136.09,2.34) 136.09,2.65 PR503.1
1.8V_PRIM_PWRGD_OK: length 3.5
  TOP w0.14: RT5840.1 RT5839.1 311.66,17.78 RT1139.1 310.34,18.34 v1(309.88,18.8)
1V8_AON_EN: length 11.3
  TOP w0.14: QV3.2 249.75,47.13 250.31,47.69 251.11,47.69 251.55,47.25 DA57.1 251.75,48.35 251.59,48.52 v1(251.59,48.64) 251.59,49.2 250.36,50.42 250.36,50.63 250.17,50.83 250.17,51.63 249.96,51.83 UZ31.4 249.35,51.83 249.06,52.12 RV1350.1 CV920.1 247.91,52.15 RZ1964.1
1V8_MAIN_EN: length 199.4
  TOP w0.14: DV16.2 249.56,42.3 250.32,43.05 250.93,43.05 251.61,42.37 RZ106.1 v2(251.61,41.38)
  TOP w0.381: RV562.1 208,47.42 v2(208.16,47.59) ; RH5893.2 170.52,111.51 v1(168.78,111.51) 164.53,111.51 164,112.04 DA56.1 ; DA56.1 163.46,113.44 v2(163.07,113.44) ; DA56.1 164.4,113.31 164.4,113.67 163.64,114.43 RV1130.2
  IN3 w0.381: v2(194.2,60.69) 189.69,60.69 188.86,61.52 188.86,63.81 187.15,65.52 184.86,65.52 184.26,66.12 184.26,69.74 182.53,71.47 182.53,77.05 184.63,79.16 184.63,81.57 183.8,82.4 v2(183.8,82.48)
  IN6 w0.254: 195.39,55.11 195.78,55.5 197.58,55.5 197.9,55.82 197.9,59.25 199.83,61.17 204.32,61.17 204.64,60.86 205.18,60.86 205.6,61.28 207.82,61.28 208.75,62.22 210.02,62.22 v2(210.87,63.07)
  IN6 w0.381: v2(224.97,46.91) 224.97,46.65 225.32,46.3 226.01,46.3 226.17,46.46 229.46,46.46 230.03,47.03 233.88,47.03 236.57,44.35 238.28,44.35 239.08,45.15 245.43,45.15 246.62,43.96 250.05,43.96 251.61,42.39 v2(251.61,41.38) ; v2(163.07,113.44) 163.53,113.44 163.86,113.11 163.86,111.8 164.35,111.31 164.35,106.39 165.31,105.43 165.31,101.42 166.14,100.59 167.37,100.59 168.23,99.73 168.23,95.55 169.73,94.05 174.31,94.05 175.13,93.22 175.13,92.84 175.9,92.08 179.39,92.08 181.61,89.86 181.61,88.83 184.53,85.91 184.53,84.95 183.8,84.22 v2(183.8,82.48) ; v2(194.2,60.69) 194.39,60.5 195.38,60.5 195.82,60.06 195.82,58.05 195.39,57.62 195.39,55.11 195.01,54.73 195.01,47.74 196.52,46.23 206.8,46.23 v2(208.16,47.59)
  BOTTOM w0.254: v2(210.87,63.07) 210.87,63.1 211.24,63.46 UV18.P7
  BOTTOM w0.381: v2(208.16,47.59) 207.51,46.93 207.51,44.88 209.15,43.25 218.68,43.25 221.54,46.1 224.41,46.1 224.97,46.66 v2(224.97,46.91) ; PR1004.2 163.16,114.36 163.16,113.53 v2(163.07,113.44)
1V8_MAIN_RUN_EN: length 61
  TOP w0.14: QZ17.2 252.75,42.26 RZ106.2 252.45,42.04 251.91,42.58 251.85,42.58 251.16,43.28 251.16,44.64 v1(250.94,44.86) 250.25,44.86 250.04,44.64 ; v2(249.71,43.41) 249.71,43.87 DV16.1 250.04,44.64 ; DA57.2 253.45,47.09 252.97,46.6 250.74,46.6 250.04,45.9 250.04,44.64
  TOP w0.254: UZ24.3 207.87,49.68 207.8,49.75 v2(207.2,49.75)
  IN6 w0.254: v2(207.2,49.75) 208.01,49.75 209.27,51.01 211,51.01 213.74,48.26 214.87,48.26 216.39,46.74 217.97,46.74 218.83,45.88 226.18,45.88 226.34,46.04 229.63,46.04 230.19,46.6 233.66,46.6 236.38,43.87 238.43,43.87 239.23,44.67 245.24,44.67 246.51,43.41 v2(249.71,43.41)
1VS_GFX_PG: length 153
  TOP w0.14: v2(250.85,51.17) 250.85,51.73 250.84,51.74 250.84,52.79 251.02,52.96 251.02,54.03 249.68,55.36 249.68,56.14 250.97,57.43 250.97,58.02 251.48,58.52 251.48,69.05 250.59,69.94 246.36,69.94 244.04,72.26 244.04,75.5 246.39,77.85 251.08,77.85 251.82,78.59 251.82,95.57 249.48,97.9 249.48,105.85 250.17,106.53 250.17,114.73 249.52,115.38 245.87,115.38 245.49,115.76 PR952.2 ; UV20.1 197.78,42.8 198.11,42.47 v1(202.69,42.47) 210.22,42.47 211.9,44.15 212.27,44.15 212.68,44.55 212.68,45.11 212.09,45.7 212.09,46.96 v2(211.97,47.09) 211.7,46.82 211.7,46.6 211.01,45.91 DV13.2
  IN2 w0.099: v2(211.97,47.09) 213.35,45.71 218.03,45.71 218.44,45.3 222.43,45.3 223.13,44.61 231.26,44.61 231.8,44.08 236.32,44.08 236.52,44.28 237.56,44.28 238.32,43.51 243.36,43.51 244.25,44.4 247.88,44.4 249.67,46.19 250.4,46.19 250.88,46.67 250.88,48.02 249.6,49.3 249.6,50.38 250.38,51.17 v2(250.85,51.17)
3.3V_CAM_EN#: length 51.9
  IN2 w0.099: v2(75.82,1.54) 75.5,1.22 67.68,1.22 66.92,1.98 64.02,1.98 63.73,2.26 61.97,2.26 61.5,2.73 61.3,2.73 61.12,2.91 60.53,2.91 59.84,3.6 59.84,4.2 58.94,5.1 58.94,8.09 59.81,8.96 59.81,9.8 60,9.98 60,11.82 59.96,11.86 59.96,12.65 59.97,12.66 59.97,14.02 59.74,14.24 59.74,15.68 58.74,16.69 57.43,16.69 56.61,17.51 56.61,21.63 56.17,22.07 v2(54.13,22.07)
  BOTTOM w0.089: RZ38.1 78.93,2.81 79.02,2.9 79.02,3.02 78.62,3.42 78.62,3.89 79.16,4.43 79.16,4.43 79.2,4.47 79.2,5.5 79.41,5.71 UH2.BE41
  BOTTOM w0.14: v1(56.62,23.99) 56.48,23.85 QZ9.2 55.07,23.01 v2(54.13,22.07) ; RZ38.1 78.49,2.43 78.43,2.36 76.65,2.36 v2(75.82,1.54)
3.3V_MSATA_EN: length 15.9
  TOP w0.089: v2(100.99,5.06) 100.59,5.46 100.59,5.69 99.92,6.35 RH423.1 99.44,7.16 v1(99.19,7.42)
  IN1 w0.076: v2(90.37,4.73) 90.37,4.84 90.49,4.96 93.26,4.96 93.75,4.48 96.9,4.48 97.06,4.31 97.61,4.31 97.82,4.52 100.45,4.52 v2(100.99,5.06)
  BOTTOM w0.089: v2(90.37,4.73) 90.3,4.79 90.3,5.37 UH2.BE18
3V/5VALW_EN: length 14.2
  TOP w0.14: v5(349.39,26.42) 349.39,26.15 349.15,25.91 v2(348.93,25.91)
  TOP w0.254: PR408.1 346.08,25.4 346.56,25.88 PR326.2 348.02,25.88 PC335.1 v2(348.93,25.91)
  BOTTOM w0.254: v2(348.93,25.91) 347.98,25.91 347.16,25.08 347.16,23.23 346.33,22.4 346.33,19.9 347.68,18.56 PR409.2
5VS_FAN1: length 5.6
  TOP w0.127: RE104.2 v5(95.58,35.97)
  TOP w0.508: v2(96.68,37.49) 96.68,37.15 97.03,36.81 RE104.2
  BOTTOM w0.508: JFAN1.2 95.6,36.9 96.19,37.49 v2(96.68,37.49)
5VS_FAN2:
  vias: v5(337.35,52.07)
+0.6VS: length 49.1
  TOP w1.524: 282.56,26.27 279.05,22.76 277.85,22.76 276.06,20.97 274.41,20.97 269.57,16.13 267.97,16.13 264.85,13.01 264.85,11.36 265.38,10.84 265.38,8.96 264.49,8.08 264.49,6.68 263.43,5.61 257.98,5.61 257.37,6.22 257.37,11.69 256.38,12.68
  BOTTOM w0.305: v2(250.03,21.11) 249.93,21.01 JDIMM2.258 249.93,18.78 249.65,18.5 249.57,18.43 v2(249.57,18.29) ; v2(173.71,18.38) 173.71,18.61 173.63,18.7 JDIMM1.258
  vias: v2(174.98,17.69) v2(175.56,17.69) v2(250.19,18.29) v2(251.36,20) v5(251.16,16.64)
+0.6VSP: length 0.9
  BOTTOM w0.203: v2(287.63,32.46) 287.63,32.34 287.87,32.1 PU600.2
  vias: v2(285.41,31.31) v2(286.01,31.31) v5(286.06,30.66)
+0.95VSP: length 13.8
  IN1 w0.254: v2(115.57,62.04) 115.41,62.04 115.06,62.38 115.06,63.65 115.6,64.19 115.6,66.42 115.09,66.92 109.63,66.92 v2(108.94,66.23)
  BOTTOM w0.254: v2(108.94,66.23) 108.74,66.42 PR803.1 107.82,65.96 PC806.1
  vias: v2(115.57,63.31) v2(115.57,62.68) v2(116.21,63.31) v2(116.21,62.68) v5(117.26,62.94)
+1.2V_DDR: length 159.1
  TOP w0.381: CH197.1 121.4,53.71 UC1.5
  TOP w0.508: R5843.2 269.25,25.86 v2(268.48,25.08) ; RH530.2 182.37,47.25 ; CH197.1 121.93,53.13 126.21,53.13 127.08,52.26 127.08,44.66 127.03,44.6
  IN1 w0.508: 259.3,24.23 261.18,22.35 267.02,22.35 268.48,23.81 v2(268.48,25.08)
  IN4 w0.508: v2(28.75,61.81) 28.5,61.81 28.26,61.57 28.26,57.16 29.45,55.98 29.45,53.79 30.37,52.87 30.37,51.41 33.63,48.15 34.35,47.31 34.73,46.92 35.2,46.32 37.32,43.86 37.87,43.31 37.87,42.46 v2(37.53,42.11)
  BOTTOM w0.305: JDIMM1.117 136.39,27.87 136.39,28.8 136.25,28.94 136.25,29.58 136.6,29.93 v2(136.78,29.93) ; JDIMM1.153 147.37,28.82 147.08,29.12 v2(146.56,29.12) 146.04,29.12 145.87,28.95 JDIMM1.147 ; JDIMM2.111 211.18,30.32 210.81,30.68 v2(210.67,30.68) ; JDIMM2.117 212.67,28.82 212.55,28.94 212.55,29.48 212.98,29.91 v2(213.16,29.91) ; v2(218.81,18.36) 218.93,18.47 JDIMM2.142 ; v2(163.87,18.39) 163.87,18.49 164.12,18.74 JDIMM1.220 ; v2(139.39,18.4) 139.63,18.63 JDIMM1.130 ; JDIMM2.220 240.42,18.51 240.35,18.43 v2(240.35,18.36) ; JDIMM1.241 169.37,29.14 v2(169.48,29.24) ; JDIMM1.160 149.12,18.8 v2(149.55,18.37) ; v2(214.44,18.35) 214.43,18.37 JDIMM2.124 ; v2(111.62,18.29) 111.47,18.43 110.5,18.43 110.13,18.81 JDIMM1.12 ; JDIMM2.154 223.93,18.6 v2(224.16,18.36) ; v2(145.12,18.4) 145.14,18.37 145.71,18.37 146.12,18.79 JDIMM1.148 ; JDIMM1.159 148.87,28.85 149.12,29.1 149.65,29.1 149.87,28.88 ; v2(225.02,29.14) 225.18,28.99 JDIMM2.159 ; JDIMM1.118 v2(136.62,18.4) ; JDIMM2.147 222.18,28.69 222.59,29.11 v2(222.72,29.11) 223.39,29.11 223.67,28.82 JDIMM2.153 ; v2(141.14,20.93) 141.12,20.91 JDIMM1.136 ; v2(217.43,18.36) 217.43,19.65 ; 149.87,28.88 JDIMM1.163 ; 149.87,28.88 150.16,29.16 150.54,29.16 150.54,29.16 150.54,29.15 v2(150.5,29.15) ; v2(131.05,18.41) 131.12,18.49 JDIMM1.96 ; JDIMM2.123 214.18,28.71 214.52,29.06 214.52,29.45 214.1,29.87 v2(214.06,29.87) ; JDIMM2.118 212.93,19.65 212.93,18.37 v2(212.94,18.35) ; JDIMM1.123 137.88,29.25 v2(138.08,29.45) ; v2(226.69,29.15) 226.33,29.15 226.18,28.99 JDIMM2.163 ; v2(235.6,29.47) 235.18,29.05 JDIMM2.199 ; JDIMM2.12 186.43,18.45 v2(186.34,18.36) ; JDIMM2.54 196.92,18.41 v2(196.98,18.36) ; JDIMM2.33 191.68,28.8 191.74,28.87 191.74,29.43 191.41,29.76 v2(191.16,29.76) ; JDIMM2.241 245.67,28.79 v2(245.29,29.18) ; JDIMM1.178 153.63,18.61 v2(153.85,18.39) ; JDIMM1.141 142.37,28.86 142.3,28.93 142.3,29.38 142.72,29.8 v2(142.86,29.8) ; JDIMM2.178 229.93,20.91 v2(230.31,21.29) ; v2(201.96,29.21) 202.18,29 JDIMM2.75 ; v2(225.84,18.36) 225.74,18.36 225.42,18.68 JDIMM2.160 ; JDIMM1.33 115.37,28.87 115.44,28.94 115.44,29.43 115.18,29.68 v2(114.86,29.68) ; v2(120.41,18.28) 120.6,18.48 120.6,19.63 JDIMM1.54 ; JDIMM1.124 v2(138.12,18.4) ; v2(134.29,30.2) 134.4,30.2 134.88,29.73 JDIMM1.111 ; v2(159.72,29.74) 159.55,29.74 158.89,29.08 JDIMM1.199 ; v2(147.84,18.39) 147.63,18.61 JDIMM1.154 ; JDIMM1.75 125.88,29.02 v2(125.71,29.19) ; v2(135.35,18.4) 135.12,18.62 JDIMM1.112 ; v2(219.16,29.73) 218.97,29.73 218.6,29.37 218.6,28.93 218.67,28.86 JDIMM2.141 ; v2(221.36,18.36) 221.99,18.36 222.43,18.79 JDIMM2.148 ; JDIMM1.142 v2(142.63,18.38) ; v2(211.65,18.35) 211.43,18.57 JDIMM2.112 ; JDIMM2.96 207.44,18.37 v2(207.46,18.36) ; JDIMM1.135 140.88,29.65 v2(139.88,30.65) 139.32,30.1 139.32,28.94 139.37,28.89 JDIMM1.129 ; JDIMM2.129 215.67,28.89 215.62,28.94 215.62,29.56 215.85,29.79 v2(216.28,29.79) 216.54,29.79 217.18,29.16 JDIMM2.135 ; v2(215.93,18.35) JDIMM2.130
  vias: v2(13.08,66.23) v2(13.37,72.35) v2(13.46,65.6) v2(28.61,63.02) v2(28.61,62.44) v2(95.43,39.67) v2(95.83,40.08) v2(96.25,40.47) v2(110.18,36.19) v2(112.78,30.35) v2(245.94,36.77) v2(245.94,36.2) v2(246.51,36.77) v2(246.51,36.2) v2(247.08,36.77) v2(247.08,36.2) v2(247.65,36.77) v2(247.65,36.2) v2(251.38,22.54) v2(251.37,21.87) v2(251.52,24.89) v2(252.05,22.21) v2(252.1,24.58) v2(252.06,22.89) v2(255.07,24.23) v2(255.07,23.65) v2(255.19,23.06) v2(255.32,22.48) v2(255.32,21.9) v2(255.65,24.23) v2(255.65,23.65) v2(255.78,23.06) v2(255.91,22.48) v2(255.91,21.9) v2(256.24,24.23) v2(256.24,23.65) v2(256.36,23.06) v2(256.49,22.48) v2(256.49,21.9) v2(256.82,24.23) v2(256.82,23.65) v2(256.95,23.06) v2(257.07,22.48) v2(257.07,21.9) v2(257.4,24.23) v2(257.4,23.65) v2(257.53,23.06) v2(257.99,24.23) v2(257.99,23.65) v5(130.68,43.28)
+1.2V_DDR_PG: length 213.1
  TOP w0.14: RZ84.2 119.7,61 119.7,58.48 119.95,58.23 UZ19.1 120.24,58.9 120.4,59.06 121.41,59.06 121.67,58.8 122.04,58.8 RZ82.1 122.56,58.2 124.2,56.55 v2(124.52,56.55)
  TOP w0.254: PR651.1 291.75,26.74 291.11,26.1 v2(291.02,26.1)
  IN2 w0.254: v2(177.65,21.65) 177.65,21.53 176.74,20.62 173.86,20.62 173.52,20.97 161.4,20.97 160.86,21.51 160.86,25.07 159.26,26.67 156.85,26.67 152.53,30.99 146.36,30.99 138.86,38.49 134.99,38.49 127.21,46.26 127.21,55.79 126.24,56.76 124.65,56.76 124.52,56.64 v2(124.52,56.55)
  IN5 w0.254: v2(291.02,26.1) 290.88,25.96 289.04,25.96 286.53,23.45 277.75,23.45 276.93,24.27 273.49,24.27 270.35,21.13 263.42,21.13 260.22,24.32 260.22,25.02 257.95,27.29 252.91,27.29 251.84,28.36 247.75,28.36 243.99,32.12 187.14,32.12 177.65,22.63 v2(177.65,21.65)
+1.2V_DTH:
  vias: v1(17.36,75.08)
+1.2V_MEN_P: length 72.4
  TOP w0.254: v2(290.15,32.92) 290.81,32.92 291.19,32.54 PR604.2
  IN1 w0.254: v2(258.83,27.12) 269.57,27.12 271.22,25.46 276.8,25.46 277.42,26.09 283.2,26.09 284.97,27.86 285.82,27.86 286.3,28.35 286.33,28.35 286.88,28.89 288.59,28.89 290.15,30.44 v2(290.15,32.92)
  IN1 w1.016: 263.02,29.02 263.95,28.09 269.64,28.09 271.52,26.2 276.44,26.2 281.39,31.15 282.19,31.15 282.26,31.08
  IN6 w0.254: v2(290.15,32.92) 290.09,32.92 289.1,31.93 287.4,31.93 286.21,30.74 284.99,30.74 283.8,31.93 v2(283.52,31.93)
  BOTTOM w0.203: PC612.2 291.4,32.92 v2(290.15,32.92) 290.09,32.92 289.07,31.89 PU600.5
  vias: v2(262.32,29.85) v2(262.95,29.85) v2(282.73,31.94)
+1.2V_PWROK: length 4.2
  TOP w0.127: v2(290.39,28.51) v5(290.39,29.71)
  TOP w0.508: v2(290.39,28.51) 290.88,28.02 PR609.2 290.88,27.43 290.83,27.38 290.83,27.05
  BOTTOM w0.203: v2(290.39,28.51) 290.39,29.15 290.2,29.34 PU600.10
+1.2V_VCCPLL_OC: length 35.3
  TOP w0.381: v2(142.96,67.75) 142.96,68.13 142.96,68.14 CH3333.1 ; CH3332.1 173.34,66.01 v2(173.85,66.52)
  TOP w0.508: v2(185.73,51.52) v5(185.73,50.17) 185.73,48.24 RH530.1 184.74,46.41 185.21,45.93 UZ16.6 ; CZ49.1 174.06,66.73 v2(173.85,66.52)
  IN4 w0.381: v2(173.85,66.52) 173.82,66.52 173.28,65.98 173.28,64.8 175.2,62.88 175.2,60.83 175.71,60.33 176.31,60.33 178.73,57.91 178.73,53.67 180.87,51.52 v2(185.73,51.52)
  BOTTOM w0.203: v2(142.96,67.75) 142.83,67.75 UH1.BH13
  BOTTOM w0.229: v2(173.85,66.52) 174.18,66.85 UH1.G11
  BOTTOM w0.254: UH1.BJ13 142.31,68.05 UH1.BH13
+1.8V_3.3V_ALW_VTR3: length 46.3
  TOP w0.14: RZ1148.2 277.56,4.95 v5(278.26,4.95)
  TOP w0.305: v2(306.72,12.86) 306.52,13.05 306.52,13.37 C3319.1 305.79,13.42 305.44,13.76 303.8,13.76 UE3.N5
  TOP w0.508: v2(305.66,6.17) 305.75,6.26 RE183.2
  IN1 w0.508: v2(306.72,12.86) 306.72,8.6 305.66,7.54 v2(305.66,6.17)
  IN6 w0.508: v2(277.67,3.3) 278.32,3.94 279.83,3.94 280.28,3.49 280.49,3.28 289.01,3.28 289.65,3.91 296.28,3.91 296.95,3.24 301.21,3.24 302.59,4.62 306.5,4.62 306.86,4.98 306.86,5.81 306.5,6.17 v2(305.66,6.17)
+1.8V_GFX_AON: length 220.2
  TOP w0.254: RV11.1 248.08,45.59 v1(246.89,45.59) 245.87,46.61 v2(245.38,46.61)
  TOP w0.381: UV28.5 173.48,112.96 CV917.1 v2(174.35,113.41) ; UV29.5 222.52,41.87 222.94,41.45 227.25,41.45 228.47,42.67 v2(228.47,43.08)
  TOP w0.457: RV645.2 v2(223.46,48.91)
  TOP w0.508: RV1112.1 v2(245.38,46.61) ; v2(206.88,48.49) 207.04,48.34 RV562.2 ; v2(182.87,112.1) 183.68,112.9 184.66,112.9 v2(185.24,112.33)
  TOP w0.762: 234.56,52.2 234.56,53.02 228.93,58.65 224.44,58.65
  IN1 w0.508: v2(245.38,46.61) 247.1,48.32 253.43,48.32 v2(253.56,48.45) 253.87,48.77 253.87,52.27 253.2,52.95 253.2,54.41 251.88,55.73 251.88,59.95 251.53,60.3 251.53,94.15 250.76,94.92 249.32,94.92 248.13,96.11 248.13,103.91 247.72,104.32 247.72,106.12 249.69,108.09 249.69,109.06 248.69,110.06 246.7,110.06 v2(246.35,110.41)
  IN2 w0.508: v2(200.99,110.66) 200.86,110.66 200.16,109.96 196.25,109.96 195.28,110.93 195.28,113.84 194.44,114.68 192.79,114.68 192.03,113.92 190.76,113.92 189.87,114.8 188.92,114.8 186.44,112.33 v2(185.24,112.33)
  IN3 w0.381: v2(228.47,43.08) 229.44,43.08 231.12,44.76 231.12,45.39 229.79,46.71 227,46.71 225.73,47.98 225.07,47.98 v2(224.15,48.9)
  IN4 w0.508: v2(182.87,112.1) 181.75,113.23 176.71,113.23 175.93,114.01 174.94,114.01 v2(174.35,113.41)
  IN5 w0.762: v2(246.35,110.41) 246.1,110.41 245.31,111.2 239.17,111.2 238.25,112.12 237.57,112.12 237.5,112.05 229.79,112.05 228.79,113.06 223.67,113.06 221.86,111.25 211.61,111.25 210.74,112.12 204.83,112.12 203.37,110.66 v2(200.99,110.66)
  IN6 w0.508: v2(163.56,117.01) 163.65,117.09 164.81,117.09 166.49,118.77 171.55,118.77 172.21,118.11 172.21,117.29 172.59,116.9 172.59,114.39 173.57,113.41 v2(174.35,113.41)
  BOTTOM w0.457: PR1000.1 163.65,117.09 v2(163.56,117.01) ; RV573.2 RV572.2
  BOTTOM w0.508: PR1500.1 v2(185.24,112.33)
  vias: v2(199.9,53.98) v2(207,50.31) v2(207.06,51.04) v2(207.57,50.48) v2(208.03,51.88) v2(214.35,65.2) v2(214.94,65.13) v2(215.01,61.43) v2(215.16,48.88) v2(215.87,61.43) v2(235.61,51.56) v2(236.47,51.55) v2(240.55,50.52) v2(241.14,50.52) v2(241.72,50.52) v2(242.31,50.52)
+1.8V_GFX_RUN: length 88.7
  TOP w0.508: v2(252.65,41.09) 253.12,40.63 254.1,40.63 254.64,41.16 RV1811.1
  IN1 w1.016: 197.87,58.68 195.52,61.02 195.52,64.26 188.79,70.99 188.79,85.56 190.69,87.47 190.69,87.95
  IN3 w0.508: v2(211.51,55.83) 211.9,55.44 219.42,55.44 222.6,52.25 230.03,52.25 231.87,50.41 231.87,49.31 236.51,44.67 236.51,43.63 239.54,40.6 248.24,40.6 250.09,42.44 251.79,42.44 252.65,41.58 v2(252.65,41.09)
  BOTTOM w0.254: UV18.L8 213.74,64.29 v2(213.33,63.89) 213.33,63.9 UV18.M8
  vias: v2(191.25,89.38) v2(191.25,88.75) v2(198.5,57.91) v2(199.14,57.91) v2(199.14,57.33) v2(199.71,57.34) v2(210.19,57.1) v2(210.59,57.53) v2(211.94,57.1) v5(190.86,88.14)
+1.8V_GFX_RUN_R:
  vias: v1(198.72,81.07) v2(195.08,81.46) v2(195.81,81.49) v2(199.94,78.97) v2(200.84,78.3) v2(200.97,77.26) v2(201.03,70.9) v2(201.03,70.27) v2(200.98,69.03) v2(201.18,77.81) v2(201.59,74.01) v2(201.59,72.67) v2(201.74,70.11)
+1.8V_PCH: length 74
  TOP w0.14: UZ26.5 108.52,49.65 107.7,48.84 107.7,47.92 106.43,46.65 106.43,44.32 107.92,42.83 114.02,42.83 114.17,42.67 114.17,41.25 v2(113.93,41.01)
  IN4 w0.508: v2(113.93,41.01) 113.66,40.74 113.66,38.04 107.84,32.22 107.84,28.59 109.32,27.11 109.32,21.51 107.72,19.91 103.38,19.91 102.82,19.34 102.82,17.5 101.98,16.66 101.98,15.05
  IN4 w0.762: 102.89,14.85 111.1,14.85 111.72,14.23 113.41,14.23 114.06,13.58 118.81,13.58 119.13,13.26
  BOTTOM w0.254: UH2.AN15 92.17,11.21 v2(92.39,11) 92.39,10.67 UH2.AR15 92.51,10.12 92.51,8.47 93.62,7.35 93.87,7.35 UH2.BB11
  vias: v2(93.51,10.94) v2(101.41,14.1) v2(101.99,14.1) v2(119.95,12.95) v2(120.52,12.95) v5(98.26,14.54)
+1.8V_PCH_I_LDO: length 3
  TOP w0.089: RE321.1 89.73,14.91 89.73,15.14 89.55,15.32 89.19,15.32 v1(88.63,15.88)
  TOP w0.356: v2(90.82,14.32) 90.76,14.38 RE321.1
+1.8V_PCH_LDO: length 2.4
  TOP w0.089: v2(89.98,15.51) 89.9,15.59 v1(89.9,16.07)
  TOP w0.508: v2(89.98,15.51) 90.37,15.12 RH5880.1
  BOTTOM w0.254: UH2.AF20 89.59,15.13 v2(89.98,15.51) 90.35,15.15 UH2.AF19
  vias: v2(90.84,15.93)
+1.8V_PLLVDD: length 0.9
  TOP w0.508: v2(212.61,82.36) 212.71,82.26 RV574.2
  vias: v2(190.12,84.71) v2(190.12,84.08) v2(190.69,84.39) v2(201.77,58.04) v2(202.38,58.68) v2(202.36,58.04) v2(202.95,58.04) v5(201.82,59.87)
+1.8VALW: length 127.5
  IN1 w0.508: v2(75.58,19.3) 73.91,19.3 73.13,20.09 71.87,20.09 71.36,19.58 69.2,19.58 68.9,19.88 65.32,19.88 65.31,19.89
  IN4 w0.508: v2(48.11,22.99) 47.37,23.72 46.81,23.72 44.53,26.01 39.07,26.01 37.9,27.18 33.63,27.18 33.17,26.72 33.17,24.97 32.27,24.07 31.43,24.07 29.27,21.91 29.27,17.15 30.48,15.94 30.48,14.51 30.02,14.06 30.02,8.6 v2(29.46,8.04)
  IN6 w0.381: 100.84,12.41 98.59,12.41
  IN6 w0.457: 98.59,12.41 97.76,13.25
  IN6 w0.508: v2(111.7,10.92) 111.51,11.11 110.71,11.11 109.86,11.96 104.45,11.96 103.8,12.61 101.04,12.61 100.84,12.41 ; v2(29.46,8.04) 26.45,8.04 25.32,6.91 25.32,6.12 24.69,5.49 20.45,5.49 19.32,6.62 19.32,7.41 15.5,11.23 5.64,11.23 5.34,10.93 v2(5.34,10.71) ; v2(75.58,19.3) 75.64,19.3 76.81,18.14 80.34,18.14 80.54,17.93 86.94,17.93 87.67,18.66 87.67,19.6 88.61,20.54 90.05,20.54 91.97,18.61 91.97,16.36 93.24,15.09 93.96,15.09 95.8,13.25 97.76,13.25
  BOTTOM w0.508: v2(114.1,7.48) 114.1,10.22 113.74,10.58 112.04,10.58 v2(111.7,10.92)
  vias: v2(131.5,5.41) v2(131.47,4.34) v2(131.75,4.88) v2(132.11,5.49) v2(231.9,5.08) v2(232.54,5.08) v2(233.17,5.08) v2(233.81,5.08) v2(243.97,95.86) v2(244,95.29) v2(244,94.7) v2(244,94.12) v2(244.57,95.8) v2(244.57,95.21) v2(244.57,94.63) v2(245.16,94.63) v2(246.9,51.39) v2(246.9,50.82) v2(247.48,51.38) v2(247.48,50.81) v2(248.06,51.36) v2(248.06,50.79) v2(248.64,51.36) v2(248.64,50.79) v2(250.16,13.77) v2(250.75,13.77) v2(251.33,13.77) v2(251.91,13.77) v2(274.32,3.28) v2(274.96,3.3) v2(275.56,3.27) v5(274.32,4.57)
+1.8VS_AUDIO: length 28.4
  TOP w0.508: RA2.1 3.27,30.86 v2(3.27,30.25)
  IN6 w0.508: v2(6.78,13.23) 5.83,12.28 3.43,12.28 2.88,12.83 2.88,13.6 3.95,14.67 3.95,17.06 4.87,17.98 6.03,17.98 8.22,20.17 8.22,22.8 2.83,28.19 2.83,29.81 v2(3.27,30.25)
  vias: v1(6.77,12.12)
+1.25V_DPHY_MAR: length 19.9
  TOP w0.381: v2(97.33,5.03) 96.34,6.02 96.34,8.84 95.77,9.41 95.17,9.41 94.73,8.97 92.94,8.97 92.01,9.89 91.06,9.89 90.25,10.71 89.71,10.71 88.93,11.48 88.47,11.48 87.96,11.99 87.96,12.17 87.91,12.22 T5004.1 87.91,12.78 87.73,12.96 87.73,13.12 v2(87.67,13.19) ; v2(87.67,13.19) 88.44,13.97 v2(88.44,13.98) 88.44,14.39 88.37,14.47 RH5879.2 ; v2(87.67,13.19) 87.13,13.19 CA131.1
  BOTTOM w0.254: UH2.AJ22 88.44,13.93 v2(88.44,13.98) ; UH2.BG5 97.21,4.9 v2(97.33,5.03) ; v2(87.67,13.19) 87.67,13.21 88.02,13.57 UH2.AJ23
+1.25V_LDOSRAM: length 3.7
  TOP w0.254: RH5879.1 89.28,14.48 89.56,14.2 89.56,13.76 89.29,13.49 T5003.1 89.08,13.48 88.72,13.48 v2(88.43,13.19)
  BOTTOM w0.254: UH2.AK23 88.04,12.8 v2(88.43,13.19) 88.8,12.82 UH2.AK22
+1.35VS_B+: length 15.7
  TOP w0.254: PR701.2 189.7,120.36 189.52,120.18 189.52,119.66 189.74,119.44 190.44,119.44 190.76,119.76 v2(190.76,119.89)
  IN2 w0.381: v2(190.76,119.89) 190.95,120.08 191.96,120.08 193.61,118.43 195.64,118.43 196.22,117.86 196.22,113.38 196.6,113 v2(197.88,113)
  vias: v1(199.33,113.48) v2(198.45,113) v2(198.45,112.4) v2(199.02,112.97) v2(199.02,112.4) v2(199.59,112.97) v2(199.59,112.4)
+1.35VS_VGAP: length 25.4
  TOP w0.254: v2(190.25,118.11) 189.79,118.11 PR711.2 188.82,117.93 PC714.1
  IN5 w0.254: v2(211.84,118.94) 211.84,119.51 211.46,119.89 208.41,119.89 207.9,120.4 199.97,120.4 198.31,118.75 194.44,118.75 194.06,119.13 192.47,119.13 191.71,118.37 190.5,118.37 v2(190.25,118.11)
  vias: v1(208.54,118.37) v2(208.66,118.94) v2(209.3,118.94) v2(209.68,118.05) v2(209.68,117.41) v2(209.68,116.78) v2(209.68,116.14) v2(209.93,118.94) v2(210.57,118.94) v2(210.57,116.14) v2(211.2,118.94) v2(211.2,116.14) v2(211.84,116.14) v2(212.47,118.94) v2(212.47,116.14) v2(213.11,118.94) v2(213.11,116.14) v2(213.74,117.9) v2(213.74,117.31) v2(213.74,116.73) v2(213.74,116.14) v2(214.38,117.9) v2(214.38,117.31) v2(214.38,116.73) v2(214.38,116.14) v2(214.38,115.56) v2(215.01,118.91) v2(215.01,118.28) v2(215.01,117.64) v2(215.01,117.06) v2(215.01,116.47) v2(215.01,115.89) v2(215.01,115.3) v2(215.65,118.91) v2(215.65,118.28) v2(215.65,117.64) v2(215.65,117.06) v2(215.65,116.47) v2(215.65,115.89) v2(215.65,115.3)
+1.35VSDGPU: length 310.9
  TOP w0.102: 216.66,69.79 216.79,69.79 CV885.1
  TOP w0.254: RV608.1 245.63,79.89 v2(245.08,79.34) ; CV1045.1 240.98,56.54 v2(240.92,56.6) ; v2(236.92,56.6) 237.05,56.48 CV1017.1 ; CV864.2 220.79,88.2 CV863.1 221.31,88.32 222.33,88.32 CV873.2 ; CV1017.1 CV1011.1 236.14,55.69 235.14,55.69 CV1001.1 ; CV1017.1 CV1016.1 ; CV1014.1 CV1012.1 239.14,55.98 v2(238.52,56.6) ; CV1015.1 248.85,64.54 v2(248.94,64.54) ; v2(248.92,58.2) 249.02,58.1 CV1004.1 ; CV1041.1 244.87,58.34 244.21,59 v2(244.12,59) ; CV1047.1 245.06,57.55 v2(245.72,58.2) ; CV1009.1 CV1006.1 CV1005.1 248.81,63.81 v2(248.12,63.81) ; CV1044.1 246.41,63.27 246.64,63.04 246.64,62.59 246.51,62.46 CV1000.1 246.11,61.74 245.94,61.91 CV1010.1 245.57,62.28 v2(246.12,62.83) ; CV1018.1 243.97,66.26 244.38,66.67 244.38,66.78 v2(244.78,67.17) ; CV1007.1 246,59.52 v2(246.52,59)
  TOP w0.381: v2(244.78,67.17) 244.86,67.25 CV1042.1 ; v2(222.31,80.65) 222.31,82.17 CV872.1 ; CV931.1 210.52,107.65 210,107.13 210,105.79 210.44,105.35 210.99,105.35 211.18,105.54 RV607.1 ; v2(204.91,79.82) 204.85,79.88 204.85,80.87 204.37,81.36 CV886.1 ; v2(214.12,84.84) 214.82,84.14 RV600.1
  TOP w0.457: v2(217.6,73.9) 217.6,74.04 218.14,74.58 CV900.1
  TOP w0.508: v2(207.55,108.88) 207.86,108.88 CV930.1 ; v2(222.31,80.65) 222.24,80.57 CV870.1 ; CV1026.1 CV1028.1 CV1029.1 238.58,94.13 ; v2(225.6,112.27) 225.81,112.47 225.81,113.09 CV946.1 CV947.1 228.28,113.09 229.61,111.77 v2(229.61,110.48) ; CV965.1 CV962.1 211.39,109.82 212.33,108.88 v2(212.35,108.88) ; CV954.1 238.81,106.86 v2(238.53,106.59) ; CV1008.1 246.44,55.18 v2(246.92,55.66) 246.76,55.81 CV999.1 ; RV634.1 245.23,97.38 244.48,98.12 v5(243.31,98.12) CV939.1 240.03,98.12 239.52,98.63 CV955.1 238.96,98.35 CV985.1 238.35,99.27 v2(238.36,99.28) ; CV1035.1 246.14,84.37 v2(245.95,84.18) ; CV976.1 206.31,111.7 v2(206.76,111.25) 206.82,111.25 207.33,111.76 CV975.1 ; v2(247.32,90.34) 247.32,90.38 246.8,90.89 246.8,91.61 CV1020.1 248.36,92.08 CV1037.1 250,92.19 250.57,91.63 250.57,91.12 249.92,90.48 CV1031.1 249.73,90.36 CV996.1 ; CV883.2 201.61,79.12 CV898.1 202.62,79.73 v2(202.57,79.78) ; CV941.1 238.33,102.49 CV953.1 237.64,102.5 v2(237.61,102.48) ; v2(248.32,67.15) 248.1,67.37 CV1002.1 CV1003.1 ; CV1048.1 245.73,65.39 v2(245.72,65.41) ; v2(245.24,91.65) 245.03,91.44 CV1032.1 ; CV969.1 214.81,111.48 215.31,111.98 v2(215.33,111.98) 216.44,111.98 216.85,111.57 CV960.1 CV958.1 ; v2(211.41,107.65) 211.4,107.65 CV931.1 ; v2(231.43,110.33) 231.83,109.93 CV942.1 ; v2(214.75,99.28) 214.98,99.05 CV974.1 215.81,98.95 CV971.1 ; CV984.1 236.81,109.79 236.69,109.68 v2(236.01,109.68) ; v2(245.72,88.83) 245.72,87.96 CV1039.1 ; RV8.1 250.86,56.62 v2(250.38,56.14) ; CV1046.1 237.5,67.59 237.5,67.22 v2(237.72,67.01) ; v2(208.35,108.07) 208.82,108.54 CV935.1 ; CV948.1 233.44,107.51 CV979.1 234.07,107.62 234.19,107.51 v2(234.32,107.51) ; v2(213.95,109.68) 213.87,109.76 CV970.1 ; CV884.2 215.58,65.9 v2(215.7,65.79) ; CV1043.1 CV1019.1 239.95,67.43 239.53,67.01 v2(239.32,67.01) ; v2(237.72,90.34) 237.72,90.52 237.97,90.78 237.97,91.05 CV997.1 ; CV977.1 204.92,109.11 v2(205.15,108.88) ; CV995.1 237.72,80.04 v2(237.72,80.73) ; v2(214.75,100.88) 214.77,100.89 CV973.1 ; CV942.1 232.29,108.85 CV950.1 ; CV942.1 233.58,109.93 CV943.1 ; CV997.1 CV1038.1 236.08,91.07 CV1021.1 ; CV997.1 238.01,91.06 CV994.1 ; v2(247.33,87.97) 247.33,87.38 CV993.1 247.46,87.11 CV1024.1 249.3,86.11 CV1025.1 ; CV896.2 CV897.2 v2(225.3,62.1) ; v2(205.14,110.44) 204.98,110.44 204.47,110.95 CV932.1 ; CV945.1 CV944.1 224.68,112.46 v2(224.46,112.24) ; RV623.1 226.11,108.9 CV981.1 226.36,108.65 226.92,108.65 v2(227.08,108.49) ; v2(228.09,106.47) 227.79,106.77 CV980.1 ; v2(250.32,82.22) 250.64,82.54 CV1013.1 CV1034.1 ; 238.58,94.13 238.58,93.09 238.86,92.81 CV994.1 ; 238.58,94.13 CV1027.1 CV1030.1 ; v2(244.12,87.94) 244.03,87.94 CV1036.1 ; CV1022.1 238.56,79.68 239.32,80.44 v2(239.32,80.73) ; v2(239.32,90.34) 239.32,90.4 238.86,90.86 CV994.1 ; CV956.1 238.88,109.81 v2(238.61,110.08) 238.61,110.6 CV937.1 238.95,111.02 237.68,112.29 CV951.1 237.65,112.48 237.06,112.48 CV938.1 ; CV972.1 213.98,107.25 v2(213.95,107.28) ; CV986.1 227.22,98.12 CV940.1 227.62,98.11 v2(228.02,98.51) ; v2(215.57,109.66) 215.6,109.66 216.46,108.8 CV978.1 ; v2(230.41,101.68) 230.46,101.73 231.01,101.73 231.34,102.06 RV605.1 ; v2(206.75,108.1) 206.96,107.9 CV936.1 ; CV1040.1 v2(240.12,84.08) ; v2(212.46,79.83) 212.58,79.95 CV902.1 ; CV929.1 209.04,100.99 v2(208.35,101.68) ; CV949.1 229.43,105.91 v2(229.64,105.7) ; CV1033.1 239.92,86.93 v2(240.12,87.13) ; CV982.1 226.33,110.73 226.95,110.11 v2(227.11,110.11) ; v2(228.86,107.32) 228.78,107.39 CV952.1 ; 216.66,69.79 v2(215.96,69.79) ; CV991.1 247.89,82.92 v2(248.11,83.14) ; CV888.1 215.96,67.46 v2(215.96,68.1) ; CV957.1 236.78,105.74 236.83,105.69 v2(236.83,105.67) ; RV618.2 216.24,106.44 v2(216.6,106.08) 216.54,106.02 CV961.1 ; v2(230.41,99.27) 230.71,99.57 CV983.1
  IN6 w0.508: v2(238.53,106.59) 238.2,106.25 237.37,106.25 236.86,105.74 236.86,105.69 v2(236.83,105.67)
  BOTTOM w0.254: UV26.H12 v2(244.12,89.54) UV26.G13 UV26.G14 ; UV23.L11 235.47,106.08 235.21,105.82 v2(235.21,105.68) ; v2(228.01,102.48) UV23.G1 ; v2(228.01,102.48) UV23.F1 ; v2(228.01,102.48) UV23.G2 ; UV26.G4 v2(244.92,82.33) UV26.F3 245.32,81.87 v2(245.71,81.48) ; 245.11,79.37 245.32,79.57 UV26.F1 ; 245.11,79.37 245.06,79.37 244.52,79.91 UV26.G1 ; 245.11,79.37 v2(245.08,79.34) ; UV23.E5 v2(230.41,101.68) ; UV26.N5 239.72,83.67 v2(240.12,84.08) ; UV26.F14 245.32,91.57 v2(245.24,91.65) ; UV25.K12 243.77,57.8 244.14,57.44 ; UV26.L14 v2(240.92,90.34) UV26.M14 ; UV25.L4 v2(244.12,64.6) ; v2(248.91,79.95) 248.91,79.95 UV26.B1 ; UV25.D12 239.3,58.18 239.3,58.21 ; UV26.F12 245.32,89.1 245.58,88.83 v2(245.72,88.83) 245.72,88.09 246.12,87.69 UV26.E10 ; UV24.R5 211.57,99.3 v2(211.56,99.3) ; v2(248.32,67.15) 248.39,67.07 248.39,66.73 UV25.T1 ; UV26.D14 v2(247.32,90.34) ; UV24.T14 204.38,98.5 v2(204.38,98.48) ; 240.92,57.4 v2(240.92,57.37) ; 240.92,57.4 UV25.F12 ; 240.92,57.4 UV25.G13 ; UV26.B14 v2(248.12,91.14) ; v2(228.09,106.47) 228.09,106.4 UV23.L2 ; UV24.F1 215.15,106.92 214.8,107.28 v2(213.95,107.28) UV24.F3 v2(213.15,106.48) UV24.G4 ; UV24.P12 v2(206.75,100.88) UV24.P11 ; UV25.G2 v2(240.92,66.21) ; v2(240.92,66.21) UV25.G1 ; v2(240.92,66.21) UV25.F1 ; UV24.E5 211.48,107.68 211.46,107.65 v2(211.41,107.65) ; v2(227.14,105.86) 227.36,106.08 UV23.L1 UV23.M1 ; UV23.R5 v2(230.41,109.68) ; UV23.T14 v2(238.61,110.08) ; UV23.L4 v2(229.64,105.7) ; UV18.B19 222.31,73.55 v2(222.6,73.26) ; UV23.E10 v2(235.21,101.68) ; UV25.R5 v2(248.12,63.81) ; UV24.T12 v2(206.75,99.28) ; UV25.M3 v2(245.72,65.41) ; UV25.L11 v2(244.12,59) ; UV23.B12 v2(236.01,99.28) ; UV25.M14 v2(245.32,55.67) ; UV25.L2 v2(244.12,65.41) ; UV24.G13 v2(205.95,105.68) UV24.H12 ; UV25.N5 v2(246.12,62.83) ; UV26.P3 v2(239.32,82.33) ; UV26.B3 v2(248.92,81.53) ; UV26.L13 v2(241.72,89.54) UV26.K12 ; UV18.T27 209.65,80.3 v2(210.08,79.87) 210.44,80.23 UV18.R27 ; UV24.T3 v2(213.15,99.28) ; UV25.P14 v2(246.92,55.66) ; UV24.N5 v2(212.35,101.68) ; v2(204.42,85.72) 204.42,85.36 UV18.AB33 ; UV26.G11 v2(244.12,87.94) ; 239.3,58.21 239.3,58.23 UV25.D11 ; 239.3,58.21 v2(239.31,58.21) ; UV25.D14 v2(238.52,56.6) ; UV23.P12 v2(236.01,108.08) UV23.P11 ; 244.14,57.44 v2(244.14,57.46) ; 244.14,57.44 244.52,57.06 UV25.L13 244.59,56.93 244.59,56.28 UV25.L14 ; UV26.B12 v2(248.92,88.74) ; UV25.R10 v2(248.12,59) ; UV23.F3 v2(228.81,101.68) ; UV23.D14 238.46,100.03 238.46,99.37 v2(238.36,99.28) 238.01,98.93 UV23.B14 ; UV25.H3 v2(241.72,64.61) UV25.G4 ; UV25.K3 v2(243.32,65.41) ; UV23.T3 v2(229.61,110.48) ; UV25.G11 241.71,58.21 ; 241.71,58.21 v2(241.71,58.24) ; 241.71,58.21 UV25.H12 ; UV24.D1 v2(215.6,108.03) ; UV23.F14 v2(237.61,102.48) UV23.G14 ; UV26.C5 v2(248.11,83.14) ; v2(228.04,100.88) 228.04,100.87 228.01,100.87 UV23.D1 ; UV23.P3 v2(229.61,108.88) ; v2(237.72,58.24) 237.72,58.21 UV25.B12 ; UV23.C5 v2(230.41,99.27) ; v2(238.38,62.92) 238.12,63.18 UV25.C5 ; UV25.T14 248.68,56.04 v2(248.68,55.68) ; UV23.B3 v2(228.81,99.28) ; UV26.T14 v2(237.72,90.34) ; UV23.P1 227.31,108.48 227.29,108.49 v2(227.08,108.49) ; UV26.T3 v2(237.72,82.33) ; v2(238.53,106.59) 238.53,106.62 238.28,106.88 UV23.M14 ; UV26.C10 247.72,87.58 v2(247.33,87.97) ; v2(245.37,67.12) 245.32,67.07 UV25.M1 ; UV23.K3 v2(228.81,104.88) ; UV26.T12 v2(237.72,88.74) ; UV25.P11 v2(247.32,58.2) UV25.P12 ; UV24.D11 207.13,108.48 v2(206.75,108.1) 206.38,108.48 UV24.D12 ; v2(228.86,107.32) 228.86,107.23 UV23.M3 ; v2(240.92,79.8) 240.9,79.82 240.86,79.82 240.52,80.16 UV26.M1 240.57,80.28 241.26,80.28 UV26.L1 241.38,80.39 241.38,81.08 UV26.L2 ; UV24.B1 v2(215.57,109.66) ; UV25.D3 v2(238.52,64.61) ; UV26.P14 v2(239.32,90.34) ; v2(205.15,100.88) UV24.P14 ; UV23.K12 236.8,105.67 v2(236.83,105.67) 236.86,105.69 236.86,105.7 237.21,106.06 UV23.L13 237.29,106.15 237.77,106.15 237.85,106.08 UV23.L14 ; UV24.P1 v2(214.75,100.88) ; UV24.C10 v2(207.55,108.88) ; v2(213.95,106.48) UV24.G2 ; UV24.G2 UV24.G1 ; UV24.G2 v2(213.95,105.68) UV24.H3 ; v2(208.35,108.07) 207.96,107.68 UV24.E10 207.8,107.68 207.4,107.28 206.79,107.28 206.39,106.88 UV24.F12 ; UV24.D3 v2(213.15,108.08) ; UV23.T12 v2(236.01,109.68) ; UV24.B12 v2(206.75,109.68) ; v2(222.3,68.43) 222.18,68.55 UV18.B13 ; UV26.M12 v2(240.92,88.74) UV26.L11 ; UV23.G11 v2(236.01,103.28) UV23.H12 ; UV26.H3 v2(244.12,81.53) UV26.G2 v2(244.92,81.53) ; v2(237.72,83.93) UV26.R5 ; UV23.F12 v2(236.81,102.48) UV23.G13 ; UV25.N10 v2(246.52,59) ; UV24.P3 v2(213.15,100.88) ; v2(209.69,85.71) 209.68,85.7 209.68,85.29 UV18.T33 ; UV24.B3 v2(213.95,109.68) ; UV23.H3 v2(229.61,103.28) UV23.G4 ; UV25.B1 v2(237.72,67.01) ; UV25.M12 v2(245.72,58.2) ; UV23.D11 v2(236.01,100.88) UV23.D12 ; UV26.K3 v2(241.72,82.33) UV26.L4 ; UV26.M3 v2(240.92,81.53) ; UV25.G14 v2(240.92,56.6) UV25.F14 ; UV25.T12 v2(248.92,58.2) ; UV26.T1 v2(237.72,80.73) ; UV24.G11 v2(207.55,105.68) ; UV23.P14 v2(237.63,108.86) ; v2(244.78,67.17) 244.78,67.17 244.52,66.91 UV25.L1 ; v2(227.11,110.11) 227.14,110.08 UV23.T1 ; v2(228.02,98.51) 227.98,98.51 UV23.B1 ; UV23.N5 230.67,107.68 230.41,107.93 v2(230.41,108.14) ; UV25.E5 v2(240.12,63.81) ; UV24.B14 v2(205.14,110.44) ; UV24.M3 v2(213.95,102.48) UV24.L2 ; UV26.R10 v2(238.52,87.94) ; v2(212.35,103.28) UV24.L4 UV24.K3 ; UV26.P12 v2(239.32,88.74) UV26.P11 ; UV26.E5 245.95,83.7 v2(245.95,84.18) ; UV25.P1 v2(247.32,66.21) ; UV23.D3 v2(229.61,100.08) ; UV24.L13 v2(205.95,103.28) UV24.K12 ; UV23.C10 v2(235.21,99.28) ; UV24.G14 205.14,106.46 v2(205.17,106.46) UV24.F14 ; v2(234.32,107.51) 234.49,107.68 UV23.N10 234.81,107.53 235.07,107.28 235.86,107.28 236.26,106.88 UV23.M12 ; UV26.N10 v2(240.12,87.13) ; UV26.D3 v2(246.56,82.29) ; UV26.D1 v2(246.55,79.97) ; UV24.L14 v2(205.15,102.48) UV24.M14 ; UV24.N10 v2(208.35,101.68) ; UV26.D12 v2(247.32,88.74) UV26.D11 ; v2(216.35,102.74) 215.68,102.08 UV24.M1 215.24,102.17 215.24,102.79 UV24.L1 ; UV25.D1 v2(239.32,67.01) ; UV24.T1 v2(214.75,99.28) ; UV25.B14 v2(236.92,56.6) ; UV24.R10 v2(207.55,100.08) ; UV24.D14 v2(205.15,108.88) ; UV25.F3 v2(240.12,65.41) ; UV23.R10 v2(235.21,109.68) ; UV25.B3 v2(237.72,65.41) ; UV25.P3 v2(247.32,64.61) ; UV25.C10 v2(237.72,59) ; UV26.P1 v2(239.32,80.73) ; UV24.C5 v2(212.35,108.88) ; UV25.E10 v2(240.09,59.03)
  BOTTOM w0.3: v2(222.62,70.68) 222.34,70.96 221.32,70.96 UV18.B16
  BOTTOM w0.305: UV18.P27 211.63,79.91 v2(211.63,79.89) 211.68,79.89 UV18.N27 ; v2(217.6,73.9) 217.63,73.9 218.19,73.34 218.63,73.34 UV18.E19 ; UV25.T3 248.52,64.96 v2(248.94,64.54) ; UV18.E13 218.82,68.55 218.47,68.9 v2(218.36,68.9) ; v2(207.23,86.75) 207.2,86.78 207.2,85.32 UV18.W33 ; UV18.T30 209.59,82.79 209.59,82.74 209.83,82.5 v2(209.83,82.32) ; v2(218.41,70.62) 218.41,70.62 UV18.E16 ; UV18.W30 207.15,82.8 207.5,82.45 v2(207.51,82.45) ; UV18.AA30 205.44,82.8 v2(205.01,82.37) ; UV24.L11 207.15,102.82 v2(206.75,102.42) 206.41,102.08 UV24.M12
  BOTTOM w0.381: RV630.2 243.65,78.74 v2(243.84,78.93) ; UV24.P14 204.12,100.48 204.09,100.51 CV933.1
  BOTTOM w0.508: v2(204.38,98.48) 204.14,98.24 CV934.1 ; v2(225.3,62.1) 225.74,61.66 CV871.1 CV862.1
  vias: v2(204.16,79.86) v2(204.75,113.64) v2(206.02,113.64) v2(206.66,79.87) v2(206.89,79.24) v2(207.29,113.64) v2(208.57,113.68) v2(209.29,113.67) v2(209.97,113.68) v2(215.86,77.32) v2(215.94,75.61) v2(215.94,73.1) v2(215.97,73.97) v2(217.36,116.27) v2(217.36,115.63) v2(217.36,115) v2(217.36,114.36) v2(217.36,113.73) v2(217.36,113.09) v2(217.37,112.46) v2(218,116.27) v2(218,115.63) v2(218,115) v2(218,114.36) v2(218,113.73) v2(218,113.09) v2(218.01,112.46) v2(218.63,116.27) v2(218.63,115.63) v2(218.63,115) v2(218.63,114.36) v2(218.63,113.73) v2(218.63,113.09) v2(218.64,112.46) v2(219.27,116.27) v2(219.27,115.63) v2(219.27,115) v2(219.27,114.36) v2(219.27,113.73) v2(219.27,113.09) v2(219.28,112.46) v2(219.9,116.27) v2(219.9,115.63) v2(219.9,115) v2(219.9,114.36) v2(219.9,113.73) v2(219.9,113.09) v2(219.91,112.46) v2(220.54,116.27) v2(220.54,114.36) v2(220.54,113.73) v2(220.54,113.09) v2(220.55,112.46) v2(221.49,87.82)
