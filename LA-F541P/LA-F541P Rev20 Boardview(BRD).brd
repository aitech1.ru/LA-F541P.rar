# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBC_MA3_BA3_H: length 31.6
  TOP w0.102: v2(241.71,87.94) 241.3,88.35 235.92,88.35 ; 222.74,77.65 222.58,77.65 222.15,77.22 220.79,77.22 220.45,76.87 220.45,74.93 219.6,74.08 219.6,73.49 v2(219.24,73.12)
  TOP w0.221: 235.92,88.35 233.92,88.35 v1(232.01,86.44) 223.22,77.65 222.74,77.65
  BOTTOM w0.102: UV26.K10 v2(241.71,87.94) ; UV18.E18 218.84,72.72 v2(219.24,73.12)
FBC_MA3_BA3_L: length 28.2
  TOP w0.102: v2(219.29,68.97) 219.67,68.59 221.2,68.59 221.97,67.82 221.97,67.08 223.27,65.79 225.62,65.79
  TOP w0.221: v2(241.72,59) 240.62,60.1 236.15,60.1 230.47,65.79 225.62,65.79
  BOTTOM w0.102: UV18.E14 219.26,68.97 v2(219.29,68.97)
  BOTTOM w0.107: UV25.H10 v2(241.72,59)
FBC_MA4_BA2_H: length 28.3
  BOTTOM w0.102: UV26.H11 243.33,87.95 243.33,87.51 242.83,87 ; UV18.A20 222.04,74.22 222.47,73.79 222.82,73.79 223.84,74.81
  BOTTOM w0.221: 242.83,87 242.31,86.49 235.52,86.49 v1(226.38,77.35) 223.84,74.81
FBC_MA4_BA2_L: length 27.5
  TOP w0.102: 225.48,66.86 223.16,66.86 v2(222.55,67.47) ; 243.65,59.82 243.65,59.5 243.74,59.42 243.74,58.59 v2(244.1,58.23)
  TOP w0.221: 225.48,66.86 226.23,66.86 226.47,66.62 230.67,66.62 236.46,60.83 v1(242.81,60.83) 243.14,60.83 243.65,60.32 243.65,59.82
  BOTTOM w0.102: UV18.A12 222.32,67.7 v2(222.55,67.47) ; v2(244.1,58.23) 244.09,58.23 UV25.K11
FBC_MA5_BA1_H: length 28.4
  TOP w0.102: 225.05,77.42 225.05,77.16 223.62,75.72 222.56,75.72 v2(221.64,74.8)
  TOP w0.147: 236.39,86.48 236.47,86.4 243.04,86.4 v2(243.33,86.68)
  TOP w0.221: 225.05,77.42 234.11,86.48 v1(235.38,86.48) 236.39,86.48
  BOTTOM w0.102: UV26.H10 243.72,87.44 243.33,87.05 v2(243.33,86.68)
  BOTTOM w0.107: UV18.B20 v2(221.64,74.8)
FBC_MA5_BA1_L: length 26.3
  BOTTOM w0.102: UV18.B12 221.57,68.03 222.76,68.03 223.4,67.39 224.75,67.39 224.99,67.15 ; UV25.K10 243.41,59.72 236.39,59.72 236.24,59.56 235.98,59.56
  BOTTOM w0.221: 224.99,67.15 227.42,67.15 v1(229.69,64.89) 235.01,59.56 235.98,59.56
FBC_MA6_MA11_H: length 36.9
  TOP w0.102: v2(216.74,73.12) 217.49,72.37 221.18,72.37 222.44,73.64 222.77,73.64 223.25,74.12
  TOP w0.147: 224.5,75.46 224.5,75.37 223.25,74.12 ; v2(244.12,83.13) 244.52,83.54 244.52,84.85 243.89,85.49 236.87,85.49 236.86,85.47
  TOP w0.221: 224.5,75.46 226.03,76.99 228.38,76.99 v1(235.33,83.95) 236.86,85.47
  BOTTOM w0.102: UV26.H5 v2(244.12,83.13) ; v2(216.74,73.12) 217.14,72.72 UV18.G18
FBC_MA6_MA11_L: length 32.1
  TOP w0.102: v2(216.74,70.62) 217.02,70.62 217.4,70.24 217.68,70.24 218.05,69.88 218.05,69.68 218.31,69.42 220.34,69.42
  TOP w0.221: 220.34,69.42 221.99,69.42 224.07,67.35 230.97,67.35 236.58,61.74 v1(240.02,61.74) 242.16,61.74 v2(243.35,62.93)
  BOTTOM w0.102: UV25.K5 243.35,63.04 v2(243.35,62.93) ; v2(216.74,70.62) 217.14,70.22 UV18.G15
FBC_MA7_MA8_H: length 29.9
  BOTTOM w0.102: UV18.B18 221.24,72.71 221.55,73.03 221.9,73.03 221.9,73.03 222.17,73.03 222.18,73.03 222.3,73.03 222.44,72.88 222.84,72.88 223.11,73.15 223.11,73.27 224.02,74.17 224.24,74.17 224.36,74.3 ; 242.92,84.81 243.41,84.32 243.41,83.05 UV26.H4
  BOTTOM w0.221: 224.36,74.3 224.39,74.33 224.92,74.33 v1(229.58,78.99) 236.16,85.57 242.15,85.57 242.92,84.81
FBC_MA7_MA8_L: length 28.6
  BOTTOM w0.102: 243.97,62.68 244.03,62.74 244.03,63.89 UV25.K4 ; UV18.B14 221.6,69.03 223.02,69.03 223.44,68.61 223.83,68.61
  BOTTOM w0.221: 243.97,62.68 243.33,62.04 242.6,62.04 241.58,61.02 235.62,61.02 v1(230.09,66.55) 228.03,68.61 223.83,68.61
FBC_MA12_RFU_H: length 33.2
  TOP w0.102: 241.37,79.51 241.37,81.28 242.14,82.05 242.14,82.49 242.36,82.72 242.64,82.72 242.95,83.03 v2(242.95,84.14) ; v2(218.41,71.47) 218.88,71.95 222.39,71.95 223.86,73.41 224.33,73.41 225.71,74.78 225.98,74.78
  TOP w0.221: 225.98,74.78 v1(229.22,74.78) 234.68,74.78 235.99,76.1 238.4,76.1 241.37,79.07 241.37,79.51
  BOTTOM w0.102: UV26.J5 242.92,84.1 v2(242.95,84.14) ; UV18.F17 v2(218.41,71.47)
FBC_MA12_RFU_L: length 29.7
  TOP w0.102: v2(218.43,69.84) 222.49,69.84 222.67,69.66
  TOP w0.221: v2(243.32,63.81) 242.7,63.18 242.7,63.1 242.08,62.48 236.87,62.48 231.27,68.08 224.26,68.08 222.67,69.66
  BOTTOM w0.102: UV25.J5 v2(243.32,63.81) ; v2(218.43,69.84) 218.43,69.84 218.79,70.2 UV18.E15
FBC_RAS#_H: length 30
  BOTTOM w0.102: UV18.D17 219.97,72.23 222.22,72.23 222.31,72.14 223.23,72.14 224.54,73.45 224.99,73.45 ; UV26.L3 241.01,82.25 241.01,82.86 241.19,83.05 241.29,83.05 241.63,83.39 241.63,83.66 241.43,83.86 241.43,84.14 241.35,84.22
  BOTTOM w0.221: 241.35,84.22 241.01,84.56 236.5,84.56 v1(228.46,76.52) 225.39,73.45 224.99,73.45
FBC_RAS#_L: length 26.1
  TOP w0.102: 236.6,65.02 240.54,65.02 v2(240.92,65.41) ; 223.35,69.89 223.08,70.17 219.72,70.17 v2(219.27,70.62)
  TOP w0.221: 223.35,69.89 224.44,68.8 232.14,68.8 v1(235.17,65.77) 235.92,65.02 236.6,65.02
  BOTTOM w0.102: UV18.D14 219.64,69.43 219.27,69.79 v2(219.27,70.62) ; UV25.G3 v2(240.92,65.41)
FBC_RST#_H: length 29
  TOP w0.102: RV615.1 243.46,82.48 v2(242.52,81.53) 242.9,81.15 242.9,80.39 242.83,80.32 ; 225.07,73.09 224.76,73.09 v2(224.35,72.67)
  TOP w0.221: 242.83,80.32 242.83,78.27 238.18,73.62 235.85,73.62 235.56,73.33 225.31,73.33 225.07,73.09
  BOTTOM w0.102: UV26.J2 v2(242.52,81.53) ; UV18.A17 223.57,71.9 v2(224.35,72.67)
FBC_RST#_L: length 26.2
  TOP w0.102: RV616.1 242.13,64.28 242.13,65.15 242.52,65.54 v2(242.52,66.21) 242.14,65.82 236.69,65.82 236.32,66.19
  TOP w0.221: v2(223.79,70.7) 223.79,70.61 224.87,69.53 232.98,69.53 236.32,66.19
  BOTTOM w0.102: UV18.A15 222.19,70.05 223.24,70.05 223.84,70.65 v2(223.79,70.7) ; UV25.J2 v2(242.52,66.21)
FBC_WCK0: length 24.8
  IN6 w0.097: v2(238.52,63.81) 238.79,63.54 238.79,62.78 237.61,61.6 225.16,61.6 224.05,62.72 222.4,62.72 222.22,62.9 222.2,62.9 222.2,62.9 222.15,62.9 222.15,62.91 221.72,62.91 ; 219.83,64.12 219.47,64.48 218.98,64.48 218.77,64.28 218.77,64.02 218.67,63.92 v2(218.41,63.92)
  IN6 w0.102: 219.83,64.12 221.05,62.91 221.72,62.91
  BOTTOM w0.102: UV25.D4 v2(238.52,63.81)
  BOTTOM w0.114: UV18.F8 217.99,64.34 v2(218.41,63.92)
FBC_WCK0_N: length 24.8
  IN6 w0.097: v2(239.32,63.81) 239.08,63.81 238.96,63.69 238.96,62.71 237.68,61.43 225.09,61.43 223.98,62.55 222.33,62.55 222.15,62.73 221.72,62.73 ; 219.7,64 219.4,64.3 219.05,64.3 218.95,64.2 218.95,64.02 219.05,63.92 v2(219.22,63.92)
  IN6 w0.102: 221.72,62.73 220.97,62.73 219.7,64
  BOTTOM w0.102: UV25.D5 v2(239.32,63.81)
  BOTTOM w0.114: UV18.E8 218.84,64.32 219.22,63.94 219.22,63.93 v2(219.22,63.92)
FBC_WCK1: length 30
  IN1 w0.097: v2(247.29,63.86) 247.29,63.67 247.19,63.56 246.98,63.56 246.7,63.28 246.7,62.07 245.78,61.15 235.16,61.15 233.46,62.85 222.7,62.85 222.68,62.87 222.21,62.87 222.01,62.67 222.01,62.46 221.85,62.29 v2(221.62,62.29)
  BOTTOM w0.102: v2(247.29,63.86) 247.17,63.86 246.92,64.12 UV25.P4 ; v2(221.62,62.29) 221.94,62.29 222.06,62.17 222.06,61.92 UV18.A5
FBC_WCK1_N: length 30.1
  IN1 w0.097: v2(222.6,62.14) 222.48,62.26 222.31,62.26 222.18,62.38 222.18,62.6 222.28,62.7 222.61,62.7 222.63,62.68 233.39,62.68 235.09,60.98 245.86,60.98 246.87,62 246.87,63.21 247.05,63.39 247.26,63.39 247.36,63.29 v2(247.36,63)
  BOTTOM w0.102: v2(247.36,63) 247.32,63 UV25.P5 ; UV18.A6 v2(222.6,62.14)
FBC_WCK2: length 24.8
  IN6 w0.097: v2(238.52,83.13) 238.86,83.47 238.86,83.87 238.34,84.39 235.85,84.39 235.8,84.34 235.79,84.34 230.77,79.32 224.92,79.32 224.71,79.1 224.71,79.1 223.97,78.36 221.97,78.36 221.81,78.51 221.81,78.51 221.67,78.65 219.49,78.65 219.27,78.43 v2(219.27,78.12)
  BOTTOM w0.102: UV26.P4 v2(238.52,83.13)
  BOTTOM w0.114: UV18.D24 219.64,77.76 v2(219.27,78.12)
FBC_WCK2_N: length 24.8
  IN6 w0.097: v2(239.32,83.13) 239.03,83.42 239.03,83.94 238.41,84.57 235.77,84.57 230.7,79.49 224.85,79.49 223.89,78.53 222.08,78.53 221.89,78.72 221.89,78.72 221.79,78.82 219.39,78.82 v2(219.25,78.96)
  BOTTOM w0.102: UV26.P5 v2(239.32,83.13)
  BOTTOM w0.114: UV18.D25 219.64,78.57 v2(219.25,78.96)
FBC_WCK3: length 31
  IN1 w0.097: v2(221.62,79.76) 221.29,80.09 221.29,80.3 221.39,80.4 221.78,80.4 222.11,80.07 223.92,80.07 224.69,79.31 231.35,79.31 235.81,83.78 236.75,83.78 237.49,84.52 245.06,84.52 245.13,84.6 246.18,84.6 246.33,84.44 246.33,83.32 v2(246.55,83.1)
  BOTTOM w0.102: UV18.B27 221.62,79.82 v2(221.62,79.76) ; v2(246.55,83.1) UV26.D4
FBC_WCK3_N: length 31
  IN1 w0.097: v2(246.76,84.01) 246.61,84.01 246.5,84.12 246.5,84.51 246.25,84.77 245.06,84.77 244.98,84.69 237.42,84.69 236.68,83.95 235.74,83.95 231.27,79.49 224.76,79.49 224,80.25 222.18,80.25 221.85,80.58 220.05,80.58 v2(220.04,80.58)
  BOTTOM w0.102: UV18.C27 220.05,80.58 v2(220.04,80.58) ; UV26.D5 246.76,83.69 v2(246.76,84.01)
FBC_WE#_H: length 32.6
  TOP w0.102: 226.39,77.72 224.17,75.51 224.17,75.42 223.3,74.55 222.29,74.55 v2(220.83,73.09)
  TOP w0.147: 236.42,85.92 v1(242.55,85.92) 243.47,85.92 244.59,87.04 244.59,88.14 244.12,88.61 v2(244.12,88.74)
  TOP w0.221: 236.42,85.92 236.27,85.92 236.1,85.75 234.41,85.75 226.39,77.72
  BOTTOM w0.102: v2(220.83,73.09) UV18.C18 ; UV26.G12 v2(244.12,88.74)
FBC_WE#_L: length 30.6
  BOTTOM w0.102: UV18.C14 220.96,68.88 221.47,68.88 221.52,68.83 222.74,68.83 223.69,67.88 224.99,67.88
  BOTTOM w0.221: UV25.L12 244.92,58.21 244.92,59.73 244.36,60.29 235.31,60.29 v1(231.74,63.86) 227.72,67.88 224.99,67.88
FBVDD/Q_ENP: length 3.4
  TOP w0.203: PC710.1 196.6,118.1 196.6,117.6 195.96,116.97 PU700.3
  TOP w0.254: PR709.2 197.24,118.62 197.04,118.42 PC710.1
FBVDD_EN: length 200.7
  TOP w0.203: PR709.1 v1(199.52,118.62) 200.28,118.62 200.79,119.13 v2(200.79,119.89) ; U33.19 205.17,53.36 v2(204.55,53.99)
  TOP w0.254: QZ6.5 252.22,55.04 v2(251.49,54.31) ; RV550.1 208.66,45.72 DV13.1 209.16,46.17 210.28,47.28 210.34,47.28 v2(210.35,47.3)
  IN2 w0.203: v2(210.35,47.3) 210.24,47.41 209.06,47.41 207.99,48.48 207.7,48.48 205.78,50.41 205.78,50.7 204.66,51.82 204.66,53.88 v2(204.55,53.99) 204.1,54.43 202.5,54.43 201.17,55.76 199.57,55.76 197.46,57.87 197.46,59.72 195.12,62.05 195.12,63.55 189.52,69.16 189.52,73.98 179.72,83.78 179.72,85.23 178.72,86.23 177.42,86.23 176.98,85.79 175.83,85.79 175.26,86.36 172.15,86.36 171.46,87.05 171.46,88.09 170.15,89.4 167.12,89.4 162.75,93.77 162.75,100.14 v2(163.04,100.43)
  IN2 w0.254: v2(251.49,54.31) 252.05,53.75 252.05,52.63 251.37,51.96 250.78,51.96 249.18,50.36 249.18,49.59 248.81,49.23 248.81,46.5 247.35,45.04 236.22,45.04 235.53,45.72 218.95,45.72 217.91,46.76 214.22,46.76 213.36,47.62 211.34,47.62 210.95,47.23 210.45,47.23 210.38,47.3 v2(210.35,47.3)
  IN3 w0.254: v2(163.04,100.43) 163.55,100.43 165.38,102.26 165.38,105.98 164.83,106.53 164.83,112.13 164.57,112.4 164.57,114.78 165.02,115.24 165.02,115.9 167.88,118.75 172.79,118.75 173.48,118.06 173.48,117.5 174.34,116.65 181.14,116.65 181.64,116.16 182.78,116.16 185.62,119 188.09,119 189.87,120.78 192.51,120.78 194.13,119.16 195.99,119.16 196.72,119.89 198.88,119.89 199.52,120.52 200.41,120.52 200.79,120.14 v2(200.79,119.89)
FBVDD_PSI: length 6.7
  TOP w0.14: PR703.2 198.46,119.85 199.01,120.4 199.14,120.4 v1(199.52,120.78)
  TOP w0.203: PU700.4 195.92,117.37 196.22,117.67 196.22,119.51 196.6,119.89
  TOP w0.254: 196.6,119.89 197.78,119.89 PR708.1 198.17,119.8 198.21,119.76 PR703.2
FBVDDQ_SENSE: length 116.8
  TOP w0.254: PR718.2 190.72,117.86 v2(190.88,117.86)
  IN3 w0.127: 215.41,65.33 215.41,62.87 215.43,62.84 215.43,61.01 215.52,60.92 215.52,59.22 216.13,58.61 216.6,58.61 v2(217.81,57.41) 217.41,57.41 216.59,56.59 215.2,56.59 214.88,56.9 214.88,58.57 213.82,59.64 213.82,60.87 213.75,60.94 213.75,61.8 213.79,61.84 213.79,62.68 213.73,62.74 213.73,63.55 213.79,63.62 213.79,66.12 214.12,66.44 214.12,68.17 214.62,68.67 214.62,69.75 214.92,70.05 214.92,70.4 214.61,70.72 214.61,72.67 214.82,72.88 214.82,72.52 215.51,71.83 215.51,68.61 214.84,67.94 214.84,65.9 215.41,65.33 ; 203.75,82.15 204.12,81.77 204.12,81.65 204.59,82.12 204.59,82.74 204.6,82.76 204.6,84.5 203.85,85.25 203.75,85.15 203.75,84.63 203.7,84.58 203.7,83.59 203.76,83.53 203.76,82.81 203.75,82.79 203.75,82.15
  IN3 w0.254: 203.85,85.25 203.04,86.05 203.04,88.21 203.51,88.67 203.51,105.22 203.16,105.57 203.16,106.6 200.03,109.73 197.87,109.73 195.58,112.02 188.72,112.02 188.22,112.52 188.22,114.05 190.31,116.14 190.31,117.29 v2(190.88,117.86) ; 204.12,81.65 203.68,81.21 202.33,81.21 202,80.88 202,79.45 202.55,78.9 205.04,78.9 205.3,78.64 207.14,78.64 207.4,78.9 209.53,78.9 209.71,78.73 213.13,78.73 213.24,78.83 214.45,78.83 214.82,78.47 214.82,72.88
  BOTTOM w0.254: UV18.F1 217.94,57.54 v2(217.81,57.41)
FCCM_GT: length 43.5
  TOP w0.14: v2(112.94,103.08) 112.61,102.75 v1(112.61,102.64)
  TOP w0.203: v2(112.94,103.08) 112.94,103.95 113.58,104.59 PU1100.11
  IN1 w0.254: v2(104.67,81.08) 104.42,81.08 103.56,80.21 103.56,77.74 104.33,76.96 104.33,73.8 v2(103.81,73.28)
  IN4 w0.254: v2(112.94,103.08) 112.87,103.16 106.53,103.16 105.51,102.14 105.51,96.17 105.31,95.96 105.31,93.17 103.68,91.55 103.68,82.06 v2(104.67,81.08)
  BOTTOM w0.254: PU1300.2 104.93,81.34 v2(104.67,81.08) ; PU1301.2 103.99,73.46 v2(103.81,73.28)
FCCM_SA: length 19.3
  TOP w0.203: PU1100.34 120.95,107.79 v2(121.06,107.89)
  IN4 w0.254: v2(112.76,95.49) 113.96,96.69 113.96,97.23 115.18,98.44 115.18,102.38 116.36,103.56 119.2,103.56 120.26,104.61 120.26,107.09 v2(121.06,107.89)
  BOTTOM w0.254: v2(112.76,95.49) 112.81,95.45 PU1302.7
FCCM_VCORE: length 56.3
  TOP w0.203: PU1100.24 120.29,103.36 v2(120.78,102.87)
  IN2 w0.254: v2(120.78,102.87) 121.21,102.44 123.03,102.44 123.91,103.32 132.66,103.32 135.31,105.96 135.31,109.37 135.92,109.98 135.92,110.46 v2(135.46,110.92) 136.63,110.92 136.76,110.79 140.51,110.79 143.06,113.33 143.06,114.35 143.77,115.07 145.67,115.07 147.55,116.94 147.55,119.55 147.85,119.85 v2(147.99,119.85) 147.99,119.59 148.25,119.33 151.28,119.33 152.22,118.39 155.07,118.39 155.49,118.81 156.9,118.81 157.25,119.16 v2(157.25,119.49)
  BOTTOM w0.254: v2(157.25,119.49) 157.25,119.4 157.46,119.18 PU1202.2 ; v2(147.99,119.85) 147.99,119.75 148.27,119.47 PU1201.2 ; PU1200.2 136.29,112.44 135.94,112.09 135.94,111.4 135.9,111.36 135.76,111.21 135.75,111.21 v2(135.46,110.92)
FFS_INT2: length 196.7
  TOP w0.14: QF1.2 234.47,43.56 236.68,45.77 v2(236.68,46.05) 236.31,46.42 UF1.11 ; v2(182.84,4.3) 183.33,4.79 183.56,4.79 183.91,4.43 185.94,4.43 186.23,4.72 186.23,6.99 186.87,7.62 186.87,8.75 186.77,8.85 186.77,9.34 186.06,10.05 186.06,15.78 188.21,17.93 188.42,18.15 v2(188.42,18.36) ; RF5.2 240.26,43.07 v5(240.26,42.65) 239.9,42.65 v2(239.36,42.11)
  IN1 w0.099: v2(182.84,4.3) 182.56,4.59 178.42,4.59 177.56,3.73 168.28,3.73 167.59,4.42 162.76,4.42 162.13,3.79 149.48,3.79 148.71,4.56 148.07,4.56 144.89,7.74 142.1,7.74 139.05,4.69 137.74,4.69 136.13,3.07 126.57,3.07 126.44,3.2 122,3.2 121.26,3.94 120.37,3.94 119.33,4.98 118.85,4.98 117.84,3.97 107,3.97 106.43,4.55 104.52,4.55 104.36,4.71 103.47,4.71 102.57,3.81 100.39,3.81 99.59,3.01 97.66,3.01 96.37,4.3 93.04,4.3 92.94,4.4 92.94,4.47 92.93,4.48 v6(92.93,4.49)
  IN6 w0.099: v2(188.42,18.36) 188.28,18.51 188.28,25.63 192.2,29.55 192.2,29.93 193.1,30.83 193.47,30.83 204.04,41.4 238.65,41.4 v2(239.36,42.11)
  BOTTOM w0.089: v6(92.93,4.49) 92.94,4.5 92.94,4.82 93.09,4.97 93.09,5.46 UH2.BE14
  BOTTOM w0.14: v2(236.68,46.05) 236.68,45.31 239.36,42.63 v2(239.36,42.11)
FFS_INT2_Q: length 86.7
  TOP w0.14: QF1.3 233.59,42.91 233.48,43.03 RF2.2 232.93,42.25 233.81,41.38 247.79,41.38 248.91,40.26 252.5,40.26 260.54,32.22 260.54,29.68 261.39,28.84 261.39,23.98 261.92,23.45 261.92,22.56 263.87,20.61 263.87,18.97 263.61,18.71 263.61,15.18 262.5,14.08 v1(262.5,12.08) 262.5,9.85 v2(262.82,9.54)
  IN3 w0.091: v2(236.36,9.84) 236.8,9.4 239.52,9.4 240.16,10.03 262.32,10.03 v2(262.82,9.54)
  BOTTOM w0.14: v2(236.36,9.84) JHDD.11
FGND: length 8
  BOTTOM w0.14: 318.42,31.83 318.9,31.34 318.9,29.72 v1(318.64,29.47) ; 318.42,31.83 318.77,32.18 318.77,33.78 317.76,34.8 316.87,34.8 316.6,35.07 JFP.4 ; 318.42,31.83 RE255.2
FPR_DET#: length 56
  TOP w0.076: UE3.B3 294.59,12.54 v2(294.53,12.54)
  TOP w0.14: RE284.1 295.31,4.98 295.31,5.43 v2(295.45,5.57)
  IN2 w0.099: v2(321.82,29.59) 320.3,28.07 320.3,26.8 318.39,24.89 318.39,22.35 315.47,19.43 314.2,19.43 312.42,17.65 310.39,17.65 310.01,17.27 310.01,15.75 309.12,14.86 307.47,14.86 306.2,16.13 306.2,17.15 305.94,17.4 305.18,17.4 304.67,16.89 304.29,16.89 303.79,16.38 303.79,14.61 303.28,14.1 303.28,12.57 302.86,12.15 294.92,12.15 v2(294.53,12.54)
  IN3 w0.091: v2(295.45,5.57) 295.45,5.76 295.25,5.96 295.25,7.06 294.46,7.84 294.46,10.48 295.14,11.15 295.14,11.99 294.59,12.54 v2(294.53,12.54)
  BOTTOM w0.14: v2(321.82,29.59) 321.31,29.08 v1(320.55,29.08) 320.3,29.34 320.3,31.19 319.81,31.67 RE274.1
FPR_GPIO_DET#: length 6.7
  BOTTOM w0.14: JFP.1 318.49,35.59 319.72,34.35 MD3.1 319.72,32.65 RE274.2 319.74,32.59 319.28,32.13 319.28,30.74 v1(319.79,30.23)
FPR_GPIO_SCAN#: length 7.9
  BOTTOM w0.14: MD4.1 321.25,32.65 RE273.2 ; MD4.1 v1(322.58,33.4) ; MD4.1 321.25,33.72 318.52,36.45 318.01,36.45 317.6,36.04 JFP.2
FPR_SCAN#: length 54
  TOP w0.076: UE3.E5 v2(297.76,13.37)
  TOP w0.14: RE283.1 296.06,5.51 v2(296.11,5.56)
  IN2 w0.099: v2(297.76,13.37) 297.76,13.41 298.58,14.23 298.58,14.99 298.97,15.37 299.98,15.37 300,15.36 300.33,15.36 300.35,15.37 302.77,15.37 303.01,15.61 303.01,16.37 303.91,17.27 304.55,17.27 305.18,17.91 306.07,17.91 306.71,17.27 306.71,16.26 307.65,15.31 308.93,15.31 309.56,15.93 309.56,17.46 310.2,18.1 312.24,18.1 314.01,19.88 315.28,19.88 317.94,22.54 317.94,25.08 319.85,26.98 319.85,28.25 v2(321.18,29.59)
  IN3 w0.076: v2(297.76,13.37) 297.36,12.97 297.36,12.83
  IN3 w0.091: v2(296.11,5.56) 296.65,5.56 297,5.91 297,6.49 296.86,6.63 296.24,6.63 294.77,8.1 294.77,10.08 295.86,11.18 297,11.18 297.36,11.53 297.36,11.93 297.36,11.94 297.36,12.4 297.36,12.4 297.36,12.73 297.36,12.74 297.36,12.83
  BOTTOM w0.14: v1(322.84,31.5) 322.66,31.67 RE273.1 320.68,31.17 320.68,30.1 v2(321.18,29.59)
FRM_LCK: length 19
  TOP w0.14: v2(214.46,47.4) 214.46,47.41 214.11,47.76 RV564.1
  IN1 w0.099: v2(214.46,47.4) 214.46,47.41 214.27,47.6 214.27,53.15 214.56,53.44 214.56,55.65 214.44,55.76 214.44,57.02 214.86,57.44 214.86,58.59 214.47,58.99 214.47,60.9 214.59,61.03 214.59,62.46 214.72,62.59 214.72,63.4 v2(214.22,63.89)
  BOTTOM w0.14: v2(214.22,63.89) 213.83,63.5 UV18.L7
GC5_MODE: length 20
  TOP w0.14: v2(213.22,46.81) 212.85,46.44 T210.1 213.44,45.52 RV1839.1
  IN1 w0.099: v2(213.22,46.81) 213.05,46.64 211.81,46.64 211.38,47.07 211.38,48.27 211.14,48.51 211.14,50.32 212.65,51.83 212.65,57.86 211.94,58.57 211.48,58.57 210.85,59.2 v2(210.85,60.59)
  BOTTOM w0.14: v2(210.85,60.59) 211.24,60.97 UV18.P4
GC6_EVENT#: length 167.7
  TOP w0.14: DV14.1 214.54,42.9 v1(215.21,43.57) 215.21,43.82 v2(215.46,44.07) ; v2(185.65,5.01) 185.29,5.37 185.29,15.98 185.16,16.11 185.16,18.67 185.26,18.77 185.26,22.52 v2(185.4,22.66)
  IN2 w0.089: 101.98,2.49 v2(101.43,3.04)
  IN2 w0.099: v2(185.65,5.01) 185.65,5.29 185.18,5.76 184.54,5.76 182.19,8.11 176.72,8.11 175.87,7.25 170.73,7.25 169.64,6.16 159.89,6.16 159.64,5.91 156.78,5.91 155.97,6.73 151.88,6.73 151.36,7.25 146.69,7.25 145.41,8.53 142.91,8.53 139.9,5.51 136.36,5.51 134.61,7.26 134.61,8.08 133.69,8.99 132.52,8.99 130.55,10.96 125.43,10.96 124.09,9.62 119.45,9.62 115.83,6 115.83,5.26 114.78,4.21 107.93,4.21 107.18,3.46 106.22,3.46 104.86,2.11 102.36,2.11 101.98,2.49
  IN6 w0.099: v2(215.46,44.07) 214.33,42.94 201.29,42.94 185.64,27.29 185.64,22.9 v2(185.4,22.66)
  BOTTOM w0.089: v2(101.43,3.04) 100.76,2.38 97.9,2.38 97.78,2.26 95.84,2.26 95.39,2.72 95.39,3.48 94.49,4.38 94.49,4.78 94.8,5.09 94.8,5.47 95.03,5.7 UH2.BE9
GC6_EVENT#_D: length 22.8
  TOP w0.14: DV14.2 215.07,44.6 v1(215.39,44.92) 215.39,45.09 215.22,45.26 RV551.1 215.52,45.87 v2(215.9,46.25)
  IN1 w0.099: v2(215.9,46.25) 215.26,46.89 214.31,46.89 213.31,47.89 213.31,49.8 213.46,49.95 213.46,54.85 213.77,55.15 213.77,62.68 v2(214.21,63.12)
  BOTTOM w0.14: v2(214.21,63.12) UV18.L6
GPIO0: length 4.7
  TOP w0.14: RM13.2 26.87,71.26 26.73,71.12 25.96,71.12 25.28,71.8 23.16,71.8 UM1.C4
GPIO2: length 3.8
  TOP w0.14: RM12.2 26.63,72.77 25.98,73.42 23.94,73.42 UM1.E3
GPIO4: length 12.7
  TOP w0.14: RM20.2 25.03,66.04 RM11.2 23.82,66.04 v2(23.73,66.13) 23.54,66.32 v1(23.2,66.32) ; UM1.E7 v2(20.75,74.21)
  IN2 w0.099: v2(23.73,66.13) 22.69,66.13 21.16,67.67 21.16,73.8 v2(20.75,74.21)
GPP_H12: length 4.6
  TOP w0.089: v2(75.37,17.09) v1(75.9,17.09) 76.38,17.09 76.96,16.51 RH5881.2
  BOTTOM w0.089: UH2.AB47 76.31,17.34 75.62,17.34 v2(75.37,17.09)
GPP_H15: length 8.1
  TOP w0.089: v2(79.6,17.44) 79.07,17.96 RH42.2 79.07,18.59 78.6,19.06 v1(78.55,19.06)
  BOTTOM w0.089: v2(79.6,17.44) 79.59,17.43 79.59,16.99 79.81,16.78 80.34,16.78 80.52,16.6 80.52,16.42 80.29,16.19 77.76,16.19 77.52,16.43 77.52,16.56 77.31,16.78 76.99,16.78 76.81,16.59 UH2.AC47
GPP_J4: length 5
  TOP w0.089: v2(96.37,9.66) 96.05,9.98 95.51,9.98 95.4,9.88 94.88,9.88 94.69,10.07 93.05,10.07 RH5853.2
  BOTTOM w0.089: UH2.AV4 96.8,9.23 v2(96.37,9.66)
GPP_J6: length 7.2
  TOP w0.089: RH5854.2 94.62,10.39 94.95,10.06 95.33,10.06 95.43,10.16 96.42,10.16 v1(97.82,8.76) 97.91,8.68 97.91,7.32 v2(97.45,6.86)
  BOTTOM w0.089: v2(97.45,6.86) 97.55,6.97 UH2.BA4
GPP_J9: length 6.5
  TOP w0.089: RH5890.1 RH5855.2 90.65,11.02 90.94,10.74 91.69,10.74 92.54,9.89 94.18,9.89 94.44,9.63 v2(94.44,9.48)
  BOTTOM w0.089: UH2.AU9 95.16,9.48 v2(94.44,9.48)
GPPJ_RCOMP: length 1.1
  BOTTOM w0.14: v1(102.79,6.71) 102.16,6.07 RH5834.1
GPU_CORE_PG: length 144.2
  TOP w0.127: v2(250.59,41.4) v1(250.59,40.85)
  TOP w0.254: v2(250.59,41.4) 250.69,41.5 DV16.3 ; v2(172.98,112.14) 172.98,112.08 172.6,111.7 UV28.2
  IN3 w0.254: v2(172.98,112.14) 172.98,111.66 171.23,109.91 171.23,103.33 169.48,101.59 169.48,95.4 170.01,94.88 171.94,94.88 173.11,93.71 174.96,93.71 175.41,93.25 175.41,92.81 176.79,91.44 179.39,91.44 179.99,90.84 179.99,87.98 180.44,87.52 180.44,85.41 181.85,84 182.34,84 183.14,83.2 183.14,78.33 182.05,77.24 182.05,70.74 183.71,69.07 183.71,65.91 184.56,65.06 186.93,65.06 188.28,63.71 188.28,61.28 188.28,61.27 188.28,60.2 193.35,55.12 196.13,55.12 197.33,53.91 198.25,53.91 198.95,54.61 201.04,54.61 201.32,54.33 203.24,54.33 203.81,54.9 219.19,54.9 223.55,50.55 229.95,50.55 236.03,44.47 236.03,43.43 239.58,39.88 249.06,39.88 v2(250.59,41.4)
  BOTTOM w0.254: PR1017.2 172.84,112.28 v2(172.98,112.14)
GPU_CORE_VDDS_PG: length 175.8
  TOP w0.14: v2(203.16,49.23) 202.95,49.44 202.95,49.96 203.48,50.5 U33.5
  IN1 w0.099: v2(244.35,113.41) 244.3,113.46 230.86,113.46 229.79,114.53 229.79,116.32 226.53,119.59 224.54,119.59 223.4,120.73 215.6,120.73 215.33,120.46 208.6,120.46 208.03,121.03 200.03,121.03 198.12,119.13 193.55,119.13 192.28,120.4 190.56,120.4 v2(190.12,119.95)
  IN3 w0.091: v2(190.12,119.95) 190.12,119.38 186.85,116.11 186.08,116.11 182.95,112.98 176.81,112.98 176.09,112.26 174.97,112.26 172.21,109.5 172.21,107.6 173.64,106.17 173.64,95.91 174.04,95.51 175.5,95.51 176.39,96.39 178.69,96.39 181.3,93.78 181.3,90.83 181.91,90.22 181.91,88.13 183.86,86.18 184.12,86.18 184.46,85.84 184.46,84.53 185.69,83.29 185.69,78.6 183.6,76.51 183.6,72.58 186.35,69.84 186.75,69.84 193.93,62.65 195.12,62.65 196.19,61.58 196.19,59.6 199.11,56.68 200.45,56.68 200.83,57.07 203.19,57.07 203.8,57.68 205.15,57.68 v2(205.52,58.06)
  IN6 w0.099: v2(203.16,49.23) 202.44,49.95 202.44,53.6 203.46,54.61 203.46,56.74 204.77,58.06 v2(205.52,58.06)
  BOTTOM w0.14: PR905.1 244.55,113.62 v2(244.35,113.41) ; PR1518.2 190.7,120.54 v2(190.12,119.95)
GPU_GC6_FB_EN: length 342
  TOP w0.076: 304.29,12.52 303.91,12.52 303.85,12.57 303.35,12.57 UE3.M4
  TOP w0.14: v2(304.99,12.39) 304.85,12.52 304.29,12.52 ; U33.7 204.19,49.59 204.19,48.18 RV1844.1 203.38,47.37 203.38,46.69 205.59,44.48 209.07,44.48 v2(210.06,45.47) ; v2(184.95,26) 184.76,25.82 184.76,23.28 184.83,23.21 184.83,22.46 185.02,22.27 185.02,18.87 184.92,18.77 184.92,12.07 184.28,11.43 184.28,9.42 v2(184.61,9.08) ; RV1133.1 242.36,43.45 v2(242.36,44.1) 242.67,44.41 242.67,47.29 v1(242.11,47.84) 241.61,48.35 241.61,49.29 242.16,49.85 243.76,49.85 QV98.1
  IN5 w0.089: 101.98,2.26 96.03,2.26 95.66,2.63 v2(95.66,3.75)
  IN5 w0.099: v2(304.99,12.39) 304.9,12.47 304.43,12.47 302.29,10.33 300.37,10.33 300.12,10.08 298.43,10.08 298.17,10.34 295.3,10.34 294.22,9.26 293.12,9.26 291.47,10.91 291.29,10.91 289.71,12.49 288.23,12.49 288.1,12.36 287.75,12.36 286.12,10.73 284.44,10.73 284.1,10.39 282.59,10.39 281.45,9.25 279.38,9.25 278.08,7.95 271.84,7.95 270.95,8.84 268.43,8.84 268.13,8.54 266.08,8.54 264.51,10.1 248.11,10.1 247.41,10.8 215.83,10.8 213.06,13.56 199.23,13.56 198.63,12.96 198.63,12.21 197.89,11.47 196.44,11.47 193.35,8.38 185.32,8.38 v2(184.61,9.08) ; 101.98,2.26 102.66,2.26 103.38,2.98 107.7,2.98 108.09,3.36 115.33,3.36 116.19,2.5 125.67,2.5 126.48,1.7 148.2,1.7 149.87,3.36 168.27,3.36 168.32,3.4 173.02,3.4 177.1,3.4 178,3.4 178.44,3.85 182.99,3.85 v2(183.44,4.3)
  IN6 w0.099: v2(242.36,44.1) 241.66,43.4 232.62,43.4 231.39,44.63 231.39,45.34 230.97,45.76 226.46,45.76 226.3,45.6 218.76,45.6 217.63,44.48 217.21,44.48 216.86,44.82 216.86,44.96 216.26,45.57 214.28,45.57 213.72,46.13 213.72,47.02 212.71,48.02 211.86,48.02 210.06,46.22 v2(210.06,45.47) 207.74,43.14 201.21,43.14 184.95,26.88 v2(184.95,26)
  BOTTOM w0.089: UH2.BF9 95.03,4.61 95.67,3.98 95.67,3.76 v2(95.66,3.75)
  BOTTOM w0.14: v2(183.44,4.3) 183.44,5.32 184.09,5.96 184.69,5.96 185.21,6.48 185.21,7.25 184.61,7.85 v2(184.61,9.08)
GPU_GC6_FB_EN_GPU: length 79.4
  TOP w0.14: v2(229.62,45.12) 229.29,44.79 QV105.2 ; RV566.1 212.83,42.72 213.49,43.38 213.49,44.88 212.4,45.98 212.4,46.77 v2(212.68,47.05) 212.68,47.1 212.2,47.58 211.77,47.58 DV13.3 ; v2(243.03,44.1) v1(243.03,45.56) 243.03,47.43 242.16,48.29 242.16,48.83 242.27,48.93 243.73,48.93 QV98.3 ; U33.6 203.47,50.1 203.37,50 203.37,49.64 203.7,49.32 v2(203.7,48.72)
  IN1 w0.099: v2(212.68,47.05) 212.68,47.06 212.68,47.35 212.25,47.78 212.25,50.78 213.07,51.6 213.07,59.53 v2(213.34,59.8)
  IN3 w0.091: v2(212.68,47.05) 212.68,47.26 211.84,48.1 207.95,48.1 207.46,47.61 205.54,47.61 204.42,48.72 v2(203.7,48.72)
  IN6 w0.099: v2(212.68,47.05) 212.68,46.59 214.3,44.97 215.89,44.97 216.6,44.25 217.76,44.25 217.93,44.42 225.69,44.42 226.83,45.56 229.18,45.56 v2(229.62,45.12) 230.06,45.56 230.77,45.56 231.08,45.25 231.08,44.58 232.53,43.14 242.07,43.14 v2(243.03,44.1)
  BOTTOM w0.14: v2(213.34,59.8) UV18.M3
GPU_GC6_FB_EN_GPU#: length 17
  TOP w0.14: QV105.1 229.95,44.34 229.95,42.37 v1(228.67,41.09) 222.61,41.09 221.87,41.83 221.87,42.55 220.75,43.66 220.75,45.06 221.16,45.47 221.54,45.47 RV1842.2 UV29.2
GPU_GPIO0: length 98.2
  IN2 w0.099: v2(181.84,93.09) 182.23,93.09 183.24,94.11 183.45,94.11 184.15,94.81 188.01,94.81 190.3,92.52 190.3,87.89 189.18,86.77 189.18,81.71 195.21,75.68 195.21,70.33 195.47,70.07 197.16,70.07 197.84,69.39 199.16,69.39 199.42,69.14 199.42,68.71 199.57,68.56 200.28,68.56 200.9,67.93 200.9,67.3 201.51,66.69 201.97,66.69 202.16,66.88 202.79,66.88 202.85,66.83 205.13,66.83 205.31,66.65 205.87,66.65 206.78,65.74 208.15,65.74 208.59,65.3 208.59,63.05 209.4,62.23 v2(210.82,62.23)
  IN6 w0.099: v2(164.86,118.58) 163.99,118.58 163.02,117.6 163.02,116.49 163.45,116.05 163.45,114.76 164.42,113.78 164.42,111.73 164.8,111.35 164.8,106.55 165.65,105.71 165.65,101.64 166.32,100.97 167.47,100.97 168.57,99.87 168.57,97.04 171.08,94.54 174.45,94.54 175.26,93.73 180.85,93.73 181.48,93.09 v2(181.84,93.09)
  BOTTOM w0.14: v2(210.82,62.23) 210.82,62.29 211.18,62.65 UV18.P6 ; RV1095.1 v2(164.86,118.58)
GPU_GPIO3: length 90.7
  IN2 w0.099: v2(183.88,112.23) 183.24,111.59 182.42,111.59 180.69,113.31 176.94,113.31 176.02,112.39 176.02,108.51 175.06,107.55 175.06,100.22 176.57,98.71 176.57,97.37 178.94,95 179.33,95 181.68,92.64 182.07,92.64 183.33,93.9 183.53,93.9 184.16,94.53 187.87,94.53 190.07,92.33 190.07,87.97 188.96,86.87 188.96,81.64 195.01,75.59 195.01,70.13 195.36,69.77 195.73,69.77 197,68.5 197,67.87 197.21,67.67 199.54,67.67 199.59,67.72 200.2,67.72 201.49,66.43 201.82,66.43 202.29,65.96 203.71,65.96 204.17,66.42 205.72,66.42 206.78,65.36 207.8,65.36 208.23,64.92 208.23,62.71 209.16,61.78 210.44,61.78 v2(210.82,61.41)
  BOTTOM w0.14: v2(210.82,61.41) 211.21,61.8 UV18.P5 ; RV1098.1 184.21,112.56 v2(183.88,112.23)
GPU_GPIO8: length 28.7
  TOP w0.14: v2(228.8,47.96) 228.99,47.77 RV1086.1 v1(230.03,47.15)
  IN6 w0.099: v2(213.34,60.58) 213.34,60.56 213.79,60.11 213.79,59.59 213.48,59.27 213.48,52.38 214.02,51.83 220.13,51.83 220.94,51.02 220.94,50.03 222.62,48.35 228.41,48.35 v2(228.8,47.96)
  BOTTOM w0.14: v2(213.34,60.58) 213.72,60.2 UV18.L3
GPU_GPIO21: length 4
  BOTTOM w0.14: UV18.P1 211.24,58 211.02,57.79 211.02,57.27 210.58,56.82 210.58,55.59 RV1840.1
GPU_GPIO22: length 2.1
  TOP w0.14: v2(211.83,63) 211.83,62.59 T4978.1
  BOTTOM w0.14: UV18.P8 211.68,63.86 211.68,63.16 v2(211.83,63)
GPU_GPIO25: length 1.5
  TOP w0.14: T4995.1 210.01,60.08 v2(210.01,60.59)
  BOTTOM w0.14: UV18.R4 210.42,61 v2(210.01,60.59)
GPU_GPIO26: length 1.4
  TOP w0.14: T4996.1 210.01,61.93 209.99,61.9 v2(209.99,61.37)
  BOTTOM w0.14: v2(209.99,61.37) 210.41,61.8 UV18.R5
GPU_ID: length 28.6
  TOP w0.076: v2(300.17,18.19) 300.56,17.8 UE3.J10
  TOP w0.14: v1(278.43,15.18) CE3319.1 278.43,13.29 RE301.2 278.49,13.24 279.17,13.24 v2(279.49,12.92)
  IN2 w0.099: v2(300.17,18.19) 299.77,17.8 299.15,17.8 298.85,17.5 298.85,16.25 298.43,15.83 295.17,15.83 294.79,16.2 293.86,16.2 292.82,17.24 290.63,17.24 290.4,17.46 289.31,17.46 288.27,16.43 287.36,16.43 286.87,15.94 285.97,15.94 283.62,13.59 282.38,13.59 281.71,12.92 v2(279.49,12.92)
GPU_JTAG_TCK: length 13.4
  BOTTOM w0.102: UV18.AM10 196.16,66.05 195.73,65.61 195.32,65.61 195.14,65.79 194.71,65.79 193.36,64.44 191.83,64.44 190.59,63.2 185.1,63.2 T201.1
GPU_JTAG_TDI: length 12.9
  BOTTOM w0.102: T202.1 186.53,62.98 190.79,62.98 191.96,64.15 193.87,64.15 194.52,64.8 195.56,64.8 195.81,65.05 195.81,65.29 196.08,65.57 196.28,65.57 196.61,65.9 196.61,66.53 UV18.AM11
GPU_JTAG_TDO: length 2.8
  BOTTOM w0.14: UV18.AP12 193.28,66.35 T203.1
GPU_JTAG_TMS: length 3.5
  BOTTOM w0.14: T204.1 191.89,65.16 192.9,65.16 UV18.AP11
GPU_JTAG_TRST#: length 9
  BOTTOM w0.102: UV18.AN11 194.93,66.39 194.93,66.3 193.39,64.76 189.64,64.76 RV593.1
  BOTTOM w0.14: v1(187.81,63.79) 188.67,63.79 RV593.1
GPU_LEVEL: length 12.2
  TOP w0.14: RV554.1 215.09,50.05 215.39,50.36 DV15.2 215.39,51.44 214.68,52.15 v1(214.68,54.92) 214.68,55.37 213.43,56.61 213.43,58.88 v2(212.51,59.8)
  BOTTOM w0.14: v2(212.51,59.8) 212.5,59.8 212.1,60.2 UV18.N3
GPU_MF_BALL_A: length 4.3
  BOTTOM w0.14: RV617.1 v1(224.02,106.13)
  BOTTOM w0.254: UV23.J1 227.21,104.88
  BOTTOM w0.508: RV617.1 225.95,106.13 227.21,104.88
GPU_MF_BALL_B: length 2.8
  TOP w0.102: RV618.1 215.6,105.54 215.05,106.08 v1(214.36,106.08)
  TOP w0.254: RV618.1 215.6,104.95 v2(215.65,104.9)
  BOTTOM w0.254: UV24.J1 215.58,104.9 v2(215.65,104.9)
GPU_MF_BALL_C: length 3.9
  TOP w0.14: v1(241.77,68.99) 242.18,68.58 242.18,68.2 RV631.1
  TOP w0.254: RV631.1 242.7,67.57 242.37,67.25 v2(241.94,67.25)
  BOTTOM w0.254: UV25.J1 242.28,67.25 v2(241.94,67.25)
GPU_MF_BALL_D: length 3.5
  BOTTOM w0.102: 242.92,80.27 UV26.J1
  BOTTOM w0.14: 242.92,80.27 242.92,78.13 RV630.1 v1(243.07,76.85)
GPU_PEX_RST_HOLD#: length 50.2
  TOP w0.14: RV563.1 220.84,48.2 220.47,47.83 v2(220.47,46.54)
  IN1 w0.099: v2(220.47,46.54) 219.67,46.54 218.85,45.72 216.94,45.72 216.74,45.51 213.36,45.51 212.64,46.24 211.64,46.24 210.98,46.91 210.98,47.38 209.92,48.44 209.92,49.1 205.87,53.15 202.12,53.15 200.85,54.42 199.33,54.42 197.93,55.82 197.55,55.82 v2(197.36,56.01)
  IN6 w0.099: v2(197.36,56.01) 197.49,56.01 197.62,56.15 197.62,59.36 199.86,61.6 203.54,61.6 203.86,61.92 205.25,61.92 205.6,61.57 207.68,61.57 208.48,62.36 208.48,63.25 v2(209.12,63.89)
  BOTTOM w0.14: UV18.T8 209.53,64.3 v2(209.12,63.89)
GPU_PSI: length 139.4
  IN2 w0.099: v2(162.92,101.6) 162.15,100.84 162.15,93.62 166.9,88.87 169.25,88.87 170.06,88.06 170.06,86.29 171.32,85.03 174.37,85.03 174.68,84.72 174.68,84.44 175.71,83.41 179.17,83.41 182.69,79.9 182.69,78.78 187.65,73.82 187.65,68.64 196.83,59.46 196.83,58.14 198.3,56.67 198.3,55.48 v2(197.93,55.12)
  IN3 w0.091: v2(162.92,101.6) 163.4,101.12 163.78,101.12 164.11,101.45 164.11,103.64 164.18,103.71 164.18,103.71 164.41,103.94 164.56,103.94 164.91,104.29 164.91,105.79 164.33,106.37 164.33,111.81 163.87,112.27 163.87,115.59 v2(163.92,115.64)
  IN4 w0.091: v2(163.92,115.64) 165.72,117.44 167.92,117.44 169.04,118.55 170.19,118.55 170.6,118.96 175.93,118.96 178.03,116.87 179.83,116.87 183.4,113.3 183.4,112.13 v2(184.02,111.51)
  IN6 w0.099: v2(197.93,55.12) 199.73,55.12 201.17,56.55 201.17,59.06 201.83,59.71 203.39,59.71 203.9,60.23 204.94,60.23 205.71,61 207.99,61 208.81,61.82 211.06,61.82 211.42,62.18 211.42,63.52 212.05,64.16 v2(212.05,65.49)
  BOTTOM w0.14: RV552.1 198.04,54.58 197.93,54.69 v2(197.93,55.12) ; v2(212.05,65.49) 212.54,65.01 212.54,63.94 212.94,63.55 UV18.M7 ; PR1001.2 v2(163.92,115.64) ; PR1501.2 188.06,111.9 187.96,111.8 184.95,111.8 184.66,111.51 v2(184.02,111.51)
GPU_PWR_LEVEL: length 110.5
  TOP w0.076: 297.04,20.83 297.04,19.69 UE3.E12
  TOP w0.14: DV15.1 215.08,52.92 215.08,53.32 v2(215.1,53.34) ; 297.04,20.83 297.04,20.87 v2(296.71,21.19) ; v1(297.55,27.26) 297.16,27.64 v2(297.16,27.64)
  IN1 w0.099: v2(215.1,53.34) 214.47,52.71 214.47,48.34 215.12,47.68 217.99,47.68 218.78,46.89 219.96,46.89 220.02,46.95 223.38,46.95 224.11,46.21 227.85,46.21 228.18,45.88 230.87,45.88 231.39,45.36 231.39,44.4 232.02,43.77 233.62,43.77 234.83,42.56 235.82,42.56 246.83,31.56 253.56,31.56 258.98,26.14 265.85,26.14 266.26,26.54 269.18,26.54 270.57,25.15 276.99,25.15 277.6,25.76 284.14,25.76 284.99,26.61 288.67,26.61 289.18,27.12 290.88,27.12 291.41,27.64 v2(297.16,27.64)
  BOTTOM w0.14: v2(297.16,27.64) 297.96,26.84 297.96,23.51 297.17,22.72 297.17,21.42 296.94,21.19 v2(296.71,21.19)
GPU_SMBCLK: length 122.9
  TOP w0.14: v2(212.19,44.78) 211.94,44.53 211.61,44.53 209.94,42.86 204.66,42.86 202.65,44.88 201.92,44.88 201.74,44.7 QV21.6 ; v2(280.99,21.86) v1(281.68,21.86) ; v2(289.74,14.99) 289.74,15.04 RE296.1 ; v2(297.76,14.97) UE3.F7
  IN2 w0.099: v2(212.19,44.78) 212.36,44.78 212.73,45.15 216.5,45.15 217.27,44.37 217.88,44.37 218.18,44.68 220.7,44.68 221.27,44.11 229.3,44.11 230.03,43.37 237.41,43.37 240.99,39.79 248.26,39.79 256.64,31.41 256.64,27.65 262.22,22.07 263.68,22.07 264.58,22.97 264.58,24.29 265.46,25.17 266.8,25.17 267.79,24.18 269.08,24.18 270.22,25.32 279.36,25.32 280.85,23.84 280.85,22.01 v2(280.99,21.86)
  IN6 w0.099: v2(289.74,14.99) 289.74,14.91 290.14,14.51 291.09,14.51 292.4,15.82 294.28,15.82 294.7,15.41 297.32,15.41 v2(297.76,14.97)
  BOTTOM w0.14: v2(280.99,21.86) 280.99,21.61 282.95,19.66 286.78,19.66 288.71,17.73 288.71,16.29 289.74,15.26 v2(289.74,14.99)
GPU_SMBDAT: length 122.9
  TOP w0.14: UE3.B6 294.62,14.23 293.27,14.23 292.6,13.55 290.6,13.55 290.04,14.12 v2(290.01,14.12) 289.86,14.12 289.28,13.54 RE295.1 ; v2(280.41,21.86) v1(280.41,22.39) ; QV21.3 200.28,46.1 200.28,45.38 200.52,45.14 200.98,45.14 201.32,45.48 202.53,45.48 204.8,43.21 209.8,43.21 211.46,44.87 211.49,44.87 211.57,44.96 v2(211.58,44.96)
  IN2 w0.099: v2(280.41,21.86) 280.54,21.99 280.54,23.72 279.24,25.02 270.34,25.02 269.2,23.88 267.67,23.88 266.68,24.87 265.59,24.87 264.88,24.17 264.88,22.85 263.81,21.77 262.09,21.77 256.34,27.52 256.34,31.28 248.13,39.49 240.87,39.49 237.29,43.07 229.91,43.07 229.17,43.81 221.15,43.81 220.58,44.37 218.31,44.37 218,44.07 217.15,44.07 216.37,44.84 212.85,44.84 212.36,44.35 212.01,44.35 211.58,44.78 v2(211.58,44.96)
  BOTTOM w0.14: v2(290.01,14.12) 289,14.12 288.37,14.75 288.37,17.59 286.64,19.32 282.78,19.32 280.41,21.69 v2(280.41,21.86)
GPU_VREFD_BALL_A: length 14.9
  TOP w0.102: TV3.1 234.79,110.1 v2(234.41,110.48)
  IN1 w0.508: v2(234.2,99.19) 233.5,99.89 233.5,106.62 233.24,106.88 233.24,108.65 233.62,109.03 233.62,110.05 234.05,110.48 v2(234.41,110.48)
  BOTTOM w0.14: v2(234.41,110.48) UV23.U10
  BOTTOM w0.254: v2(234.2,99.19) 234.35,99.04 234.35,98.54 UV23.A10
GPU_VREFD_BALL_B: length 15.4
  TOP w0.102: v2(208.38,111.14) 208.37,111.13 TV4.1
  IN4 w0.508: v2(208.38,111.14) 208.32,111.08 208.32,109.88 209.36,108.84 209.36,99.06 208.78,98.48 v2(208.35,98.48)
  BOTTOM w0.254: v2(208.38,111.14) 208.11,110.88 UV24.A10 ; UV24.U10 v2(208.35,98.48)
GPU_VREFD_BALL_C: length 15.3
  TOP w0.102: v2(248.92,59.8) 248.53,59.41 TV6.1
  IN4 w0.099: v2(236.19,59.02) 236.19,59.22 237.31,60.34 248.39,60.34 v2(248.92,59.8)
  BOTTOM w0.254: UV25.A10 236.52,59.35 v2(236.19,59.02) ; UV25.U10 v2(248.92,59.8)
GPU_VREFD_BALL_D: length 15.8
  TOP w0.102: v2(248.92,87.13) 249.26,87.48 250.02,87.48
  TOP w0.14: TV5.1 250.02,87.48
  IN4 w0.508: v2(248.92,87.13) 248.25,86.46 247.04,86.46 246.46,86.46 245.81,85.81 237.97,85.81 236.92,86.87 v2(236.92,87.13)
  BOTTOM w0.254: UV26.A10 v2(248.92,87.13) ; UV26.U10 v2(236.92,87.13)
GPU_ZQ_BALL_A: length 3.5
  TOP w0.102: v2(236.81,104.08) 236.81,103.99 237.11,103.7 v1(237.21,103.7) 237.33,103.81 238.84,103.81
  TOP w0.14: 238.84,103.81 238.91,103.81 RV619.1
  BOTTOM w0.107: UV23.J13 v2(236.81,104.08)
GPU_ZQ_BALL_B: length 5.4
  TOP w0.14: RV620.1 207.63,104.7 v2(208.39,103.94)
  IN4 w0.091: v2(208.39,103.94) 208.39,104.54 207.69,105.24 206.32,105.24 v2(205.95,104.88)
  BOTTOM w0.14: UV24.J13 v2(205.95,104.88)
GPU_ZQ_BALL_C: length 2.6
  TOP w0.102: RV633.1 241.89,56 242.13,56.24 v1(242.13,56.96) 242.13,57.06 v2(242.46,57.4)
  BOTTOM w0.102: UV25.J13 242.52,57.4 v2(242.46,57.4)
GPU_ZQ_BALL_D: length 2.6
  TOP w0.102: RV632.1 244.51,89.12 243.74,89.12 v2(243.32,89.54)
  BOTTOM w0.102: UV26.J13 v2(243.32,89.54)
H_CATERR#: length 10.2
  BOTTOM w0.076: 134.62,81.22 135.31,81.22 135.53,81.44 137.23,81.44 137.35,81.32 139.73,81.32 UH1.BM30
  BOTTOM w0.14: RH570.2 131.16,80.7 131.43,80.7 131.88,81.16 v1(133.14,81.16) 133.23,81.07 134.47,81.07 134.62,81.22
H_CPUPWRGD: length 113.3
  TOP w0.14: v2(132.76,82.26) v5(133.34,82.26)
  IN1 w0.099: v2(125.53,55.53) 125.53,55.78 125.99,56.25 128.96,56.25 131.03,58.31 131.03,62.23 129.15,64.1 129.15,65.59 128.67,66.07 128.67,77.68 132.76,81.77 v2(132.76,82.26)
  IN2 w0.089: 101.98,26.39 99.64,24.04 99.64,23.08 98.16,21.6 98.16,19.82 94.99,16.65 94.99,15.38 95.39,14.98 96.68,14.98 96.75,15.05 97.23,15.05 97.33,15.15 97.8,15.15 97.88,15.08 99.78,15.08 v2(100.15,15.44)
  IN2 w0.099: 101.98,26.39 102.04,26.44 102.11,26.44 102.54,26.87 105.29,26.87 107.1,28.68 109.58,28.68 110.48,27.77 121.62,27.77 122.2,28.36 122.2,34.14 119.82,36.52 119.82,43.72 125.53,49.43 v2(125.53,55.53)
  BOTTOM w0.076: 134.62,82.3 134.73,82.41 136.12,82.41 136.24,82.52 137.34,82.52 UH1.BT31
  BOTTOM w0.089: UH2.AE3 97.99,15.21 98.05,15.14 99.13,15.14 99.31,14.96 99.55,14.96 100.04,15.44 v2(100.15,15.44)
  BOTTOM w0.14: 134.62,82.3 134.52,82.2 132.82,82.2 v2(132.76,82.26)
H_DRAMRST#: length 100.8
  TOP w0.14: v2(139.38,7.65) 139.52,7.65 140.49,8.62 140.49,9.56 139.12,10.92 134.56,10.92 133.45,12.03 v1(133.45,14.05) 133.45,15.67 CD69.1 133.68,15.7 135.24,17.26 RD102.2 RD35.2
  IN6 w0.089: 74.51,6.4 74.56,6.4 75.9,5.05 75.9,4.38 76.89,3.4 78.33,3.4 79.18,4.24 79.52,4.24 79.8,3.96 80.44,3.96 81.03,4.55 81.33,4.55 81.69,4.19 81.69,3.09 82.33,2.45 85.77,2.45 86.21,2.89 88.1,2.89 88.75,2.24 95.06,2.24 96.05,3.23 97.21,3.23 98.53,1.91
  IN6 w0.099: v2(73.13,5.77) 73.13,6.09 73.44,6.4 74.51,6.4 ; v2(139.38,7.65) 139.67,7.36 139.89,7.36 140.26,6.99 140.26,3.43 138.39,1.56 125.18,1.56 124.43,2.32 117.32,2.32 116.56,1.56 98.87,1.56 98.53,1.91
  BOTTOM w0.089: 75.06,6.86 75.14,6.86 75.2,6.91 75.75,6.91 76.15,6.91 76.29,6.77 UH2.BB46
  BOTTOM w0.14: v2(73.13,5.77) 73.13,6.1 73.43,6.4 73.86,6.4 74.01,6.26 74.39,6.26 74.99,6.86 75.06,6.86
H_PECI: length 315.2
  TOP w0.14: RE48.2 304.17,26.42 304.1,26.48 v2(304.1,26.99)
  IN2 w0.089: v2(101.11,15.34) 101.57,15.8 101.98,15.8
  IN2 w0.099: 101.98,15.8 102.85,15.8 103.2,16.16 103.63,16.16 104.05,15.74 106.51,15.74 106.9,16.13 106.9,16.46 107.25,16.82 108.41,16.82 110.77,19.18 121.18,19.18 122.52,17.85 129.17,17.85 130.88,16.13 140.97,16.13 143.11,13.99 150.75,13.99 152.16,12.59 163.96,12.59 164.7,11.85 188.89,11.85 189.76,10.97 211.02,10.97 214.38,7.62 242.63,7.62 244.22,9.21 254.45,9.21 255.21,9.97 260.92,9.97 261.94,10.99 263.97,10.99 266.32,13.34 267.97,13.34 268.35,12.96 273.25,12.96 273.89,13.59 278.89,13.59 280.09,14.79 283.01,14.79 283.48,15.25 283.48,15.63 285.22,17.37 288.27,17.37 288.91,18.01 289.82,18.01 290.83,19.03 291.34,19.03 291.95,18.42 292.61,18.42 294.06,16.97 298.04,16.97 298.27,17.2 298.27,21.97 298.65,22.35 299.34,22.35 300.15,23.17 300.15,24.82 300.48,25.15 301.75,25.15 302.15,25.54 303.26,25.54 304.1,26.38 v2(304.1,26.99)
  IN4 w0.089: v2(101.11,15.34) 101.59,15.82 101.59,16.82 101.77,17 101.77,19.11 101.98,19.32
  IN4 w0.091: 101.98,19.32 103.88,21.22 104.78,21.22 105.16,21.59 105.16,22.86 104.88,23.13 104.88,26.7 106.41,28.23 106.41,32.29 108.81,34.69 108.81,36.11 112.92,40.21 112.92,41.12 113.55,41.76 117.72,41.76 126.87,50.91 126.87,56.72 124.45,59.15 124.45,61.86 129.54,66.95 129.54,79.08 131.36,80.89 131.36,82.53 132.2,83.38 v2(133.41,83.38)
  BOTTOM w0.089: v2(101.11,15.34) 101.47,14.98 RH539.2
  BOTTOM w0.14: RH190.1 132.72,84.67 132.72,83.71 132.84,83.59 133.2,83.59 v2(133.41,83.38)
H_PECI_R: length 4.4
  BOTTOM w0.14: UH1.BT34 137.2,83.68 135.37,83.68 134.93,84.12 RH200.1 134.3,84.44 RH190.2
H_PM_DOWN: length 109.9
  IN1 w0.099: v2(126.11,55.57) 129.97,55.57 131.49,57.09 131.49,63.2 129.69,65 129.69,65.78 129.08,66.39 129.08,77.52 133.17,81.61 133.17,82.48 132.04,83.61 129.64,83.61 v2(129.53,83.49)
  IN2 w0.089: v2(99.52,15.44) 99.51,15.43 95.46,15.43 95.32,15.57 95.32,16.47 98.88,20.04 98.88,21.67 99.37,22.15 99.92,22.15 100.41,22.63 101.1,22.63 101.98,23.52
  IN2 w0.099: 101.98,23.52 104.93,26.46 105.33,26.46 107,28.13 109.69,28.13 110.39,27.43 121.72,27.43 122.51,28.21 122.51,34.26 120.12,36.65 120.12,43.35 126.11,49.34 v2(126.11,55.57)
  BOTTOM w0.089: v2(99.52,15.44) 99.45,15.37 UH2.AE2
  BOTTOM w0.14: RH155.1 129.94,83.19 129.64,83.49 v2(129.53,83.49)
H_PM_DOWN_R: length 8
  BOTTOM w0.076: 134.62,82.7 136.57,82.7 136.59,82.69 137.94,82.69 137.98,82.73 138.46,82.73 UH1.BP31
  BOTTOM w0.14: RH155.2 131.63,82.75 132.89,82.75 133.09,82.55 133.88,82.55 v1(134.04,82.7) 134.62,82.7
H_PM_SYNC: length 4.3
  BOTTOM w0.089: UH2.AF3 98.17,14.94 99.02,14.94 99.17,14.78 100.04,14.78 101,15.75 RH189.1
H_PM_SYNC_R: length 104.8
  TOP w0.089: v2(136.1,84.3) 136.1,84.03 v5(135.57,83.5)
  TOP w0.14: v2(109.68,42.13) 109.83,41.97 109.83,39.13 107.82,37.12 107.82,29.57 105.67,27.41 105.67,26.45 108.09,24.03 108.09,23.16 108.44,22.81 108.44,20.98 109.88,19.54 109.88,17.76 v2(110.36,17.28)
  IN1 w0.099: v2(131.74,85.13) 131.53,84.92 129.27,84.92 128.58,84.23 128.58,83.31 129.07,82.82 129.07,80.37 127.34,78.63 127.34,65.94 123.45,62.05 123.45,59.44 121.66,57.65 121.66,56.24 120.07,54.65 120.07,47.4 116.55,43.88 114.34,43.88 113.63,43.17 110.84,43.17 109.79,42.13 v2(109.68,42.13)
  IN2 w0.089: v2(139.73,84.43) 139.36,84.07 136.33,84.07 v2(136.1,84.3)
  BOTTOM w0.076: UH1.BM34 140.05,84.1 v2(139.73,84.43)
  BOTTOM w0.14: RH189.2 102.66,15.75 103.3,15.11 103.65,15.11 104.24,15.7 106.5,15.7 107.5,16.7 107.93,16.7 108.44,17.22 110.3,17.22 v2(110.36,17.28) ; v2(136.1,84.3) 135.38,85.02 134.77,85.02 134.27,85.52 132.67,85.52 132.37,85.23 131.84,85.23 v2(131.74,85.13)
H_PROCHOT#: length 399.4
  TOP w0.14: RE96.2 300.03,23.9 299.88,24.05 299.88,26.02 299.29,26.61 299.29,27.08 299.15,27.22 298.16,27.22 297.84,26.9 297.26,26.9 296.67,27.49 295.79,27.49 v5(295.35,27.93) 294.58,28.7 294.58,29.91 293.78,30.71 291.97,30.71 291.37,30.11 290.22,30.11 288.13,28.01 288.13,27.26 287.43,26.56 286.4,26.56 285.67,27.3 v2(285.42,27.3) ; PR1919.1 54.93,18.04 55.4,18.51 55.4,18.87 57.08,20.55 60.83,20.55 61.3,21.02 61.3,23.6 59.21,25.69 51.91,25.69 50.04,27.56 50.04,30.95 51.87,32.79 51.87,33.79 v2(52.37,34.29)
  IN1 w0.099: v2(129.96,47.64) 128.95,48.64 125.41,48.64 121.83,52.22 v2(121.82,52.22) 121.82,52.75 122.71,53.64 122.71,57.43 123.96,58.68 123.96,61.97 127.77,65.78 127.77,78.08 129.51,79.82 v2(129.51,80.89)
  IN2 w0.099: v2(129.78,98.32) 130.09,98.32 131.57,96.83 131.57,96.15 133.08,94.64 133.08,93.87 131.55,92.35 130.4,92.35 128.02,89.97 128.02,85.62 129.11,84.53 129.11,83.1 129.51,82.69 v2(129.51,80.89) ; v2(121.82,52.22) 121.82,52.23 121.61,52.23 121.41,52.03 121.41,50.08 122.11,49.39 122.11,48.92 121.02,47.83 118.77,47.83 118.43,48.17 117.51,48.17 116.84,47.5 116.84,44.83 117.29,44.39 117.29,43.48 116.71,42.91 115.21,42.91 113.61,44.5 95.8,44.5 87.43,36.13 85.44,36.13 85.07,36.5 53.66,36.5 52.37,35.21 v2(52.37,34.29)
  IN3 w0.091: v2(129.78,98.32) 129.78,98.54 126.88,101.44 120.52,101.44 119.61,102.35 119.61,109.35 119.73,109.48 v2(119.97,109.48) ; v2(129.96,47.64) 130.14,47.49 157.31,30.21 162.47,25.61 162.47,25.02 162.47,21.29 162.92,20.84 183.15,20.84 183.67,20.32 201.18,20.32 202.64,18.86 227.33,18.86 228.16,19.69 249.81,19.69 250.95,20.83 254.16,20.83 254.38,21.04 256.16,21.04 256.55,20.66 260.03,20.66 260.42,21.05 268.18,21.05 268.59,21.46 277.52,21.46 283.36,27.3 v2(285.42,27.3)
  BOTTOM w0.14: v2(119.97,109.48) 119.81,109.32 PR1103.1 ; RH165.2 130.15,80.58 RH158.1 129.97,81.34 v2(129.51,80.89)
H_PROCHOT#_EC: length 2.4
  TOP w0.14: RE96.1 300.03,20.44 UE3.H13
H_PROCHOT#_R: length 8.4
  BOTTOM w0.076: 134.62,81.55 135.13,81.55 v1(135.4,81.81) 135.54,81.67 136.02,81.67 136.52,82.18 136.88,82.18 137.13,81.93 137.62,81.93 137.9,81.65 UH1.BR30
  BOTTOM w0.14: 134.62,81.55 131.74,81.55 131.39,81.9 131.17,81.9 130.73,81.46 RH158.2
H_THERMTRIP#: length 10.2
  BOTTOM w0.089: UH2.AD3 97.98,15.97 97.7,15.97 97.56,15.83 97.56,15.69 97.62,15.62 99.17,15.62 99.37,15.83 99.72,15.83 99.83,15.93 99.83,16.03 99.93,16.13 100.08,16.13 100.18,16.03 100.18,15.93 100.29,15.83 100.62,15.83 101.11,16.31 101.16,16.31 101.27,16.41 101.27,16.61 101.11,16.77 101.11,16.91 101.21,17.02 101.52,17.02 101.62,16.91 101.62,16.62 101.73,16.51 101.93,16.51 101.98,16.56
  BOTTOM w0.14: 101.98,16.56 RH191.1 102.92,17.5 104.11,17.5 v1(104.59,17.02)
H_THERMTRIP#_R: length 313.8
  TOP w0.14: v2(301.31,4.23) 301.31,3.76 QE10.3
  TOP w0.254: v2(172.7,82.65) 172.51,82.46 RH163.2
  IN2 w0.089: v2(172.7,82.65) 173.14,83.09 173.14,84.16 173.31,84.34 173.78,84.34 173.98,84.14 173.98,83.43 174.76,82.65 177.36,82.65 178.09,81.92 179.11,81.92 179.56,82.38 179.78,82.38 179.9,82.26
  IN2 w0.099: 179.9,82.26 181.94,80.22 181.94,78.37 186.8,73.51 186.8,68.98 193.17,62.61 193.17,60.58 v2(192.72,60.14) 193.68,59.18 195.36,59.18 197.99,56.55 197.99,55.75 197.52,55.28 197.52,54.95 198.09,54.38 200.16,54.38 200.39,54.16 201.81,54.16 205.34,50.63 205.34,49.9 205.88,49.35 206.31,49.35 206.54,49.12 206.54,48.71 206.43,48.59 206.43,48.34 208.26,46.5 209.81,46.5 211.15,45.16 211.15,44.78 211.88,44.05 212.48,44.05 212.96,44.53 216.25,44.53 217.02,43.76 218.13,43.76 218.43,44.06 220.46,44.06 221.03,43.5 228.84,43.5 229.62,42.72 237.2,42.72 240.8,39.12 247.52,39.12 253.34,33.3 253.34,29.62 261.56,21.4 264.16,21.4 265.55,22.79 267.08,22.79 267.73,23.44 269.29,23.44 270.38,24.54 273.39,24.54 v2(274.69,23.23)
  IN3 w0.091: v2(287.57,4.1) 287.96,4.49 294.58,4.49 294.84,4.23 296.93,4.23 297.15,4.45 298.7,4.45 298.99,4.17 301.25,4.17 v2(301.31,4.23)
  IN6 w0.099: v2(103.43,15.59) 106.37,15.59 106.88,15.08 108.24,15.08 108.72,15.57 108.72,16.88 110.94,19.1 171.2,19.1 171.88,19.78 175.5,19.78 v2(175.58,19.7)
  BOTTOM w0.076: UH1.J31 173.03,82.31 v2(172.7,82.65)
  BOTTOM w0.14: v2(175.58,19.7) 175.58,20.45 176.47,21.34 176.47,27.12 177.82,28.47 177.82,38.37 191.39,51.94 191.39,58.8 v2(192.72,60.14) ; v2(287.57,4.1) 287.1,4.56 281.45,4.56 280.67,5.34 280.67,13.21 279.91,13.97 279.91,18.02 278.06,19.87 278.06,22.72 277.11,23.67 275.13,23.67 v2(274.69,23.23) ; v2(103.43,15.59) 103.43,15.95 103.35,16.03 RH191.2
H_VCCST_PWRGD: length 124.7
  TOP w0.14: RH482.1 130.9,90.55 131.91,89.54 v2(131.91,87.93) ; v2(182.32,64.01) 182.32,63.88 181.62,63.18 RH164.2 RH154.1 ; UE7.4 123.32,62.69 v1(123.32,60.33) 122.89,59.9 v2(122.49,59.9)
  IN1 w0.099: v2(122.49,59.9) 122.58,59.9 122.93,60.25 122.93,62.13 126.93,66.13 126.93,78.65 128.6,80.32 128.6,82.78 128.21,83.17 128.21,84.32 129.12,85.23 129.12,85.69 129.54,86.1 130.37,86.1 130.57,85.9 131.11,85.9 131.74,86.53 131.74,87.76 v2(131.91,87.93)
  IN4 w0.089: 179.46,89.73 179.9,89.29 179.9,87.44
  IN4 w0.091: 179.9,87.44 181.06,86.28 181.06,81.97 182.82,80.21 182.82,76.45 181.88,75.5 181.88,65.04 182.17,64.74 182.17,64.15 v2(182.32,64.01) ; v2(178.59,90.62) 178.91,90.62 179.46,90.06 179.46,89.73
  IN6 w0.099: v2(131.91,87.93) 131.47,88.36 131.47,90.86 133.84,93.23 165.01,93.23 165.8,92.43 174.65,92.43 175.91,91.17 177.66,91.17 178.22,90.62 v2(178.59,90.62)
H_VCCST_PWRGD_GATE: length 6.1
  TOP w0.14: v1(123.5,58) 123.5,58.26 RZ82.2 121.94,59.2 v2(121.83,59.31) 121.54,59.6 UZ19.4 121.54,60.45 122.18,61.09 UE7.2
  BOTTOM w0.14: v2(121.83,59.31) 121.81,59.3 RZ1957.2 121.18,59.31 RZ1955.2
HD_SOC_SEL: length 4.1
  BOTTOM w0.108: RA15.2 11.13,33.69 RA16.2 10.03,33.76 10.03,33.87 9.79,34.12 9.79,34.18 9.24,34.73 UA1.6
  BOTTOM w0.14: v1(12.18,33.9) 12.03,33.74 RA15.2
HDA_BITCLK: length 17.2
  BOTTOM w0.089: 101.98,1.91 95.7,1.91 94.95,2.66 94.95,3.39 94.13,4.2 94.13,5.44 94.26,5.56 94.26,5.97 93.93,6.3 UH2.BD11
  BOTTOM w0.14: RP15.3 104.58,3.17 CH50.2 v1(104.67,2.24) 104.34,1.91 101.98,1.91
HDA_BITCLK_AUDIO: length 146.5
  IN6 w0.089: 101.98,8.56 98.65,8.56 97.92,9.3 96.67,9.3 96.62,9.24 95.93,9.24 95.75,9.42 95.12,9.42 94.31,8.61 93.91,8.61 93.82,8.52 93.82,8.09 93.73,8 93.56,8 93.47,8.09 93.47,8.52 93.1,8.89 91.82,8.89 90.95,8.01 90.95,7.85 89.58,6.48 88.84,6.48 88.71,6.61 88.32,6.61 87.94,6.99 87.94,10.51 86.21,12.23 85.18,12.23 84.47,11.52 83.05,11.52 82.88,11.69 80.18,11.69 79.81,12.06 78.03,12.06 77.84,11.87 76.59,11.87 76.3,12.17 76.3,13.4 75.89,13.81 75.89,15.36 74.47,16.78 73.97,16.78 73.26,17.48
  IN6 w0.099: v2(5.67,34.04) 5.36,33.73 4.76,33.73 4.63,33.86 4.63,35.08 4.8,35.24 6.69,35.24 6.79,35.34 6.79,35.65 6.66,35.77 4.62,35.77 4.48,35.91 4.48,36.05 4.64,36.21 10.89,36.21 11.28,36.6 11.56,36.6 12.13,36.03 12.71,36.03 13.75,34.99 13.75,32.92 15.3,31.37 15.3,30.79 17.26,28.83 17.26,28.56 21.35,24.46 25.42,24.46 30.61,19.28 36.75,19.28 37.75,20.27 41.86,20.27 45.51,23.92 50.2,23.92 50.46,23.67 51.67,23.67 52,23.34 56.12,23.34 57.45,22.01 61.2,22.01 61.63,21.58 64.28,21.58 64.56,21.3 69.26,21.3 72,18.56 72,18.33 72.69,17.65 73.1,17.65 73.26,17.48 ; v2(107.11,8.81) 106.49,8.81 105.63,7.95 102.9,7.95 102.29,8.56 101.98,8.56
  BOTTOM w0.14: v2(107.11,8.81) v1(106.13,8.81) 105.46,8.81 103.66,7.01 103.66,5.73 103.76,5.63 104.27,5.63 104.58,5.94 RP15.6 ; CA120.2 CA33.1 5.23,33.48 5.67,33.91 v2(5.67,34.04) 5.67,34.1 6.44,34.88 UA1.13
