# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDS_SENSE_VGA: length 4.3
  BOTTOM w0.203: UV18.U2 208.34,59.01 208.34,58.43
  BOTTOM w0.254: PR1517.1 206.57,56.23 208.34,58 208.34,58.43
V1N: length 34.7
  IN1 w0.254: v2(126.52,98.96) 126.9,98.96 127.66,99.72 133.41,99.72 136.82,96.31 138.91,96.31 140.36,97.76 140.36,99.59 142.63,101.85 142.63,106.91 144.15,108.43 145.44,108.43 v2(145.54,108.33)
  BOTTOM w0.254: PR1219.2 145.54,107.46 v2(145.54,108.33) ; PR1212.1 PR1213.1 125.85,99.32 126.2,98.96 v2(126.52,98.96) 126.56,98.96 126.74,98.78 127.76,98.78 PR1203.2
V2N: length 58.9
  IN1 w0.254: v2(152.98,107.95) 152.78,108.15 152.21,108.15 151.37,109 147.61,109 146.89,108.28 146.89,106.66 144.63,104.39 144.63,101.07 143.89,100.34 143.89,95.76 143.06,94.92 135.84,94.92 133.1,97.66 131.17,97.66 130,98.83 128.8,98.83 128.04,98.07 126.04,98.07 125.1,99.01 125.1,100.73 126.24,101.88 127.28,101.88 128.19,102.79 129.39,102.79 129.67,102.52 129.67,101.86 128.75,100.94 126.88,100.94 v2(126.85,100.91)
  BOTTOM w0.14: v1(125.34,103.19) 125.73,102.79 PR1214.1
  BOTTOM w0.254: PR1221.2 152.98,107.95 v2(152.98,107.95) ; PR1214.1 PR1215.1 125.74,101.21 126.54,101.21 v2(126.85,100.91) 126.92,100.84 127.66,100.84 PR1207.2
V3N: length 56
  IN1 w0.254: v2(146.52,97.38) 146.32,97.18 146.32,95.9 143.89,93.47 134.49,93.47 132.59,95.38 128.88,95.38 127.18,97.08 126.45,97.08 126.13,96.75 v2(126.13,96.58)
  IN2 w0.254: v2(146.52,97.38) 146.27,97.64 146.27,99.72 146.86,100.32 146.86,108.61 147.55,109.3 154.2,109.3 155.5,108 159.92,108 160.11,107.81 v2(160.11,107.75)
  BOTTOM w0.254: PR1217.1 PR1216.1 126.13,96.81 v2(126.13,96.58) 126.13,96.38 126.44,96.06 127.57,96.06 128.07,96.56 PR1211.2 ; v2(160.11,107.75) PR1223.2
VBAT1_ISL88738: length 9.3
  TOP w0.14: PR1938.2 v1(42.69,22.3)
  TOP w0.203: PU1900.31 47.91,17.89 47.73,18.07 44.87,18.07 43.94,19 43.94,19.74 43.71,19.97 43.1,19.97 PC1945.2 PR1938.2
VBATT: length 12.2
  TOP w0.508: v2(31.14,17.88) 31.14,18.14 31.98,18.97 38.62,18.97 v1(39.54,19.9) 40.86,21.21 PR1938.1
VBUS1_ECOK: length 317.7
  TOP w0.076: 298.16,20.83 298.26,20.73 298.26,20.46 298.16,20.36 UE3.F13
  TOP w0.14: PR241.1 16.38,27.13 PR239.1 16.48,26.42 16.98,25.91 v2(17.04,25.91) ; v2(297.84,21.18) 297.84,21.15 298.16,20.83 298.16,20.83
  IN1 w0.099: v2(17.04,25.91) 17.36,25.91 21.75,21.52 21.75,20.82 23.38,19.18 30.42,19.18 32.18,17.42 43.43,17.42 44.41,18.4 44.41,20 44.94,20.53 46.51,20.53 47.03,20.01 51.85,20.01 52.67,20.83 54.85,20.83 56.17,19.51 56.17,18.62 v2(57.06,17.73)
  IN5 w0.099: v2(297.84,21.18) 297.24,21.78 297.24,22.15 296.88,22.52 295.11,22.52 294.18,21.58 293.7,21.58 292.59,20.47 288.95,20.47 288.33,19.85 288.33,19.21 287.05,17.93 276.12,17.93 274.78,16.59 267.63,16.59 265.28,14.24 263.08,14.24 262.78,14.54 257.03,14.54 256.45,13.96 253.01,13.96 252.15,14.82 250.72,14.82 248.6,16.95 215.47,16.95 215.09,17.33 203.13,17.33 202.76,17.7 180.45,17.7 177.1,14.35 164.63,14.35 164.17,14.82 145.1,14.82 143.98,13.7 140.25,13.7 139.7,13.15 132.38,13.15 131.98,12.75 122.99,12.75 121.63,11.39 115.69,11.39 115.24,10.94 113.64,10.94 113.33,10.63 112.29,10.63 111.36,9.69 108.27,9.69 108.09,9.51 106.82,9.51 105.93,8.62 104.41,8.62 103.46,9.58 101.4,9.58 100.85,9.03 99.36,9.03 98.76,9.63 97,9.63 96.57,10.06 95.17,10.06 95.16,10.04 95,10.04 94.96,10.08 92.81,10.08 92.18,9.45 89.59,9.45 89.1,8.97 87.77,8.97 86.28,10.45 85.17,10.45 85.07,10.35 81.3,10.35 81.08,10.57 80.32,10.57 80,10.89 78.66,10.89 78,10.23 77.72,10.23 77.5,10.02 76.8,10.02 75.46,11.35 75.46,12.38 75.19,12.65 74.16,12.65 73.46,13.35 72.03,13.35 71.38,12.7 69.48,12.7 68.73,11.95 67.53,11.95 65.85,10.27 63.67,10.27 61.36,12.58 61.36,12.81 61.66,13.11 62.08,13.11 62.24,13.27 62.24,16.52 61.92,16.84 61.92,17.93 61.48,18.37 57.69,18.37 v2(57.06,17.73)
  BOTTOM w0.14: PR269.1 56.72,17.4 v2(57.06,17.73)
VBUS2_ECOK: length 323
  TOP w0.076: 295.02,20.83 295.02,20.58 295.44,20.17 UE3.C13
  TOP w0.14: v2(11.71,23.83) 11.71,23.77 PR213.2 12.32,23.19 PR217.1 ; 295.02,20.83 295.02,21.49 v2(295.43,21.9)
  IN2 w0.099: v2(59.06,13.16) 59.54,13.64 59.54,15.6 58.73,16.41 57.34,16.41 56.26,17.49 56.26,20.12 55.6,20.78 52.68,20.78 52.16,20.26 46.69,20.26 v2(46.22,19.79)
  IN5 w0.089: 101.98,8.38 100.35,8.38
  IN5 w0.099: v2(295.43,21.9) 295.02,21.49 295.02,21.4 294.96,21.33 294.96,21.15 293.87,20.07 291.14,20.07 289.38,18.31 288,18.31 287.21,17.52 276.34,17.52 274.97,16.16 267.79,16.16 265.47,13.84 262.91,13.84 262.61,14.14 257.2,14.14 256.62,13.56 252.74,13.56 251.91,14.38 248.94,14.38 246.8,16.52 215.33,16.52 214.92,16.93 202.97,16.93 202.6,17.3 180.61,17.3 177.27,13.95 164.46,13.95 164.04,14.38 145.23,14.38 144.14,13.3 140.41,13.3 139.86,12.75 132.82,12.75 132.24,12.17 124.97,12.17 124.11,11.32 122.38,11.32 121.92,10.86 118.53,10.86 117.9,10.23 112.46,10.23 111.53,9.29 108.9,9.29 107.53,7.93 102.54,7.93 102.08,8.38 101.98,8.38 ; v2(59.06,13.16) 59.46,12.75 60.62,12.75 63.5,9.87 67.76,9.87 68.67,10.78 70.65,10.78 70.89,11.02 70.89,11.64 72.17,12.92 73.35,12.92 77.5,8.77 77.73,8.77 77.97,9.01 78.64,9.01 79.1,8.56 79.78,8.56 80.06,8.84 80.06,9.07 80.48,9.49 81.08,9.49 81.36,9.77 84.41,9.77 85.07,9.11 85.07,8.4 85.22,8.26 86.25,8.26 86.59,8.59 89.19,8.59 89.58,8.21 90.72,8.21 91.26,8.74 94.83,8.74 95.06,8.51 96.11,8.51 96.71,9.11 97.69,9.11 98.42,8.38 100.35,8.38
  IN6 w0.099: v2(46.22,19.79) 46.22,19.1 44.74,17.62 32.85,17.62 32.44,17.22 30.94,17.22 29.96,18.2 16.54,18.2 14.85,19.89 14.85,22.07 13.6,23.32 12.19,23.32 11.71,23.8 v2(11.71,23.83)
  BOTTOM w0.14: v2(59.06,13.16) 59.06,12.81 58.88,12.62 58.12,12.62 58.07,12.57 56.19,12.57 55.88,12.88 PR268.1
VCC0V9_LVR_OUT: length 1.6
  IN2 w0.254: v2(24.11,37.61) v2(24.76,37.61)
  BOTTOM w0.203: UT1.H18 25.06,37.3 v2(24.76,37.61) ; UT1.F18 24.4,37.3 24.11,37.59 v2(24.11,37.61)
  vias: v1(24.39,38.28) v2(25.4,40.22) v2(26.05,40.23)
VCC0V9_SVR:
  vias: v1(23.41,40.3) v2(21.9,46.2) v2(22.48,46.36) v2(22.47,45.77) v2(24.11,40.22) v2(24.11,39.57) v2(24.11,38.92) v2(26.06,40.87) v2(26.71,40.87)
VCC1V8A_TBTA_LDO: length 2
  BOTTOM w0.203: CT151.1 19.23,61.09 19.76,60.55 19.98,60.55 20.61,59.92 UT4.K1
VCC1V8D_TBTA_LDO: length 2
  BOTTOM w0.14: 21.11,54.71 21.11,53.75 CT152.1
  BOTTOM w0.152: UT4.A2 21.11,54.71
VCC3V3_FLASH: length 64.6
  TOP w0.127: v1(48.57,29.3) RT171.1
  TOP w0.356: 20.93,61.92 19.75,61.92 19.42,61.59 RT432.1
  TOP w0.508: v2(19.79,58.73) 19.81,58.75 CT146.1 20.66,58.97 RT226.1 20.66,60.29 21.14,60.77 21.14,61.71 20.93,61.92 21.41,62.4 RT1093.1 23.56,62.4 24.03,61.93 24.03,61.58 24.25,61.37 ; RT243.1 42.94,30.96 43.3,30.61 45.09,30.61 45.92,29.77 UT5.8 46.68,29.3 RT171.1 47.5,29.95 47,30.44 v2(47,30.79)
  IN3 w0.483: v2(22.45,52.53) 22.4,52.53 20.98,53.96 20.98,58.25 20.5,58.73 v2(19.79,58.73)
  IN5 w0.508: v2(29.15,58.9) 28.93,58.69 28.93,57.18 29.85,56.26 29.85,53.34 30.74,52.45 31.24,52.45 31.62,52.07 32.51,50.29 34.55,46.99 35.05,46.36 37.72,43.31 40.95,40.27 44.42,38.18 45.01,37.59 45.01,36.28 46,35.29 46,32.11 47,31.1 v2(47,30.79)
  BOTTOM w0.254: RT168.1 21.85,52.86 22.18,52.53 v2(22.45,52.53) 22.45,52.81 22.48,52.83 RT169.1 ; v2(19.79,58.73) 19.82,58.73 20.03,58.52 20.47,58.52 UT4.G1
VCC3V3_TBT_SX: length 1.4
  TOP w0.152: CT145.1 21.83,59.5 v2(21.67,59.34)
  BOTTOM w0.152: v2(21.67,59.34) 21.2,58.88 UT4.H2
VCC5V0_SYS: length 7.2
  TOP w0.127: v2(27.69,54.74) v1(28.3,54.74)
  IN3 w0.508: v2(24.61,58.83) 24.99,58.83 25.4,58.42 25.4,56.14 26.8,54.74 v2(27.69,54.74)
  BOTTOM w0.203: UT4.H10 25.11,58.87 24.66,58.87 24.63,58.83 v2(24.61,58.83)
VCC_3V3_PCIE: length 1.1
  TOP w0.254: v2(26.06,37.62) 25.98,37.54 CT99.1
  BOTTOM w0.254: UT1.L16 v2(26.06,37.62)
VCC_3V3_USB2: length 1.1
  TOP w0.254: CT100.1 25.95,38.16 v2(26.06,38.27)
  BOTTOM w0.254: UT1.J16 v2(26.06,38.27)
VCC_SENSE: length 36.1
  IN6 w0.254: v2(117.26,99.38) 117.26,100.23 117.62,100.59 119.66,100.59 120.32,101.25 124.98,101.25 125.27,101.54 127.56,101.54 127.84,101.26 130.85,101.26 131.13,101.54 133.87,101.54 135.03,100.38 135.03,98.05 136.78,96.3 140.01,96.3 v2(142.1,98.39)
  BOTTOM w0.254: RH198.2 140.73,96.28 141.9,97.45 141.9,98.18 v2(142.1,98.39) ; PR1142.1 PC1130.2 116.59,99.21 117.09,99.21 v2(117.26,99.38)
VCC_SENSE_R: length 26
  BOTTOM w0.254: RH197.2 139.74,95.38 RH198.1 139.72,94.97 140.36,94.34 150.82,94.34 154.87,90.29 157.69,90.29 v1(158.62,89.36) 159.32,88.65 159.32,86.59 UH1.AG37
VCCDSW_EN: length 4
  TOP w0.076: 304.29,15.65 303.25,15.65 UE3.M7
  TOP w0.14: 304.29,15.65 305.66,15.65 306.1,16.09 RH5869.2
VCCDSW_EN_GPIO: length 199.7
  TOP w0.14: RH5869.1 307.07,16.7 v2(307.25,16.52) ; RH5867.1 136.21,15.13 QE20.2 138.87,15.13 140.69,16.96 143.19,16.96 143.64,16.51 143.64,15.18 v2(143.77,15.05) ; v2(273.57,4.67) 273.57,3.62 272.99,3.04 267.83,3.04 267.58,3.29 267.58,3.9 266.12,5.36 264.88,5.36 264.19,4.68 258.11,4.68 256.75,3.32 252.99,3.32 252.66,3.65 252.66,5.3 250.95,7 250.95,9.78 250.25,10.48 DI16.2 248.44,11.12 246.73,12.83 241.3,12.83 v1(241.17,12.96) 241.05,13.08 v2(241.05,13.97)
  IN2 w0.099: v2(143.77,15.05) 151.3,15.05 152.25,14.1 231.73,14.1 232.36,13.46 240.54,13.46 v2(241.05,13.97)
  IN3 w0.091: v2(273.57,4.67) 273.63,4.73 287.02,4.73 287.27,4.98 294.78,4.98 295.03,4.73 296.65,4.73 296.86,4.94 298.12,4.94 298.66,5.48 299.29,5.48 299.94,4.83 302.09,4.83 302.3,4.63 306.38,4.63 306.71,4.95 306.71,11.61 305.49,12.83 305.49,14.28 307.07,15.85 307.07,16.13 307.28,16.34 307.28,16.52 v2(307.25,16.52)
VCCDSW_EN_Q: length 3.2
  TOP w0.14: DI16.1 DI15.2 246.74,8.68 246.56,8.5 RH5870.2 245.85,8.26 v1(245.72,8.13)
VCCGT_B+:
  vias: v2(105.45,76.71) v2(105.39,75.78) v2(105.39,74.43) v2(105.46,77.43) v2(105.92,77.84) v2(105.92,77.09) v2(105.93,76.39) v2(106.08,86.15) v2(106.08,85.51) v2(106.08,84.88) v2(106.08,84.24) v2(106.15,83.65) v2(106.15,82.31) v2(106.13,71.32) v2(106.18,70.71) v2(106.4,75.78) v2(106.4,74.43) v2(106.71,86.23) v2(106.7,71.03) v2(106.71,70.45) v2(107.17,83.65) v2(107.17,82.31) v2(107.29,70.45) v5(104.45,82.36)
VCCGT_SENSE: length 63.6
  TOP w0.254: v2(109.73,104.2) PR1113.1 PC1106.1
  IN6 w0.254: v2(141.73,96.52) 141.85,96.41 141.85,95.71 141.44,95.3 135.84,95.3 134.11,97.03 134.11,98.93 132.69,100.36 130.77,100.36 130.53,100.12 128.76,100.12 127.11,98.46 126.07,98.46 124.99,99.54 123.15,99.54 121.94,98.33 120.69,98.33 120.41,98.62 116.92,98.62 114.56,100.98 110.95,100.98 110.43,101.5 110.43,102.63 109.06,104.01 109.06,104.94 109.39,105.27 110.21,105.27 110.5,104.98 110.5,104.65 110.06,104.2 v2(109.73,104.2)
  BOTTOM w0.254: v2(141.73,96.52) 141.73,96.31 142.08,95.96 142.55,95.96 143.31,96.72 143.31,98.58 142.32,99.57 140.9,99.57 140.21,98.88 140.21,98.65 139.58,98.03 137.61,98.03 136.35,96.77 134.5,96.77 134.04,96.31 RH471.2 RH203.2
VCCGT_SENSE_R: length 29.2
  BOTTOM w0.254: UH1.AH38 158.15,86.86 158.05,86.75 157.86,86.75 157.76,86.86 157.76,87.12 158.15,87.52 158.15,87.71 156.84,89.03 154.74,89.03 v1(154.59,88.88) 154.43,89.03 153.4,89.03 149.77,92.67 135.99,92.67 135.64,93.02 135.61,93.02 134.21,94.41 134.21,95.05 RH471.1
VCCIO_EN: length 19.6
  TOP w0.14: RZ1965.2 v2(106.25,50.69) 106.24,50.69 v1(105.84,50.29)
  IN4 w0.091: v2(106.25,50.69) 106.25,53.96 105.35,54.87 105.35,59.25 104.97,59.63 104.97,62.87 105.73,63.63 v2(106.05,63.63)
  BOTTOM w0.254: PU800.11 107.04,63.52 106.94,63.63 v2(106.05,63.63) 105.97,63.7 105.05,63.7 PC811.1 PR804.1 PR1951.2
VCCIO_PG: length 1.2
  TOP w0.14: PT202.1 103.89,62.88 PR851.2
VCCIO_SENSE: length 79.9
  TOP w0.254: v2(105.06,66.42) 108.33,66.42 108.63,66.72 109.26,66.72 109.68,67.15 115.19,67.15 117.92,64.42 123.92,64.42 125.49,65.99 v5(127.51,65.99) 128.94,65.99 129.52,65.41 130.18,65.41 v2(130.2,65.43)
  TOP w0.305: v2(173.12,68.86) 173.16,68.9 173.16,69.7 172.85,70.01 171.85,70.01 170.76,71.1 v2(170.76,71.75)
  IN6 w0.254: v2(170.76,71.75) 170.35,71.35 169.93,71.35 169.32,71.96 158.52,71.96 157.87,72.61 157.87,73.37 157.58,73.66 154.69,73.66 153.87,72.85 153.29,72.85 153.06,72.62 142.13,72.62 140.35,70.84 133.64,70.84 131.48,68.67 131.48,67.5 130.2,66.22 v2(130.2,65.43)
  BOTTOM w0.254: v2(173.12,68.86) 173.48,69.22 UH1.H14 ; PR806.2 v2(105.06,66.42)
VCCMPHY_SENSE: length 8.1
  BOTTOM w0.089: 75.06,23.06 75.24,23.06 75.57,22.73 76.33,22.73 76.4,22.66 UH2.K47
  BOTTOM w0.14: 75.06,23.06 74.63,23.06 74.6,23.09 71.34,23.09 70.83,23.6 70.73,23.6 T4943.1
VCCSA_SENSE: length 12.8
  TOP w0.14: PC1118.2 124.91,106.76
  TOP w0.254: 124.91,106.76 v2(124.22,106.76)
  IN3 w0.254: v2(124.22,106.76) 124.59,106.76 126.47,108.63 133.18,108.63 v2(133.77,108.04)
  BOTTOM w0.254: v2(133.77,108.04) 134.06,108.04 134.4,107.7 RH202.2 ; PR1128.2 124.21,106.74 v2(124.22,106.76)
VCCSA_SENSE_R: length 55.3
  IN4 w0.254: v2(168.2,87.45) 168.2,87.57 169.17,88.54 169.17,91.76 168.19,92.74 v2(168.19,93.1)
  IN6 w0.254: v2(168.19,93.1) 168.19,93.84 167.95,94.08 147.79,94.08 142.12,99.75 137.52,99.75 135.21,102.05 135.21,105.24 134.28,106.18 v2(133.77,106.18)
  BOTTOM w0.14: v1(135.41,106.79) RH202.1
  BOTTOM w0.254: UH1.M38 170.75,87.23 169.84,88.14 168.85,88.14 168.2,87.49 v2(168.2,87.45) ; RH202.1 134.11,106.79 133.77,106.45 v2(133.77,106.18) 133.77,105.96 134.17,105.56 RH201.1
VCCSENSE_VGA: length 116
  IN2 w0.254: v2(173.51,116) 173.38,116 171.96,114.58 171.96,112.1 171.17,111.3 166.15,111.3 164.49,109.64 164.49,107.07 165.67,105.89 165.67,101.69 163.63,99.65 163.63,94.97 164.68,93.92 168.86,93.92 v2(169.67,93.1) ; v2(214.18,61.4) 214.28,61.3 214.28,59.41 214.28,59.39 213.99,59.11 213.3,58.42 213.3,55.52 210.73,52.96 206.6,52.96 203,56.55 201.85,56.55 200.8,57.61 200.8,60.35 198.84,62.31 197.71,62.31 191.17,68.84 191.17,76.41 184.74,82.85 184.74,86.04 182.02,88.76 182.02,89.54 181.42,90.14 180.45,90.14 177.67,92.91 v2(177.67,93.09)
  IN4 w0.254: v2(177.67,93.09) 177.35,93.09 176.43,94.02 174.39,94.02 173.6,94.81 170.72,94.81 169.98,94.07 169.98,93.41 v2(169.67,93.1)
  BOTTOM w0.152: v2(173.51,116) v1(174.09,116)
  BOTTOM w0.203: v2(214.18,61.4) 213.78,61 UV18.L4
  BOTTOM w0.254: v2(173.51,116) 173.07,116.44 PR1021.1
VCCST_PWRGD: length 255.9
  TOP w0.14: RE306.2 v2(311.05,24.61) ; v2(312.45,29.16) 312.65,29.36 312.65,30.25 313.32,30.93 313.32,31.27 311.28,33.31 v2(303.31,33.31)
  IN3 w0.091: v2(311.05,24.61) 311.91,25.47 311.91,26.7 311.33,27.28 311.1,27.28 310.88,27.5 310.88,28.13 311.91,29.16 v2(312.45,29.16)
  IN5 w0.099: v2(183.32,64.01) 183.98,64.67 191.13,64.67 191.35,64.44 191.35,45.4 197.18,39.57 249.92,39.57 260.99,28.51 266.89,28.51 269.46,25.95 275.6,25.95 279.07,29.41 283.17,29.41 284.32,30.56 286.28,30.56 287.35,31.63 289.74,31.63 290.06,31.95 294.65,31.95 296.01,33.31 v2(303.31,33.31)
  IN6 w0.099: v2(130.43,68.45) 130.43,69.04 132.99,71.6 137,71.6 137.59,72.19 139.88,72.19 142.04,74.35 143.46,74.35 143.89,73.92 153.04,73.92 154.15,75.03 157.84,75.03 158.98,73.89 158.98,73.48 159.21,73.25 159.69,73.25 160.28,73.84 169.15,73.84 170.13,72.86 172.7,72.86 173.14,73.31 173.14,74.54 174.19,75.59 176.71,75.59 177.78,74.52 177.78,70.49 178.23,70.03 178.23,68.86 180.98,66.12 180.98,63.98 181.46,63.5 182.86,63.5 183.29,63.93 183.29,63.98 v2(183.32,64.01)
  BOTTOM w0.14: v2(130.43,68.45) 128.51,68.45 126.91,66.85 v1(126.1,66.04) 121.99,61.93 121.99,59.79 122.4,59.38 122.4,59.11 121.67,58.39 RZ1957.1
VCCST_PWRGD_CPU: length 15
  TOP w0.089: v2(173.87,68.12) 173.86,68.14 173.58,68.14 v5(173.19,67.76)
  TOP w0.14: v2(181.34,61.39) 180.96,61.39 180.52,61.84 RH154.2
  IN3 w0.089: 179.9,62.83 179.46,63.28 179.46,66.58 179.13,66.91 178.24,66.91 177.42,67.73 174.7,67.73 174.3,68.12 v2(173.87,68.12)
  IN3 w0.091: 179.9,62.83 v2(181.34,61.39)
  BOTTOM w0.076: UH1.H13 173.51,68.49 v2(173.87,68.12)
VCCSTG_EN: length 131.3
  TOP w0.14: v2(130.74,64.64) 130.65,64.73 125.56,64.73 124.58,63.76 119.64,63.76 119,63.12 119,62.51 119.14,62.37 v1(119.14,62.14) 119.14,57.55 118.42,56.83 v2(118.42,56.81) ; RZ72.1 191.26,43.87 191.26,45.72 190.37,46.61 189.1,46.61 186.23,49.48 186.23,51.87 186.75,52.39 187.41,52.39 189.87,54.84 189.87,59.11 187.64,61.34 185.93,61.34 184.47,62.8 184.47,63.91 v2(184.35,64.02) ; v2(110.03,49.42) 110.03,49.62 109.82,49.84 UZ26.4 109.82,50.44 109.41,50.85 108.33,50.85 107.25,49.77 RZ1965.1 RZ1153.1
  IN3 w0.091: v2(110.03,49.42) 110.49,48.96 112.53,48.96 115.76,52.19 115.76,53.98 118.42,56.63 v2(118.42,56.81)
  IN6 w0.089: 181.1,63.27 180.31,63.27 179.3,64.28 179.3,66.27 177.99,67.58 177.99,69.8 176.96,70.83 173.47,70.83 173.25,71.05 171.98,71.05 171.66,70.73 169.8,70.73 169.32,71.21 158.33,71.21 157.57,71.96 144.05,71.96 143.49,71.41 143.02,71.41 142.61,71 141.98,71 140.83,69.85 139.54,69.85 138.5,68.81 138.02,68.81 137.48,68.27 135.08,68.27 134.62,67.81
  IN6 w0.099: v2(130.74,64.64) 130.74,65.72 131.34,66.33 131.87,66.33 132.09,66.11 132.92,66.11 134.62,67.81 ; 181.1,63.27 183.17,63.27 183.91,64.01 184.34,64.01 v2(184.35,64.02)
VCCSTG_EN_R: length 182.5
  TOP w0.14: v2(112.5,40.79) 112.5,41.17 v1(113.43,42.1) 113.43,42.49 113.32,42.59 107.72,42.59 106.06,44.24 106.06,46.79 106.94,47.66 RZ1153.2
  IN5 w0.099: v2(189.49,63.6) 190.02,64.14 190.68,64.14 191.15,63.66 191.15,52.38 186.26,47.49 186.26,41.08 174.36,29.18 174.36,24.51 174.02,24.17 174.02,23.68 173.59,23.25 173.59,21.43 172.49,20.33 131.32,20.33 130.73,20.92 107.53,20.92 105.15,23.31 105.15,25.67 106.58,27.11 106.58,33.79 112.32,39.52 112.32,40.62 v2(112.5,40.79)
  IN6 w0.099: v2(182.19,85.55) 182.07,85.43 182.07,83.49 181.77,83.19 181.77,81.71 182.12,81.36 182.12,73.03 189.49,65.66 v2(189.49,63.6)
  BOTTOM w0.14: v2(182.19,85.55) 182.21,85.53 182.24,85.53 182.36,85.42 UZ9.4
VDD33STB: length 3.5
  TOP w0.14: v2(7.62,34.47) 7.71,34.47 v1(8.14,34.9)
  TOP w0.381: v2(7.62,34.47) 7.62,34.01 RA100.2 8.1,33.78 8.6,33.28 RA101.2
  BOTTOM w0.203: UA1.10 7.64,34.49 v2(7.62,34.47)
VDD_1.2V: length 5.9
  TOP w0.14: v5(289.13,28.4) 289.46,28.4 v2(289.81,28.06)
  TOP w0.254: v2(289.81,28.06) 289.52,27.77 PR603.2
  BOTTOM w0.203: PC610.1 289.94,26.99 PR601.1 288.99,27.23 289.31,27.55 289.31,28 289.07,28.25 PU600.11
  BOTTOM w0.254: PC610.1 290.13,27.73 v2(289.81,28.06)
VDD_ISL88738: length 32.4
  TOP w0.14: v1(53.56,22.63) 54.24,22.63 54.62,22.25 54.62,21.66 v2(54.42,21.45)
  TOP w0.203: PU1900.18 51.7,14.11 52.03,14.44 v2(52.26,14.44) 52.66,14.44 53.09,14.86 PR1912.1 PC1928.1
  TOP w0.254: PR1911.2 54.85,21.01 v2(54.42,21.45) ; v2(41.08,12.19) 41.08,11.25 41.28,11.05 PR1908.2
  IN3 w0.254: v2(41.08,12.19) 41.66,12.19 41.78,12.32 41.78,15.62 43.41,17.25 48.82,17.25 51.63,14.44 v2(52.26,14.44)
  IN5 w0.254: v2(54.42,21.45) 54.21,21.25 54.21,21.24 53.93,20.96 53.93,20.96 53.78,20.82 53.78,15.62 52.6,14.44 v2(52.26,14.44)
VDDP_ISL88738: length 6.5
  TOP w0.203: PR1908.1 43.41,11.05 v1(45.13,12.77) 46,12.77 46.29,13.06 46.29,13.47 46.52,13.71 PU1900.8
  TOP w0.254: PR1908.1 PC1927.2
VDDQ_DDR: length 16.2
  BOTTOM w0.203: UH1.K6 172.3,63.68 171.85,63.68 171.66,63.49 UH1.L6
  BOTTOM w0.254: UH1.AG5 159.17,62.84 v2(159.48,63.15) ; UH1.J5 173.37,62.84 v2(173.71,63.18) 173.4,63.49 UH1.J6 UH1.K6 ; UH1.AG9 158.99,65.45 v2(159.42,65.88) ; UH1.AE12 160.57,67.4 v2(160.32,67.64) ; UH1.L12 171.89,67.53 172.47,67.53 UH1.K12 172.73,67.4 v2(173.05,67.08) ; UH1.AL11 156.31,66.75 v2(156.69,67.13) 156.96,67.4 UH1.AJ12 ; UH1.AF5 159.79,62.84 v2(159.48,63.15) ; v2(159.48,63.15) 159.58,63.15 UH1.AF6 ; UH1.AA6 164.11,63.48 v2(164.5,63.1) 164.88,63.49 UH1.W6 ; v2(167.02,63.16) 167.35,63.49 UH1.T6 UH1.R6 ; UH1.AT12 151.74,67.4 v2(152.11,67.03) 152.48,67.4 UH1.AR12 ; UH1.AP7 153.48,63.75 UH1.AP6 UH1.AR6 ; UH1.Y12 164.62,67.4 v2(164.91,67.11)
  BOTTOM w0.305: UH1.AR6 152.01,63.12 v2(151.94,63.12) ; UH1.AY6 149.08,63.49 v2(149.42,63.15) 149.77,63.49 UH1.AW6
  vias: v5(159.32,51.73)
VDDS_SENSE_VGA: length 3.1
  BOTTOM w0.254: UV18.U1 208.76,58.58 208.76,57.63 207.52,56.39 PR1520.1
VSS_SENSE: length 36.1
  TOP w0.203: PC1107.1 117.54,101.22 v2(117.16,101.6) 117.16,101.66 116.92,101.91 116.92,102.69 116.87,102.73 PU1100.18
  IN6 w0.254: v2(117.16,101.6) 117.79,100.97 119.53,100.97 120.21,101.64 124.87,101.64 125.12,101.89 127.71,101.89 127.99,101.61 130.62,101.61 130.9,101.89 134.02,101.89 135.39,100.52 135.39,98.2 136.93,96.65 139.83,96.65 141.38,98.2 v2(141.38,98.39)
  BOTTOM w0.254: v2(141.38,98.39) 141.48,98.28 141.48,97.67 v1(140.72,96.9) 139.38,96.9 138.95,96.47 RH465.2
VSS_SENSE_R: length 26
  BOTTOM w0.254: UH1.AG38 158.94,88.44 157.51,89.87 v1(157.01,89.87) 156.98,89.9 154.71,89.9 154.19,90.42 153.83,90.42 153.57,90.67 153.57,91.04 153.32,91.29 153.11,91.29 152.7,91.7 152.7,91.91 152.45,92.16 152.27,92.16 151.83,92.61 151.83,92.78 151.58,93.04 151.34,93.04 150.96,93.41 150.96,93.66 150.66,93.96 140.2,93.96 138.95,95.21 RH465.1 138.91,95.42 RH466.1
VSSGT_SENSE: length 63.6
  TOP w0.203: v2(112.65,106.55) 113.11,106.55 113.14,106.59 PU1100.6
  TOP w0.254: v2(112.65,106.55) 112.46,106.55 112.27,106.36 PC1109.1
  IN6 w0.254: v2(142.37,96.52) 142.23,96.38 142.23,95.56 141.59,94.92 135.68,94.92 133.73,96.87 133.73,98.77 132.53,99.98 130.93,99.98 130.69,99.73 128.92,99.73 127.27,98.08 125.92,98.08 124.84,99.16 123.31,99.16 122.1,97.95 120.53,97.95 120.25,98.24 116.76,98.24 114.4,100.6 110.8,100.6 110.05,101.34 110.05,102.47 108.67,103.85 108.67,105.1 110.13,106.55 v2(112.65,106.55)
  BOTTOM w0.14: v2(112.65,106.55) 112.68,106.55 v1(113.16,106.07)
  BOTTOM w0.254: RH204.2 RH472.1 135.83,96.39 136.51,96.39 137.77,97.65 139.74,97.65 140.59,98.5 140.59,98.72 141.06,99.19 142.16,99.19 142.91,98.44 142.91,96.87 142.57,96.52 v2(142.37,96.52)
VSSGT_SENSE_R: length 29.3
  BOTTOM w0.254: RH204.1 134.61,95.02 134.61,94.59 136.14,93.05 149.92,93.05 153.56,89.42 v1(155.75,89.42) 156.99,89.42 158.55,87.86 158.55,86.61 UH1.AH37
VSSIO_SENSE: length 76.3
  TOP w0.254: v2(170.05,72.05) 170.05,70.99 v1(171.77,69.28) 171.79,69.25 v2(172.29,69.25) ; PR810.2 107.6,65.7 109.11,65.7 110.2,66.79 115.05,66.79 117.77,64.06 124.12,64.06 125.52,65.46 v2(128.7,65.46)
  IN6 w0.254: v2(128.7,65.46) 128.93,65.46 131.12,67.65 131.12,68.82 133.52,71.21 140.24,71.21 142.06,73.03 142.06,73.48 142.47,73.89 142.85,73.89 143.12,73.62 143.12,73.35 143.27,73.19 152.29,73.19 152.36,73.27 153.81,73.27 155.29,74.75 157.35,74.75 158.47,73.64 158.47,72.98 158.78,72.67 169.43,72.67 v2(170.05,72.05)
  BOTTOM w0.254: v2(172.29,69.25) 172.8,69.25 UH1.J14
VSSMPHY_SENSE: length 8.2
  BOTTOM w0.089: 75.06,22.59 75.1,22.56 76.25,22.56 76.39,22.42 76.9,22.42 77.05,22.57 UH2.K46
  BOTTOM w0.14: 75.06,22.59 74.52,22.59 74.3,22.82 71.27,22.82 70.73,23.36 69.66,23.36 T4944.1
VSSSA_SENSE: length 21.7
  TOP w0.203: PU1100.31 120.76,106.59 120.93,106.41 121.35,106.41 121.62,106.68 v1(121.62,106.83) 121.62,107.27 121.92,107.57 121.92,108.48 v2(121.84,108.56) 121.97,108.69 122.39,108.69 PC1121.1
  IN3 w0.254: v2(121.84,108.56) 122.68,108.56 123.42,107.83 123.42,105.9 123.97,105.35 124.6,105.35 126.39,107.13 126.39,107.9 126.76,108.28 132.58,108.28 133.39,107.46 v2(133.77,107.46)
  BOTTOM w0.254: v2(133.77,107.46) 133.63,107.46 133.38,107.7 RH470.2
VSSSA_SENSE_R: length 55.3
  IN4 w0.254: v2(168.77,93.09) 168.77,92.72 169.55,91.95 169.55,88.43 168.88,87.76 v2(168.88,87.38)
  IN6 w0.254: v2(168.77,93.09) 168.77,93.83 168.16,94.44 147.94,94.44 142.27,100.1 137.67,100.1 135.57,102.2 135.57,105.39 134.3,106.66 133.57,106.66 133.15,106.24 v2(133.15,106.17)
  BOTTOM w0.14: v1(132.18,106.79) RH470.1
  BOTTOM w0.254: RH469.1 133.11,106.13 v2(133.15,106.17) 133.11,106.2 RH470.1 ; UH1.M37 170.36,86.61 170.36,87.1 169.7,87.75 169.25,87.75 v2(168.88,87.38)
VSSSENSE_VGA: length 117.5
  IN2 w0.254: v2(178.31,93.09) 178.31,92.82 180.61,90.52 181.58,90.52 182.4,89.7 182.4,88.91 185.12,86.2 185.12,83.01 191.56,76.57 191.56,69 197.87,62.69 199,62.69 201.18,60.5 201.18,57.77 202.01,56.94 203.16,56.94 206.76,53.34 210.57,53.34 212.92,55.68 212.92,58.57 213.89,59.55 213.89,59.57 213.9,59.57 213.9,60.03 213.89,60.03 213.89,60.82 v2(213.33,61.38) ; v2(170.5,93.09) 169.9,93.69 169.89,93.69 169.28,94.3 164.83,94.3 164.01,95.12 164.01,99.49 166.05,101.53 166.05,106.05 164.87,107.23 164.87,109.49 166.31,110.92 171.32,110.92 172.34,111.94 172.34,114.42 173.27,115.36 173.66,115.36 174.14,115.84 174.14,116.24 172.95,117.44 v2(172.95,117.91)
  IN4 w0.254: v2(178.31,93.09) 178.31,92.77 178.02,92.49 177.42,92.49 176.27,93.64 174.23,93.64 173.44,94.43 170.88,94.43 170.36,93.91 170.36,93.23 v2(170.5,93.09)
  BOTTOM w0.254: v2(213.33,61.38) 213.74,61.79 UV18.L5 ; PR1018.1 172.95,117.45 v2(172.95,117.91)
1.8V_PRIM_PWRGD/SHD_IO2: length 8.6
  TOP w0.076: v2(302.6,15.78) 302.19,15.37 UE3.L7
  TOP w0.14: RT1139.2 309.31,17.67 308.65,17.67 v2(308.49,17.82)
  IN6 w0.076: 303.47,16.64 v2(302.6,15.78)
  IN6 w0.099: 303.47,16.64 303.74,16.91 304.43,16.91 305.61,18.09 308.23,18.09 v2(308.49,17.82)
3D VISION/STEREO: length 6.1
  BOTTOM w0.14: UV18.P3 211.26,60.2 211.66,59.8 211.66,59.08 211.87,58.87 211.87,57.95 211.51,57.59 211.51,56.5 211.95,56.06 211.95,55.55 T4977.1
3S_BATT+:
  vias: v1(29.78,22.63)
32KHZ_OUT: length 10.4
  TOP w0.14: v2(297.61,6.36) 297.6,6.36 297.16,5.92 v1(297.16,5.79) 297.16,5.38 297.51,5.03 297.56,5.03 CE1501.2 ; v2(297.76,11.74) UE3.F3
  IN3 w0.091: v2(297.61,6.36) 297.61,6.38 296.95,7.04 296.37,7.04 295.81,7.6 295.81,10.26 296.37,10.82 297.16,10.82 297.76,11.42 v2(297.76,11.74)
+1.8ALWP: length 3.6
  TOP w0.14: v2(246.93,99.19) 246.93,99.54 v1(246.6,99.87)
  BOTTOM w0.381: PC1608.1 247.71,99.78 248.46,100.52 PR1603.1 PC1606.1
+AC_IN: length 24.1
  TOP w0.254: v2(29.39,7.14) 28.85,7.14 PR234.1
  IN2 w0.508: v2(23.17,26.09) 23.42,26.09 24.48,25.03 24.48,20.46 27.84,17.1 27.84,15.4 26.22,13.78 26.22,10.08 29.16,7.14 v2(29.39,7.14)
  vias: v1(24.6,24.19) v2(22.55,26.13) v2(22.58,26.73) v2(23.17,27.94) v2(23.17,27.35) v2(23.16,26.73)
+CHG_SRC_20V: length 1
  TOP w0.14: v5(51.36,6.83) 51.36,6.54 50.85,6.03
  vias: v2(49.37,3.24) v2(49.37,2.6) v2(49.36,2.02) v2(49.66,5.97) v2(49.66,5.34) v2(49.66,4.7) v2(49.66,4.07) v2(49.99,3.25) v2(49.99,2.61) v2(49.98,2.03) v2(51.54,2.71) v2(51.54,2.07)
+DC_IN: length 117.7
  TOP w0.127: v5(27.04,79.41) 26.67,79.05 v2(26.61,79.05)
  TOP w0.508: PR211.1 35.23,3.71 v5(36.02,2.92) v2(36.02,1.93) ; v2(63.07,20.83) 63.58,21.34 v5(64.64,21.34) PD203.2
  IN1 w0.508: 14.34,28.55 14.35,28.54 14.35,18.96 13.27,17.88 11.79,17.88 10.79,16.89 10.79,16.03 11.8,15.02 11.8,7.11 12.31,6.61 12.83,6.61 13.31,7.09 15.77,7.09 17.02,5.84 19.86,5.84 23.49,2.21 25.38,2.21 26.16,2.99 28.98,2.99 29.35,2.62 35.17,2.62 35.85,1.93 v2(36.02,1.93)
  IN4 w0.508: v2(47.13,24.44) 46.51,25.06 46.51,25.38 44.83,27.05 38.94,27.05 38.2,27.79 33.38,27.79 32.57,26.97 32.57,25.22 32.06,24.72 31.26,24.72 31.22,24.68 31.18,24.68 29.97,23.47 26.84,23.47
  IN5 w0.508: v2(47.13,24.44) 45.94,23.24 44.06,23.24 43.64,22.82 43.64,21.72 44.9,20.46 48.36,20.46 49.98,18.85 49.98,15.5 51.75,13.72 52.96,13.72 54.67,15.43 54.67,18.5 56.05,19.88 60.14,19.88 60.71,20.45 61.6,20.45 62.17,19.88 62.61,19.88 63.07,20.33 v2(63.07,20.83)
  vias: v2(12.41,30.43) v2(12.7,29.91) v2(12.67,29.08) v2(13.02,30.47) v2(13.1,29.48) v2(13.39,30.96) v2(13.65,29.84) v2(13.64,29.13) v2(13.66,30.42) v2(13.99,30.92) v2(14.25,30.39) v2(14.23,29.16) v2(14.29,29.8) v2(25.59,82.59) v2(25.59,81.95) v2(25.57,81.27) v2(25.59,80.54) v2(25.59,79.9) v2(26.1,81.5) v2(26.11,80.81) v2(26.09,80.19) v2(26.06,79.57) v2(26.59,81.81) v2(26.61,81.17) v2(26.63,80.45) v2(26.62,79.79)
+DC_IN_SS: length 4.8
  TOP w0.127: v5(6.9,25.97) 6.99,25.88 10.35,25.88 10.78,26.32 v2(11.48,26.32)
  vias: v2(11.91,26.75) v2(13.12,25.36) v2(13.69,25.4)
+DCPRTC: length 3.1
  TOP w0.254: CH3331.1 75.3,3.25 v1(75.77,3.72) 75.77,3.9 v2(75.48,4.19)
  BOTTOM w0.127: v2(75.48,4.19) 75.89,4.19 UH2.BG47
  BOTTOM w0.254: UH2.BF47 76.54,4.86 76.29,4.61 UH2.BG47
+EC_DEBUG_VCC: length 3.9
  TOP w0.14: v2(313.89,30.82) 314.27,30.82 v5(314.58,30.51)
  TOP w0.381: v2(313.89,30.82) 313.74,30.82 313.18,30.26 RE60.2
  BOTTOM w0.305: JDEG1.1 313.02,31.68 v2(313.89,30.82)
+EDPVDD: length 1.6
  TOP w0.14: CV157.1 52.07,28.26 v5(52.07,26.8)
  vias: v2(57.77,34.34) v2(58.35,34.34) v5(53.09,30.99) v5(58.15,32.97)
+FB_PLLAVDD: length 6.4
  TOP w0.102: v2(216.73,72.29) 217.17,72.29 v1(217.48,71.98)
  TOP w0.381: v2(215.51,79.31) 215.26,79.06 214.77,79.06 CV923.1
  TOP w0.508: CV921.1 208.94,80.68 v2(209.12,80.68) ; CV922.1 216.68,72.35 v2(216.73,72.29)
  BOTTOM w0.254: UV18.H17 v2(216.73,72.29) ; UV18.U27 209.12,80.68 v2(209.12,80.68)
  BOTTOM w0.305: v2(215.51,79.31) 214.91,79.31 214.47,79.75 214.47,80.19 UV18.K27
  vias: v2(191.63,84.38) v2(191.61,83.72)
+FBA_VREFC0: length 59.4
  TOP w0.381: v2(203.86,105.64) 204.19,105.97 CV926.1
  TOP w0.406: RV625.1 223.71,109.76 CV927.1 224.79,109.76 225.25,110.22 v2(225.25,111.32)
  TOP w0.508: RV625.1 223.7,109.46 RV623.2 224.26,108.61 224.52,108.35 RV624.2
  IN6 w0.508: v2(203.86,105.64) 203.84,105.64 203.79,105.59 203.48,105.59 203.01,106.06 203.01,110.3 204.67,111.96 209.73,111.96 210.39,111.3 218.9,111.3 218.91,111.32 v2(225.25,111.32)
  BOTTOM w0.406: UV23.J14 238.1,104.4 238.89,104.4 239.33,104.84 239.33,110.75 237.5,112.58 229.98,112.58 229.39,113.16 227.09,113.16 v1(226.82,112.88) 226.82,112.39 225.74,111.32 v2(225.25,111.32) ; v2(203.86,105.64) 203.86,105.54 204.09,105.31 204.09,105.14 UV24.J14
+FBA_VREFC0_R: length 3.8
  TOP w0.508: RV624.1 222.85,107.96 v1(222.6,107.7) 222.14,107.24 QV101.1
+FBC_VREFC1: length 59.7
  TOP w0.14: v1(246.14,98.22) RV634.2
  TOP w0.406: RV634.2 246.14,96.84 RV635.2 246.15,95.9 CV989.1 247.05,94.95 RV636.1 v2(247.06,94.28)
  TOP w0.508: CV988.1 241.97,91.05 v2(242.33,91.4)
  IN3 w0.508: v2(242.33,91.4) 243.07,91.4 245.94,94.28 v2(247.06,94.28)
  IN6 w0.508: v2(242.33,91.4) 243.4,90.34 244.22,90.34 244.94,89.62 244.94,88.67 247.51,86.1 247.51,83.43 247.33,83.25 247.33,80.77 248.03,80.08 248.03,79.12 247.52,78.61 245.49,78.61 243.59,76.71 243.59,71.2 246.73,68.05 246.73,65.7 246.49,65.46 246.49,63.55 246.7,63.34 246.7,61.61 245.99,60.9 245.46,60.9 244.73,60.17 244.73,56.39 244.7,56.36 244.7,56.36 244.22,55.88 243.04,55.88 242.52,56.4 v2(242.52,56.6)
  BOTTOM w0.254: v2(242.33,91.4) 242.33,91.32 UV26.J14 ; UV25.J14 v2(242.52,56.6)
+FBC_VREFC1_R: length 3.9
  TOP w0.14: RV635.1 245.52,94.99 245.1,95.42 v1(245.1,95.68)
  TOP w0.508: RV635.1 246.14,94.34 245.3,93.5 QV102.1
+GPCPLL_AVDD: length 1.3
  TOP w0.508: v2(213.37,80.72) 213.45,80.8 RV574.1
  BOTTOM w0.381: v2(215.9,79.88) 216.34,79.45 UV18.H26
  vias: v1(216.8,80.1)
+GPU_CORE: length 16
  TOP w0.254: 180.89,111.12 180.66,111.35 179.35,111.35 179.13,111.13 PR1023.1
  TOP w0.457: RV1810.1 171.95,119.52 172.63,118.83 173.91,118.83 174.22,118.53 v2(174.22,118.32)
  IN6 w0.508: v2(177.04,111.86) 176.31,111.86 175.07,113.1 175.07,114.24 174.31,115 174.31,116.84 174.22,116.93 v2(174.22,118.32)
  vias: v2(180.68,106.86) v2(180.68,106.26) v2(180.68,105.65) v2(180.68,105.06) v2(180.68,104.45) v2(180.66,103.85) v2(180.68,103.27) v2(180.68,102.68) v2(180.67,102.09) v2(180.67,101.48) v2(180.67,100.89) v2(180.67,100.3) v2(180.67,99.69) v2(180.67,99.08) v2(180.68,98.48) v2(180.68,97.89) v2(180.68,97.3) v2(181.47,96.64) v2(181.47,96.02) v2(181.48,95.41) v2(181.48,94.81) v2(181.73,94.22) v2(182.04,106.75) v2(182.05,106.12) v2(182.04,105.51) v2(182.03,104.92) v2(182.04,104.33) v2(182.04,103.73) v2(182.04,103.11) v2(182.06,98.35) v2(182.08,97.74) v2(182.08,97.16) v2(182.08,96.57) v2(182.09,95.99) v2(182.08,95.39) v2(182.07,94.81) v2(182.27,102.57) v2(182.4,94.24) v2(182.62,103.11) v2(182.67,106.75) v2(182.68,106.12) v2(182.68,105.51) v2(182.66,104.92) v2(182.68,104.31) v2(182.67,103.72) v2(182.67,98.35) v2(182.67,97.74) v2(182.67,97.16) v2(182.67,96.57) v2(182.68,95.97) v2(182.68,95.39) v2(182.68,94.79) v2(182.88,102.57) v2(183.23,103.13) v2(183.25,97.74) v2(183.25,97.16) v2(183.25,96.57) v2(183.29,106.75) v2(183.28,106.11) v2(183.31,105.51) v2(183.3,104.92) v2(183.31,104.31) v2(183.29,103.72) v2(183.27,98.35) v2(183.27,95.99) v2(183.3,95.39) v2(183.3,94.79) v2(183.48,102.6) v2(183.83,103.14) v2(183.76,102.08) v2(183.76,101.45) v2(183.76,100.87) v2(183.76,100.29) v2(183.76,99.7) v2(183.77,99.11) v2(183.83,97.74) v2(183.83,97.16) v2(183.83,96.57) v2(183.89,106.75) v2(183.88,106.13) v2(183.9,105.54) v2(183.89,104.94) v2(183.9,104.33) v2(183.89,103.73) v2(183.86,98.35) v2(183.89,95.95) v2(183.91,95.36) v2(184.11,102.58) v2(184.48,106.77) v2(184.47,106.19) v2(184.48,105.6) v2(184.5,105.01) v2(184.53,97.02) v2(184.53,96.43) v2(185.13,97.02) v2(185.13,96.43) v2(185.78,97.06) v2(185.8,96.48) v2(186.41,97.04) v2(186.43,96.46) v2(200.03,80.72) v2(201.03,72.44) v2(201.13,71.82) v2(202.4,77.43) v2(202.49,76.21) v2(202.45,66.41) v2(202.6,75.3) v2(202.83,65.16) v2(203.34,73.32) v2(203.28,67.24) v2(203.29,66.42) v2(203.36,77.44) v2(203.39,71.35) v2(204.34,68.51) v2(204.78,78.39) v2(205.62,65.65) v2(205.84,63.89) v2(205.84,63.07) v2(205.84,62.21) v2(205.86,60.56) v2(206.44,73.4) v2(206.36,71.21) v2(206.35,70.31) v2(206.57,58.14) v2(206.69,60.58) v2(206.9,58.83) v2(207.27,71.12) v2(207.33,68.24) v2(207.34,67.27) v2(207.32,66.49) v2(207.4,62.29) v2(207.52,64.82) v2(207.5,63.87) v2(207.45,62.91) v2(208.34,77.28) v2(208.33,76.32) v2(208.33,68.15) v2(208.34,66.51) v2(208.37,70.32) v2(209.35,78.32) v2(209.35,70.32) v2(209.35,69.55) v2(209.29,67.28) v2(209.36,73.41) v2(210.29,78.17) v2(210.26,70.36) v2(210.49,73.28) v2(211.33,78.17) v2(211.32,73.28) v2(211.3,71.07) v2(211.36,69.37) v2(211.72,66.21) v2(212.19,69.28) v2(212.31,78.18) v2(212.27,76.28) v2(212.27,71.26) v2(212.4,73.18) v2(213.24,67.27) v2(213.36,78.3) v2(213.36,77.41) v2(213.46,71.23) v2(213.57,73.29) v2(214.18,78.34) v2(214.17,69.29) v2(214.31,75.3) v2(214.31,74.31) v2(214.31,73.32) v2(215.08,70.96) v2(215.09,69.58) v2(215.3,75.31) v2(215.32,72.7) v2(215.35,76.39) v5(183.26,107.82)
+GPU_CORE_VDDS: length 79.4
  TOP w0.508: v2(205.46,67.24) 205.05,67.65 PC1502.1 ; RV1808.1 v2(224.59,118.39)
  IN1 w0.508: v2(210.19,109.64) 211.38,110.83 211.38,112.82 212.12,113.56 216.12,113.56 216.59,113.09 216.59,112.31 217.11,111.79 221.07,111.79 221.56,112.28 221.56,113.34 222.78,114.56 224.44,114.56 224.84,114.96 224.84,117.34 224.59,117.59 v2(224.59,118.39)
  IN4 w0.508: v2(210.19,109.64) 210.19,98.48 209.37,97.66 202.76,97.66 v2(202.06,98.36)
  IN6 w0.508: 194.45,104.83 190.24,109.04 190.24,109.69 185.04,114.89 185.04,119.77 v2(184.96,119.85)
  BOTTOM w0.203: 206.26,67.7 206.26,67.66 205.84,67.24 v2(205.46,67.24)
  BOTTOM w0.254: v2(206.44,76.26) 206.84,75.87 UV18.W21 ; UV18.AA23 204.84,77.74 v2(205.36,77.22) ; UV18.V18 207.86,72.8 v2(208.35,72.3) ; v2(211.39,77.34) 211.84,77.79 UV18.P23 ; v2(203.44,75.27) 203.44,75.36 203.01,75.8 UV18.AC21 ; UV18.W14 206.38,68.34 206.38,67.82 206.26,67.7 ; v2(204.47,74.23) 204.84,73.87 UV18.AA19
  BOTTOM w0.305: v2(212.17,74.3) 211.84,73.97 UV18.P19 ; UV18.P16 211.84,70.64 v2(212.13,70.34) ; UV18.T14 v2(210.36,68.28) ; UV18.P12 211.71,66.8 v2(211.24,67.27) ; v2(210.31,76.27) UV18.T21 ; UV18.M14 v2(213.36,69.27) ; v2(205.46,67.24) 205.41,67.24 204.96,66.8 UV18.AA12 ; UV18.U17 208.84,71.82 v2(208.35,72.3) ; UV18.M21 213.54,75.5 v2(213.54,75.29) ; v2(204.4,70.36) UV18.AA16 ; UV18.AC14 203.04,68.8 v2(203.39,69.15)
  BOTTOM w0.508: PR1521.1 185.14,120.02 v2(184.96,119.85)
  vias: v2(190.35,95.16) v2(190.34,94.57) v2(190.35,96.39) v2(190.35,95.79) v2(190.9,97.97) v2(190.91,97.38) v2(192.65,98.05) v2(192.64,97.46) v2(192.66,99.85) v2(192.65,98.75) v2(192.96,100.36) v2(193.08,99.3) v2(193.22,100.89) v2(193.25,97.45) v2(193.25,102.76) v2(193.25,102.13) v2(193.25,101.49) v2(193.3,99.85) v2(193.29,98.75) v2(193.27,98.04) v2(193.65,100.38) v2(193.71,99.3) v2(193.93,99.85) v2(193.92,98.75) v2(193.91,98.04) v2(193.85,97.45) v2(194.28,100.41) v2(194.35,99.3) v2(194.55,100.95) v2(194.62,104.23) v2(194.63,101.82) v2(194.56,99.89) v2(194.67,102.92) v2(194.92,100.41) v2(194.94,99.44) v2(194.99,101.35) v2(195.26,102.92) v2(195.86,102.92) v2(196.46,102.92) v2(197.11,102.92) v2(197.74,102.95) v5(196.91,100.9)
+INV_PWR_SRC:
  vias: v2(48.8,35.05) v2(49.41,35.05) v5(47.16,36.56) v5(48.64,35.66) v5(50.27,36.27)
+NVVDDS_B+: length 24
  IN4 w0.381: v2(182.09,116.99) 182.58,117.48 186.95,117.48 187.33,117.1 187.78,117.1 188.34,117.65 189.22,117.65 190.58,116.29 192.57,116.29 195.06,113.81 195.06,110.82 196.04,109.85 197.98,109.85 v2(198.86,108.97)
  BOTTOM w0.508: PR1514.1 182.7,117.6 v2(182.09,116.99)
  vias: v1(200.47,108.71) v2(198.88,107.21) v2(198.88,106.63) v2(198.88,106.05) v2(200.49,107.99) v2(200.49,107.41) v2(200.49,106.83) v2(200.49,106.24)
+ODR_PWR: length 19.4
  TOP w0.127: 327.29,51.39 327.29,52.67 v5(326.67,53.29)
  IN3 w1.016: 328.23,50.48 328.23,45.7 329.94,44 331.68,44 332.39,44.72 332.97,44.72 333.3,44.39 333.3,41.17 334.65,39.81
  BOTTOM w0.203: UR1.12 337.44,37.39
  BOTTOM w0.305: v2(336.91,37.09) 337.21,37.39 337.44,37.39
  vias: v2(327.3,50.39) v2(336.27,37.29)
+PECI_VREF: length 7.4
  TOP w0.14: v1(302.12,24.33) 302.24,24.33 v2(302.54,24.64)
  TOP w0.305: UE3.J11 v2(300.96,18.97)
  IN2 w0.508: v2(302.54,24.64) 302.54,23.27 301.42,22.15 301.42,20.56 300.96,20.1 v2(300.96,18.97)
+PEX_PLL_HVDD: length 1.2
  TOP w0.14: v1(200.3,66.83) 200.3,66.89 v2(199.94,67.24)
  BOTTOM w0.381: UV18.AH12 199.54,67.64 v2(199.94,67.24)
+PEX_PLL_VDD: length 2.3
  TOP w0.14: v2(201.65,78.51) 201.68,78.49 T4994.1
  BOTTOM w0.254: UV18.AG26 200.77,79.4 v2(201.65,78.51)
+PEX_SVDD_3V3: length 1.2
  TOP w0.381: T4993.1 200.24,68.48 v2(199.9,68.14)
  BOTTOM w0.381: v2(199.9,68.14) 200.34,67.7 UV18.AG12
+PWR_SRC_AC:
  vias: v5(59.02,8.12)
+RTC_CELL_VBAT: length 27
  TOP w0.254: v2(294.56,11.77) UE3.A2
  TOP w0.381: RE50.1 290.06,5.7 290.89,6.53 291.54,6.53 292.09,5.98 v2(292.09,5.72)
  IN3 w0.508: v2(294.56,11.77) 292.23,9.44 292.23,8.71 v2(292.2,8.69)
  BOTTOM w0.508: v2(292.09,5.72) 291.62,6.19 291.62,8.1 v2(292.2,8.69) 291.83,9.06 291.83,12.1 290.98,12.96 290.3,12.96 289.94,12.6 287.84,12.6 285.73,14.71 285.73,15.93 285.29,16.36 283.67,16.36 v2(283.05,15.74)
  vias: v1(282.8,14.67)
+RTCBATT: length 145.6
  TOP w0.508: JRTC.1 329.75,102.42 329.06,101.73 329.06,92.97 330.21,91.82 v5(330.21,90.88) 330.21,88.72 v2(331.34,87.58) ; v2(281.69,19.41) 279.93,17.65 279.93,13.97 280.11,13.79 280.11,11.95 280.46,11.61 280.46,10.01 278.54,8.09 RH67.2
  IN2 w0.508: v2(331.34,87.58) 328.88,87.58 326.4,85.1 326.4,80.71 328.45,78.66 329.34,78.66 332.62,75.39 332.62,66.16 333.1,65.68 333.1,58.73 332.68,58.31 332.68,53.15 329.91,50.38 329.91,43.02 327.03,40.13 315.05,40.13 311.99,37.07 308.85,37.07 302.64,30.86 300.34,30.86 299.21,29.73 299.21,28.65 297.54,26.98 296.75,26.98 296.17,27.56 290.88,27.56 290.59,27.27 289.51,27.27 288.8,26.56 286.84,26.56 285.83,25.54 285.83,23.55 v2(281.69,19.41)
+RTCVCC: length 159.8
  TOP w0.356: v2(69.45,5.37) 69.6,5.21 70.54,5.21 RH83.1
  TOP w0.381: RH84.1 74.42,1.87 74.28,2.01 CH80.1 74.22,2.34 74.38,2.5 74.38,4.01 CH70.1 73.76,4.92 74.1,5.26 v2(74.1,5.35) 74.37,5.62 74.37,6.08 73.79,6.67 73.79,7.14 74.64,7.99 75.81,7.99 RH531.2
  TOP w0.508: v2(166.73,18.39) 166.73,15.8 v1(168.42,14.11) 169.83,12.69 169.83,9.73 169.45,9.35 169.45,8.25 169.67,8.03 C3.1 170.23,6.48 170.61,6.86 QRTC.1 171.45,6.31 R276.1
  IN2 w0.381: v2(61.83,12.7) 62.38,12.15 62.38,11.21 63.72,9.87 63.72,7.29 64.24,6.77 65.28,6.77
  IN5 w0.508: v2(166.73,18.39) 165.86,19.26 130.4,19.26 129.93,19.72 107.1,19.72 105.9,20.92 105.52,20.92 105.04,21.4 103.34,21.4 102,22.75 102,24 101.12,24.88 99.93,24.88 97.98,22.93 88.94,22.93 87.51,21.5 80.91,21.5 78.04,18.63 74.69,18.63 73.31,20.01 66.08,20.01 65.13,19.05 65.13,18.18 64.16,17.22 64.16,14.5 62.36,12.7 v2(61.83,12.7) ; v2(74.1,5.35) 73.91,5.16 69.65,5.16 v2(69.45,5.37)
  BOTTOM w0.254: v2(74.1,5.35) 74.54,5.35 74.98,5.79 75.28,5.79 UH2.BD49 UH2.BC49
+RTCVCC_R: length 354.4
  TOP w0.381: QRTC.3 174.93,7.82 176.05,8.94 178.18,8.94 178.92,8.21 181.05,8.21 181.53,7.72 181.53,3.44 v2(181.33,3.24)
  TOP w0.508: RE16.1 281.51,14.25 280.72,13.46 280.72,12.24 281.13,11.84 281.13,9.6 279.45,7.93 RH67.1 ; v2(278.53,3.29) 278.53,3.67 279.43,4.57 ; v2(14.32,33.09) v1(13.17,33.09) 11.7,33.09 11.06,33.73 10.2,33.73 RA101.1
  IN3 w0.508: v2(14.32,33.09) 14.9,32.5 14.9,28.36 13.41,26.87 12.97,26.87 8.26,22.17 8.26,19.69 6.62,18.05 6.62,15.51 5.78,14.67 5.02,14.67 4.45,14.1 4.45,13.08 2.48,11.11 2.48,8.32 3.05,7.75 9.59,7.75 11.88,10.04 19.07,10.04 21.39,7.73 21.39,2.63 v2(20.5,1.74)
  IN4 w0.254: v2(20.5,1.74) 20.93,1.31 42.08,1.31 42.8,2.03 43.82,2.03 44.51,1.33 51.73,1.33 53.49,3.1 61.04,3.1 61.98,2.16 65.15,2.16 65.81,1.5 75.03,1.5 75.57,2.03 76.71,2.03 77.32,1.42 82.17,1.42 ; 84.67,1.42 84.83,1.27 90.04,1.27 90.55,1.78 91.45,1.78 92.09,1.14 150.12,1.14 151.89,2.92 177.51,2.92 178.4,3.81 180.76,3.81 v2(181.33,3.24) 181.65,2.92 189.49,2.92 190.37,3.81 190.88,3.81 191.77,2.92 204.6,2.92 206.1,1.42 244.08,1.42 247.36,4.7 250.36,4.7 251.91,3.15 257.23,3.15 257.89,3.81 263.02,3.81 263.53,4.32 264.42,4.32 265.29,5.2 266.67,5.2 267.66,4.2 272.87,4.2 273.27,3.81 278,3.81 v2(278.53,3.29)
+SD_VDD2: length 18.9
  IN6 w0.762: v2(336.73,37.91) 336.74,37.92 336.74,40.52 339.22,43 341.22,43 342.49,41.73 346.48,41.73 348.11,43.36 349.56,43.36
  BOTTOM w0.203: UR1.13 336.85,37.79 v2(336.73,37.91)
  vias: v1(350.44,44.26) v2(349.72,48.38) v2(349.72,47.8) v2(349.97,44.45) v2(350.09,43.88)
+SDC_IN: length 5.4
  TOP w0.381: PR1903.1 52.76,9.91 53.03,10.18 55.57,10.18 55.87,10.48 v2(55.87,10.95)
  BOTTOM w0.254: v2(55.87,12.17) 55.41,12.62 PR1904.1
  vias: v2(11.62,18.84) v2(11.74,19.46) v2(12.12,19.99) v2(12.21,18.84) v2(12.35,19.43) v2(12.6,20.35) v2(12.81,18.84) v2(12.88,19.76) v2(13.21,19.28) v2(17.32,20.65) v2(17.31,20.06) v2(17.29,19.45) v2(17.71,21.1) v2(18.2,21.45) v2(55.87,11.56) v2(58.4,12.13) v2(58.41,11.53) v2(58.4,10.91) v2(58.39,10.32) v2(58.99,12.12) v2(59,11.52) v2(58.99,10.9) v2(59.59,11.53) v2(59.58,10.92) v5(59.56,12.13)
+SP_PLLVDD: length 0.5
  BOTTOM w0.254: v2(202.5,64.62) 202.5,64.62 202.41,64.62 UV18.AE8
  vias: v1(202.26,63.96)
+TBTA_VBUS_1: length 31.1
  TOP w0.14: v1(29.56,31.2) 28.85,30.48 PL201.2
  TOP w0.254: PR249.1 27.68,7.3 28.39,6.59 29.62,6.59 30.75,7.71 30.75,12.64 31.43,13.32 v2(31.43,13.69)
  IN1 w0.508: v2(27.38,26.76) 26.46,25.84 v2(24.71,25.84)
  IN2 w0.508: v2(24.71,25.84) 24.89,25.84 25.24,25.48 25.24,20.56 25.99,19.82 27.86,19.82 31.43,16.25 v2(31.43,13.69)
  vias: v2(26.23,29.25) v2(26.8,29.25) v2(27.37,29.25) v2(27.38,28.66) v2(27.38,28.03) v2(27.38,27.39) v2(27.94,29.25) v2(27.97,28.66) v2(27.97,28.03) v2(27.97,27.39) v2(27.99,26.76)
+V_DDR_REF: length 3
  BOTTOM w0.127: v2(289.43,32.94) 289.23,33.15 PC609.1
  BOTTOM w0.203: PU600.4 288.67,32.13 288.74,32.2 288.74,32.7 PC609.1
+V_DDR_REFA: length 31.4
  TOP w0.127: v2(127.07,18.31) 127.07,18.1 v5(127.37,17.79)
  TOP w0.508: CD18.1 150.19,18.37 v2(150.2,18.37) ; RH484.2 RH209.1 RH206.2 127.41,18.65 v2(127.07,18.31)
  IN4 w0.508: v2(150.2,18.37) 150.2,18.85 149.1,19.94 149.09,19.94 148.15,20.89 143.19,20.89 142.56,20.26 128.02,20.26 127.07,19.31 v2(127.07,18.31)
  BOTTOM w0.305: JDIMM1.164 150.12,18.44 v2(150.2,18.37)
+V_DDR_REFA_R: length 64.2
  TOP w0.127: v5(139.14,68.47) 139.5,68.47 v2(139.73,68.7)
  TOP w0.508: RH484.1 CH101.1 124.88,21.64 v2(124.85,21.67)
  IN3 w0.381: 138.32,64.98 138.32,65.64 137.69,66.28 137.69,68.4 138.06,68.77 139.65,68.77 v2(139.73,68.7)
  IN3 w0.508: 138.32,64.98 138.32,61.36 138.66,61.01 140.02,61.01 140.81,60.22 140.81,59.24 137.52,55.94 137.52,53.78 134.17,50.43 128.61,50.43 127.35,49.17 127.35,30.92 126.54,30.11 126.54,28.55 125.38,27.38 125.38,22.19 v2(124.85,21.67)
+V_DDR_REFB: length 15.7
  TOP w0.254: v2(226.5,18.36) 226.5,18.56 226.99,19.05 CD29.1
  TOP w0.508: RH485.2 RH207.2 RH210.1 234.3,19.11 v5(234.56,18.85) 234.89,18.52 234.89,18.43 234.93,18.39 234.93,18.38 v2(234.96,18.35)
  IN5 w0.508: v2(226.5,18.36) 226.5,18.56 226.96,19.02 234.29,19.02 v2(234.96,18.35)
  BOTTOM w0.305: v2(226.5,18.36) 226.5,18.37 226.42,18.44 JDIMM2.164
+V_DDR_REFB_R: length 128.3
  TOP w0.508: RH485.1 CH100.1 231.31,21.74 v2(230.66,22.39)
  IN3 w0.381: 139.6,65.89 139.6,66.52 138.43,67.69 v2(138.43,67.9)
  IN3 w0.508: v2(230.66,22.39) 230.32,22.39 229.2,21.27 226.7,21.27 225.93,20.51 207.44,20.51 207.18,20.77 204.4,20.77 203.43,21.74 203.43,25.07 202.95,25.54 202.37,25.54 201.68,26.23 198.5,26.23 197.55,27.18 182.44,27.18 181.9,26.64 175.36,26.64 173.53,28.48 164.95,28.48 164.52,28.91 164.52,29.55 145.66,48.41 145.66,61.97 145.86,62.16 145.86,63.39 145.44,63.8 140.47,63.8 139.6,64.67 139.6,65.89
+VDISPLAY_VCC: length 30.7
  TOP w0.254: v2(28.45,74.68) RM2.2 RM1.2
  IN4 w0.254: v2(14.1,91) 14.57,91.47 21.17,91.47 21.46,91.76 23.83,91.76 28.14,87.45 28.14,80.97 27.97,80.8 27.97,75.16 v2(28.45,74.68)
  vias: v1(15.71,90.43) v2(14.11,90.4)
+VGA_B+: length 32.1
  IN5 w0.508: v2(170.35,103.62) 175.31,103.62 177.17,105.47 177.17,109.04 178.44,110.31 179.78,110.31 180.28,110.81 v2(180.28,112.33)
  IN6 w0.508: v2(180.28,112.33) 180.53,112.59 181.43,112.59 181.71,112.87 181.71,115.8 180.57,116.94 177.89,116.94 175.82,119.01 173.95,119.01 v2(173.34,119.62)
  BOTTOM w0.508: v2(173.34,119.62) 173.05,119.33 PR1014.1
  vias: v1(165.69,107.14) v2(165.39,109.02) v2(165.39,108.43) v2(165.39,107.85) v2(166.56,105.26) v2(166.57,104.14) v2(166.56,103.22) v2(166.59,102.62) v2(166.63,102.03) v2(166.71,101.37) v2(166.8,104.73) v2(166.96,103.65) v2(167.17,106.81) v2(167.18,106.22) v2(167.35,109) v2(167.35,108.42) v2(167.35,107.83) v2(167.55,107.26) v2(167.76,106.21) v2(167.89,106.78) v2(168.42,107) v2(168.37,106.23) v2(169.29,103.63)
+VID_PLLVDD: length 9.2
  TOP w0.14: RV582.1 v1(199.26,60.76)
  TOP w0.508: CV854.1 201.77,61.93 201.77,62.47 202.05,62.75 v2(202.05,62.89) ; v2(198.27,61.44) 198.65,61.83 RV582.1
  IN6 w0.508: v2(202.05,62.89) 201.85,63.09 201.29,63.09 200.62,62.42 199.24,62.42 v2(198.27,61.44)
  BOTTOM w0.305: v2(202.05,62.89) 202.33,62.89 UV18.AD7
+VLDOIN_1.2V: length 1.5
  BOTTOM w0.127: 284.47,31.36 v1(284.47,32.86)
+VR_CAP: length 26.9
  TOP w0.254: CE40.1 304.46,7.68 303.9,8.24 301.89,8.24 300.99,9.14 300.99,9.59 v2(300.92,9.66) 300.92,10.2 UE3.J1 ; UE3.C10 v2(295.36,18.17)
  IN2 w0.508: v2(300.92,9.66) 300.92,9.4 300.47,8.94 298.6,8.94 298.29,9.25 298.29,9.85 297.67,10.47 292.49,10.47 v2(291.17,11.79)
  IN3 w0.508: v2(295.36,18.17) 294.16,18.17 291.6,15.6 291.6,14.86 291.33,14.59 291.33,11.95 v2(291.17,11.79)
+XS_PLLVDD: length 1
  BOTTOM w0.305: v2(203.44,65.14) 203.44,64.8 UV18.AD8
  vias: v1(205.14,62.98)
A_DE0: length 1.5
  TOP w0.14: RI19.1 326.24,35.79 UI3.16
A_DE1: length 2.7
  TOP w0.14: v1(326.26,38.29) RI20.1 325.74,37.34 325.2,36.79 UI3.18
A_EQ0: length 1.6
  TOP w0.14: UI3.17 325.32,36.29 325.6,36.58 RI15.1
A_EQ1: length 1.6
  TOP w0.14: UI3.15 326.02,35.29 RI16.1
AC1_DISC#: length 129.9
  TOP w0.14: PR1937.1 63.21,8.85 v2(62.46,9.6) ; v2(23.43,21.15) 22.04,21.15 21.9,21.29 PR243.2 ; v2(59.62,19.09) v1(59.06,19.09)
  IN1 w0.099: v2(23.43,21.15) 24.19,20.38 28,20.38 28.26,20.64 33.66,20.64 34.19,21.16 36.07,21.16 37.39,19.84 39.66,19.84 40.98,21.16 47.56,21.16 47.84,20.88 50.61,20.88 50.8,21.07 50.8,21.48 52.2,22.88 54.63,22.88 57.87,19.64 59.06,19.64 v2(59.62,19.09)
  IN2 w0.099: v2(62.46,9.6) 62.46,10.12 61.82,10.76 61.82,11.83 61.17,12.48 61.17,13.55 61.82,14.19 61.82,16.38 61.73,16.46 61.73,18.21 60.41,19.53 60.07,19.53 v2(59.62,19.09)
  IN3 w0.091: v2(36.13,43.74) 36.13,44.71 35.26,45.58 35.26,46.62 34.17,48.18 32.31,51.13 29.66,53.79 29.66,56.16 28.65,57.16 28.65,59.21 28.96,59.51 v2(29.1,59.51)
  IN4 w0.091: v2(36.13,43.74) 34.43,42.03 34.43,39.54 39.26,34.71 44.06,34.71 45.31,33.46 57.58,33.46 59.54,31.5 59.54,26.79 57.45,24.69 57.45,21.26 v2(59.62,19.09)
  BOTTOM w0.14: v2(29.1,59.51) 28.58,58.99 RT5844.2 ; v2(59.62,19.09) 59.45,19.26 58.14,19.26 57.38,18.5 55.54,18.5 55.08,18.97 PR278.1
AC_DIS: length 265
  TOP w0.14: v2(300.16,19.77) UE3.H12 ; PR1920.1 57.42,23.57 PQ1906.2 57.67,22.86 v2(58.12,22.86) 58.63,22.35 v1(59.01,22.35)
  IN5 w0.099: v2(300.16,19.77) 300.13,19.79 294.24,19.79 294.12,19.67 291.31,19.67 289.55,17.9 288.16,17.9 287.38,17.12 276.51,17.12 275.13,15.75 267.95,15.75 265.64,13.44 262.75,13.44 262.45,13.74 257.37,13.74 256.79,13.16 249.48,13.16 246.64,16 215.22,16 214.69,16.53 202.8,16.53 202.43,16.9 180.78,16.9 177.44,13.55 164.3,13.55 163.88,13.97 145.38,13.97 144.31,12.9 142.09,12.9 141.39,12.2 v2(140.17,12.2)
  IN6 w0.089: 101.98,9.12 101.07,9.12 100.97,9.01 99.55,9.01 98.83,9.73 98.32,9.73 97.99,10.06 97.36,10.06 96.85,10.57 95.76,10.57 95.21,10.01 94.99,10.01 94.8,10.21 92.27,10.21 91.99,9.93 90.68,9.93 90.18,10.43 89.61,10.43 88.6,11.44 87.43,11.44 86.23,12.65 80.24,12.65 79.97,12.37 79.24,12.37 79.1,12.23 77.91,12.23 77.77,12.09 76.73,12.09 76.58,12.24 76.58,13.37 76.07,13.88 76.07,15.44 74.18,17.32 73.88,17.32 73.49,17.71
  IN6 w0.099: v2(58.12,22.86) 58.62,22.37 61.29,22.37 61.76,21.89 64.7,21.89 64.99,21.6 69.58,21.6 72.33,18.86 72.33,18.48 72.8,18.01 73.19,18.01 73.49,17.71 ; v2(140.17,12.2) 138.74,12.2 137.88,13.05 123.1,13.05 121.36,11.31 119.15,11.31 118.64,10.81 118.64,10.81 118.01,10.18 115.03,10.18 113.25,8.41 112.43,8.41 111.8,9.04 110.88,9.04 110.33,9.59 106.55,9.59 105.41,8.45 103.96,8.45 103.29,9.12 101.98,9.12
AC_DISC#: length 336.3
  TOP w0.14: v2(12.96,24.55) 13.08,24.55 13.34,24.81 13.94,24.81 14.12,25 14.12,25.91 14.5,26.29 PR218.2 ; v1(23.22,21.87) 22.94,21.6 v2(22.33,21.6) ; UE3.E13 297.36,21.18 v2(296.73,21.81)
  IN1 w0.099: v2(61.71,13.51) 61.71,13.53 61.22,14.02 61.22,14.88 58.76,17.34 58.76,19.1 58.61,19.24 57.7,19.24 54.46,22.48 52.95,22.48 52,21.53 52,20.89 51.32,20.21 47.11,20.21 46.59,20.73 44.83,20.73 44.21,20.11 44.21,18.48 43.38,17.65 32.31,17.65 30.36,19.61 23.37,19.61 22.33,20.66 v2(22.33,21.6)
  IN5 w0.099: v2(61.71,13.51) 61.47,13.51 61.16,13.2 61.16,12.49 63.58,10.07 65.93,10.07 67.61,11.75 68.81,11.75 69.56,12.5 71.46,12.5 72.08,13.12 73.43,13.12 76.72,9.83 77.58,9.83 77.8,10.04 78.08,10.04 78.73,10.7 79.92,10.7 80.25,10.38 81.01,10.38 81.31,10.07 85.26,10.07 85.44,10.25 86.22,10.25 87.69,8.78 89.3,8.78 89.67,8.41 90.66,8.41 90.76,8.51 90.76,8.94 91,9.18 92.34,9.18 93.04,9.88 94.91,9.88 95.21,9.58 95.6,9.58 95.97,9.22 96.47,9.22 96.65,9.4 97.67,9.4 98.39,8.68 100.92,8.68 101.54,9.3 103.34,9.3 104.22,8.42 106.01,8.42 106.91,9.31 108.17,9.31 108.35,9.49 111.44,9.49 112.38,10.43 117.81,10.43 118.46,11.08 121.82,11.08 122.56,11.81 124.26,11.81 124.83,12.37 132.03,12.37 132.61,12.95 139.78,12.95 140.33,13.5 144.06,13.5 145.14,14.58 164.12,14.58 164.55,14.15 177.19,14.15 180.53,17.5 202.68,17.5 203.05,17.13 215.01,17.13 215.41,16.72 248.46,16.72 250.59,14.59 251.99,14.59 252.82,13.76 256.54,13.76 257.12,14.34 262.7,14.34 263,14.04 265.39,14.04 267.73,16.38 274.86,16.38 276.2,17.72 287.13,17.72 287.91,18.51 289.29,18.51 291.06,20.27 292.67,20.27 293.78,21.38 294.26,21.38 295.2,22.32 296.23,22.32 296.69,21.85 296.69,21.85 v2(296.73,21.81)
  IN6 w0.099: v2(22.33,21.6) 19.54,21.6 18.67,22.46 17.47,22.46 16.44,23.49 14.3,23.49 13.24,24.55 v2(12.96,24.55)
  BOTTOM w0.14: PQ220.3 60.04,15.95 60.25,15.74 PR272.1 PR270.1 61.66,15.43 61.51,15.29 59.88,15.29 59.64,15.52 59.13,15.52 58.93,15.72 58.35,15.72 57.63,15.01 57.63,14.68 PQ221.3 58.14,14.81 58.78,14.81 58.97,14.62 58.97,14.23 59.21,13.99 59.21,13.67 59.68,13.19 PQ221.6 59.99,13.19 60.23,13.43 60.23,14 60.46,14.23 61.48,14.23 PC219.1 61.99,14.17 61.71,13.9 v2(61.71,13.51)
