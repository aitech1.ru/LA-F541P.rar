# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_MA7: length 52.1
  IN6 w0.117: v2(151.29,52.87) 150.84,52.42 150.84,51.25 151.36,50.73 151.36,48.87 149.86,47.37 149.86,45.69 137.2,33.03 137.2,29.17 136.72,28.69 136.72,24.51 136.37,24.17 136.37,22.87 136.5,22.74 137.22,22.74 137.35,22.61 137.35,22.37 137.22,22.25 136.31,22.25 136.18,22.12 136.18,21.88 136.31,21.75 v2(137.84,21.75)
  BOTTOM w0.076: UH1.AN1 154,55.1 v1(153.77,54.86) 151.78,52.87 v2(151.29,52.87)
  BOTTOM w0.221: JDIMM1.122 137.62,21.53 v2(137.84,21.75)
DDR_A_MA8: length 52.6
  IN6 w0.117: v2(151.29,53.51) 151.67,53.13 151.67,51.83 152.2,51.3 152.2,48.52 150.75,47.07 150.75,46.8 150.87,46.69 151.28,46.69 151.4,46.57 151.4,46.34 151.28,46.22 150.87,46.22 150.75,46.1 150.75,45.39 138.05,32.68 138.05,31.66 138.22,31.49 138.4,31.49 138.51,31.6 138.51,32.61 138.63,32.73 138.83,32.73 138.98,32.58 138.98,31.59 138.51,31.12 138.17,31.12 138.06,31 138.06,30.77 138.17,30.65 138.48,30.65 138.62,30.51 138.62,28.91 138.5,28.79 138.02,28.79 137.84,28.62 137.84,28.38 137.96,28.27 138.5,28.27 138.62,28.15 138.62,27.47 138.36,27.21 138.36,26.23 v2(137.86,25.73)
  BOTTOM w0.076: v2(151.29,53.51) 151.97,53.51 152.97,54.5 152.97,54.51 153.79,55.33 153.79,59.94 153.71,60.01 153.71,61.24 UH1.AN3
  BOTTOM w0.221: v2(137.86,25.73) 138.37,26.25 JDIMM1.125
DDR_A_MA9: length 52.2
  IN6 w0.117: v2(135.78,24.24) 136.3,24.76 136.3,30.1 136.78,30.58 136.78,33.21 149.43,45.85 149.43,47.54 150.94,49.04 150.94,50.73 150.52,51.14 150.52,54.03 150.77,54.28 150.77,54.84 151.93,56 151.93,59.16 152.05,59.28 152.64,59.28 152.75,59.4 152.75,59.63 152.64,59.75 152.05,59.75 151.93,59.86 151.93,60.1 152.05,60.21 152.64,60.21 152.75,60.33 152.75,60.56 152.64,60.68 152.05,60.68 151.93,60.8 v2(151.93,61.86)
  BOTTOM w0.076: v2(151.93,61.86) 151.61,62.19 UH1.AT4
  BOTTOM w0.221: JDIMM1.121 137.37,26.16 136.37,25.16 136.37,24.83 v2(135.78,24.24)
DDR_A_MA10: length 52.3
  IN6 w0.089: v2(157.41,57.72) 158.4,56.73 158.4,51.12 158.74,50.77 158.74,50.5
  IN6 w0.117: v2(146.47,22.21) 146.26,22 145.4,22 145.28,22.12 145.28,22.35 145.39,22.47 145.84,22.47 145.96,22.59 145.96,22.82 145.84,22.94 145.39,22.94 145.28,23.05 145.28,25.23 146.98,26.93 146.98,30.1 146.57,30.51 146.57,30.96 146.68,31.08 146.85,31.08 146.97,31.19 146.97,31.43 146.85,31.54 146.68,31.54 146.57,31.66 146.57,32.4 146.84,32.67 148.09,32.67 148.95,33.54 148.95,34.82 157.49,43.36 157.49,44.98 158.74,46.23 158.74,50.5
  BOTTOM w0.076: v2(157.41,57.72) 158,58.32 158,60.59 UH1.AH2
  BOTTOM w0.221: v2(146.47,22.21) 146.31,22.21 145.63,21.52 JDIMM1.146
DDR_A_MA11: length 52.9
  IN6 w0.117: v2(151.3,51.61) 151.78,51.13 151.78,48.69 150.33,47.24 150.33,45.56 137.63,32.86 137.63,29 137.14,28.51 137.14,27.83 137.26,27.71 137.84,27.71 137.96,27.58 137.96,27.36 137.85,27.24 137.26,27.24 137.14,27.12 137.14,26.88 137.26,26.77 137.79,26.77 137.93,26.62 137.93,26.41 137.82,26.3 137.26,26.3 137.14,26.18 137.14,24.27 136.8,23.93 136.8,23.44 137.01,23.23 137.63,23.23 v2(137.84,23.02)
  BOTTOM w0.076: v2(151.3,51.61) 154.36,54.67 154.36,60.53 UH1.AN2
  BOTTOM w0.221: JDIMM1.120 137.12,22.39 137.76,23.02 v2(137.84,23.02)
DDR_A_MA12: length 51.1
  IN6 w0.117: v2(135.78,25.59) 135.78,30.18 136.36,30.76 136.36,33.38 149,46.02 149,47.7 150.52,49.22 150.52,50.55 150.2,50.86 150.2,54.22 150.57,54.58 150.57,55.17 151.5,56.1 151.5,58.7 151.39,58.82 151.15,58.82 151.04,58.7 151.04,57.06 150.9,56.92 150.69,56.92 150.57,57.04 150.57,59.17 v2(150.13,59.61)
  BOTTOM w0.076: UH1.AU4 150.31,61.74 150.31,60.05 150.29,60.04 150.29,59.77 v2(150.13,59.61)
  BOTTOM w0.221: v2(135.78,25.59) 136.07,25.59 136.88,26.4 JDIMM1.119
DDR_A_MA13: length 55.5
  IN6 w0.117: v2(159.92,55.88) 160.02,55.88 164.59,51.31 164.59,43.12 155.55,34.09 155.55,32.56 153.02,30.03 153.02,29 153.32,28.7 153.32,26.48 152.42,25.57 152.42,23.87 152.54,23.74 152.67,23.74 152.79,23.62 152.79,23.29 152.67,23.17 151.61,23.17 151.48,23.04 151.48,22.83 151.61,22.7 152.67,22.7 152.78,22.58 152.78,22.3 152.66,22.17 v2(150.74,22.17)
  BOTTOM w0.076: UH1.AE3 160.94,61.54 161.09,61.39 161.09,57.05 v2(159.92,55.88)
  BOTTOM w0.221: v2(150.74,22.17) 149.57,21 149.12,21 148.64,20.52 JDIMM1.158
DDR_A_PAR: length 52
  IN6 w0.089: v2(157.41,55.24) 157.58,55.24 157.9,54.93 157.9,50.5
  IN6 w0.117: 157.9,50.5 157.9,46.58 156.65,45.32 156.65,43.75 145.35,32.45 145.35,30.35 145.47,30.23 145.59,30.23 145.71,30.12 145.71,29.88 145.59,29.77 145.47,29.77 145.35,29.65 145.35,29.42 145.47,29.3 145.59,29.3 145.71,29.18 145.71,28.95 145.59,28.83 145.47,28.83 145.35,28.71 145.35,28.48 145.47,28.36 145.59,28.36 145.71,28.25 145.71,28.01 145.59,27.9 145.47,27.9 145.35,27.78 145.35,27.55 145.47,27.43 145.59,27.43 145.71,27.31 145.71,27.08 145.59,26.96 145.47,26.96 145.35,26.85 145.35,26.5 144.36,25.51 144.36,23.59 144.48,23.48 v2(144.8,23.48)
  BOTTOM w0.076: UH1.AG3 158.74,61.24 158.74,57.64 158.31,57.21 158.31,56.15 v2(157.41,55.24)
  BOTTOM w0.221: JDIMM1.143 142.89,26.87 143.09,26.67 143.09,25.11 144.72,23.48 v2(144.8,23.48)
DDR_A_RAS#: length 52.7
  IN6 w0.089: 160.67,50.5 159.01,52.16 159.01,61.25 v2(159.48,61.72)
  IN6 w0.117: 160.67,50.5 160.67,45.43 159.42,44.18 159.42,42.46 150.88,33.92 150.88,32.68 148.91,30.71 148.91,26.13 148.01,25.23 148.01,22.83 148.28,22.56 148.28,21.68 148.4,21.56 148.77,21.56 148.89,21.68 148.89,21.92 v2(149.18,22.21)
  BOTTOM w0.076: UH1.AH4 158.61,61.88 159.33,61.88 v2(159.48,61.72)
  BOTTOM w0.221: v2(149.18,22.21) 148.75,22.21 147.14,20.6 JDIMM1.152
DDR_A_WE#: length 52
  IN6 w0.089: v2(159.48,62.39) 160.12,61.75 160.12,61.28 159.19,60.34 159.19,52.4 161.09,50.5
  IN6 w0.117: v2(149.18,23.48) 148.43,24.23 148.43,25.06 149.33,25.96 149.33,30.54 151.3,32.51 151.3,33.75 159.84,42.29 159.84,44 161.09,45.26 161.09,50.5
  BOTTOM w0.076: UH1.AG4 159.28,62.19 v2(159.48,62.39)
  BOTTOM w0.221: JDIMM1.151 146.87,26.7 147.03,26.54 147.04,25.86 147.28,25.62 147.28,25.02 148.82,23.48 v2(149.18,23.48)
DDR_B_ACT#: length 98
  IN3 w0.089: 151.3,57.04 151.48,57.22 151.48,59.85 151.66,60.02 151.66,61.51 151.55,61.62 151.55,62.08 152.36,62.9 152.36,63.93 152.64,64.21 152.64,65.23 v2(152.1,65.77)
  IN3 w0.122: v2(212.07,21.51) 211.42,21.51 210.98,21.94 210.98,23.97 210.66,24.3 210.66,25.75 210.39,26.02 209.33,26.02 209.21,26.14 209.21,26.62 209.09,26.74 208.85,26.74 208.72,26.62 208.72,26.14 208.6,26.02 208.22,26.02 207.67,26.57 207.67,26.74 208,27.08 208,27.25 207.82,27.42 207.65,27.42 207.32,27.09 207.15,27.09 205.44,28.8 203.72,28.8 202.47,30.05 199.91,30.05 198.42,31.53 189.14,31.53 188.16,32.51 169.88,32.51 168.95,33.43 165.17,33.43 151.21,47.38 151.21,50.26 150.86,50.61 150.86,56.6 151.3,57.04
  BOTTOM w0.089: v2(152.1,65.77) 151.97,65.77 UH1.AT9
  BOTTOM w0.221: JDIMM2.114 211.94,21.38 v2(212.07,21.51)
DDR_B_ALERT#: length 90.6
  IN3 w0.089: v2(153.01,64.38) 152.57,62.89 152.57,62.7 152.36,60.92 151.79,58.87 151.79,56.69 151.69,56.27 151.69,51.41 151.66,50.81 151.66,50.5
  IN3 w0.122: 151.66,50.5 151.66,49.62 151.81,48.58 152.24,47.01 152.29,46.91 164.2,35 164.37,34.89 164.74,34.77 173.34,32.93 188.23,32.93 191.44,31.96 198.61,31.96 203.5,30.11 205.03,29.49 206.1,28.93 210.35,26.57 210.66,26.34 211.04,25.96 211.36,24.63 211.69,23.47 211.74,23.34 v2(212.08,22.95)
  BOTTOM w0.076: UH1.AR8 152.59,64.8 v2(153.01,64.38)
  BOTTOM w0.221: v2(212.08,22.95) 212.55,22.48 212.55,20.78 212.43,20.65 JDIMM2.116
DDR_B_BG0: length 97.6
  IN3 w0.089: 151.37,63.66 151.85,64.14 152.25,64.14 152.47,64.36 152.47,64.78 v2(152.12,65.13)
  IN3 w0.122: 151.37,63.66 150.7,62.99 150.7,58.32 149.99,57.61 149.99,47.4 164.81,32.58 168.6,32.58 169.54,31.63 173.64,31.63 174.84,30.43 176.99,30.43 177.11,30.55 177.11,31.34 177.23,31.46 177.47,31.46 177.6,31.34 177.6,30.55 177.72,30.43 177.96,30.43 178.08,30.55 178.08,31.34 178.21,31.46 178.45,31.46 178.57,31.34 178.57,30.55 178.78,30.34 184.5,30.34 184.72,30.55 197.21,30.55 199.4,28.36 202.94,28.36 203.36,27.94 205.09,27.94 208.71,24.32 v2(210.23,24.32)
  BOTTOM w0.076: UH1.AR9 152.44,65.45 v2(152.12,65.13)
  BOTTOM w0.221: JDIMM2.115 212.18,26.56 211.38,25.77 211.38,25.4 210.3,24.32 v2(210.23,24.32)
DDR_B_BG1: length 100.3
  IN3 w0.122: v2(151.98,63.76) 151.18,62.96 151.18,57.78 150.41,57.01 150.41,50.08 150.54,49.96 150.67,49.96 150.79,49.84 150.79,49.6 150.67,49.47 150.54,49.47 150.41,49.35 150.41,49.11 150.54,48.99 150.67,48.99 150.79,48.86 150.79,47.21 151.71,46.29 164.99,33 168.78,33 169.72,32.06 173.81,32.06 175.01,30.86 175.51,30.86 176.73,32.08 181.43,32.08 181.55,31.96 181.55,31.53 181.67,31.41 181.91,31.41 182.04,31.53 182.04,31.96 182.16,32.08 182.4,32.08 182.52,31.96 182.52,31.53 182.65,31.41 182.89,31.41 183.01,31.53 183.01,31.96 183.13,32.08 187.99,32.08 188.11,31.96 188.11,31.75 187.95,31.59 184.76,31.59 184.64,31.47 184.64,31.23 184.76,31.1 198.24,31.1 200.56,28.79 203.12,28.79 203.54,28.37 205.27,28.37 208.04,25.59 v2(210.22,25.59)
  BOTTOM w0.076: v2(151.98,63.76) 152.37,64.15 UH1.AR7
  BOTTOM w0.221: JDIMM2.113 211.67,26.78 210.48,25.59 v2(210.22,25.59)
DDR_B_BS0: length 99
  IN3 w0.089: v2(158.5,65.12) 158.87,64.76 158.87,64.3 158.72,64.15 158.72,60.41 159.17,59.97 159.17,54.97 159.56,54.57 159.56,52.82 159.96,52.42 160.46,52.42 162.18,50.7
  IN3 w0.122: 162.18,50.7 162.86,50.01 162.86,49.84 162.48,49.45 162.48,49.28 162.65,49.11 162.82,49.11 163.21,49.49 163.38,49.49 163.55,49.32 163.55,49.15 163.17,48.76 163.17,48.59 163.34,48.42 163.51,48.42 163.9,48.8 164.07,48.8 169.27,43.61 172.09,43.61 172.98,42.72 195.18,42.72 197.21,40.69 211.9,40.69 221.37,31.22 221.37,28.01 221.63,27.75 221.63,22.5 v2(222.65,21.48)
  BOTTOM w0.076: UH1.AH8 158.37,65.12 v2(158.5,65.12)
  BOTTOM w0.221: v2(222.65,21.48) 222.65,20.74 222.93,20.47 JDIMM2.150
DDR_B_BS1: length 102.4
  IN3 w0.089: v2(157.59,65.09) 157.97,64.71 157.97,64.01 158.37,63.61 158.37,61.48 158.14,61.25 158.14,60.49 158.77,59.86 158.77,54.66 159.09,54.35 159.09,52.43 160.81,50.71
  IN3 w0.122: v2(220.77,25.54) 220.77,26.44 220.51,26.7 220.51,30.87 211.54,39.84 196.86,39.84 194.83,41.87 172.62,41.87 171.74,42.75 168.91,42.75 165.56,46.11 165.39,46.11 165.22,45.93 165.22,45.76 167.81,43.17 167.81,43 167.63,42.83 167.46,42.83 160.81,49.48 160.81,49.64 160.93,49.76 161.31,49.76 161.43,49.88 161.43,50.12 161.31,50.25 160.93,50.25 160.81,50.37 160.81,50.71
  BOTTOM w0.076: v2(157.59,65.09) 157.95,65.45 UH1.AH9
  BOTTOM w0.221: JDIMM2.145 221.67,27.09 221.51,26.93 221.41,26.93 220.77,26.3 v2(220.77,25.54)
DDR_B_CAS#: length 104
  IN3 w0.089: v2(160.33,65.13) 159.95,64.75 159.95,64.33 160.48,63.8 160.48,61.23
  IN3 w0.122: v2(225,23.01) 224.58,23.43 224.58,30.36 224.24,30.69 224.24,32.3 213.06,43.48 198.37,43.48 195.75,46.1 174.98,46.1 173.37,47.71 173.2,47.71 173.02,47.54 173.02,47.36 173.33,47.06 173.33,46.91 173.13,46.71 172.99,46.71 172.33,47.36 172.33,47.54 172.85,48.05 172.85,48.23 172.32,48.76 172.14,48.76 171.28,47.89 171.1,47.89 170.93,48.06 170.93,48.24 171.8,49.1 171.8,49.28 171.63,49.45 171.45,49.45 170.59,48.58 170.41,48.58 170.24,48.75 170.24,48.93 171.11,49.79 171.11,49.97 170.82,50.26 168.86,50.26 165.38,53.73 164.53,53.73 161.52,56.74 161.52,60.19 160.48,61.23
  BOTTOM w0.076: UH1.AF8 160,64.8 v2(160.33,65.13)
  BOTTOM w0.221: JDIMM2.156 224.43,22.43 v2(225,23.01)
DDR_B_D0: length 90.2
  IN1 w0.079: v2(135.54,66.6) 134.99,66.6 133.29,64.9 133.29,45.94 147.03,32.2 155.78,32.2 156.6,31.38 156.6,31.27 156.33,31 156.33,30.89 156.44,30.78 156.55,30.78 156.83,31.05 156.94,31.05 158.76,29.22 158.76,28.73 159.38,28.12 160.67,28.12 162.37,26.41 174.36,26.41 175.02,25.74 176.33,25.74 179.47,22.61 183.54,22.61 184.06,23.12 184.27,23.12 184.43,22.96 184.43,22.79 v2(184.16,22.52)
  BOTTOM w0.076: UH1.BT11 136.72,66.69 136.56,66.53 135.62,66.53 v2(135.54,66.6)
  BOTTOM w0.14: v2(184.16,22.52) 184.24,22.52 185.43,21.34 JDIMM2.8
DDR_B_D1: length 91.1
  IN1 w0.079: v2(183.28,25.03) 183.04,25.27 182.31,25.27 182.23,25.35 182.23,25.71 182.15,25.79 182,25.79 181.92,25.71 181.92,25.35 181.84,25.27 181.68,25.27 181.6,25.35 181.6,25.71 181.52,25.79 181.37,25.79 181.29,25.71 181.29,25.35 181.21,25.27 180.63,25.27 180.55,25.19 180.55,24.86 180.48,24.79 180.32,24.79 180.24,24.86 180.24,25.19 180.16,25.27 180,25.27 179.92,25.19 179.92,24.86 179.85,24.79 179.69,24.79 179.61,24.86 179.61,25.19 179.53,25.27 179.12,25.27 178.92,25.47 178.92,25.9 178.8,26.02 175.14,26.02 174.47,26.69 162.49,26.69 160.76,28.42 159.47,28.42 159.04,28.85 159.04,29.34 157.45,30.94 157.45,31.02 157.83,31.4 157.83,31.52 157.72,31.63 157.61,31.63 157.22,31.24 157.14,31.24 155.9,32.49 147.14,32.49 133.57,46.06 133.57,64.73 134.4,65.56 v2(135.05,65.56)
  BOTTOM w0.076: UH1.BR11 137.81,66.4 137.07,66.4 137.03,66.36 136.05,66.36 135.25,65.56 v2(135.05,65.56)
  BOTTOM w0.14: JDIMM2.7 185.18,26.93 v2(183.28,25.03)
DDR_B_D2: length 89.5
  IN1 w0.079: v2(187.01,23.12) 186.29,23.83 186.29,25.68 183.62,28.35 176.13,28.35 175.64,28.84 163.58,28.84 157.79,34.63 149.31,34.63 149.24,34.71 149.24,34.95 149.16,35.02 149,35.02 148.92,34.94 148.92,34.71 148.84,34.63 148.68,34.63 148.61,34.71 148.61,35.05 148.53,35.13 148.37,35.13 148.29,35.05 148.29,34.71 148.21,34.63 148.03,34.63 136.16,46.5 136.16,55.79 135.76,56.19 135.76,57.61 137.59,59.44 137.59,62.67 135.92,64.34 v2(135.74,64.34)
  BOTTOM w0.076: v2(135.74,64.34) 136.06,64.34 136.53,64.81 136.94,64.81 137.35,65.22 138,65.22 UH1.BR8
  BOTTOM w0.14: JDIMM2.20 188.43,21.7 v2(187.01,23.12)
DDR_B_D3: length 89.8
  IN1 w0.079: v2(187.01,24.39) 186.58,24.82 186.58,25.8 183.63,28.74 178.1,28.74 177.19,29.66 163.16,29.66 157.9,34.92 152.01,34.92 151.52,35.41 151.28,35.41 151.2,35.33 151.2,34.99 151.13,34.91 150.97,34.91 150.89,34.99 150.89,35.33 150.81,35.41 150.63,35.41 150.55,35.33 150.55,34.99 150.47,34.91 150.32,34.91 150.24,34.99 150.24,35.33 150.16,35.41 150,35.41 149.92,35.33 149.92,34.99 149.84,34.91 149.69,34.91 149.61,34.99 149.61,35.33 149.53,35.41 147.65,35.41 136.44,46.62 136.44,55.74 135.94,56.25 135.94,57.56 137.76,59.37 137.76,63.85 v2(136.39,65.21)
  BOTTOM w0.076: v2(136.39,65.21) 136.63,64.97 136.87,64.97 137.3,65.4 138.46,65.4 UH1.BP8
  BOTTOM w0.14: v2(187.01,24.39) 188.07,25.45 188.07,26.21 188.68,26.81 JDIMM2.21
DDR_B_D4: length 91.3
  IN1 w0.079: v2(184.31,21.25) 184.19,21.25 183.17,22.28 179.4,22.28 176.25,25.43 174.94,25.43 174.24,26.13 162.26,26.13 160.57,27.81 159.28,27.81 158.48,28.62 158.48,29.11 157.11,30.48 156.34,30.48 155.87,30.95 155.87,31.06 156.14,31.33 156.14,31.43 156.03,31.54 155.91,31.54 155.65,31.28 155.54,31.28 155.43,31.39 155.43,31.5 155.63,31.7 155.63,31.81 155.52,31.92 155.4,31.92 155.21,31.72 155.09,31.72 154.9,31.92 146.91,31.92 133.01,45.82 133.01,65.23 134.93,67.15 v2(135.82,67.15)
  BOTTOM w0.076: v2(135.82,67.15) 136.24,66.73 136.53,66.73 136.78,66.98 138.46,66.98 UH1.BP11
  BOTTOM w0.14: JDIMM2.4 184.43,21.12 184.31,21.24 v2(184.31,21.25)
DDR_B_D5: length 91.5
  IN1 w0.079: v2(136.42,67.12) 136.42,66.81 135.63,66.02 135.63,65.63 135.17,65.17 134.41,65.17 133.85,64.61 133.85,46.17 147.26,32.77 156.34,32.77 157.19,31.91 157.87,31.91 158.38,31.4 158.38,31.24 158.02,30.88 158.02,30.77 158.13,30.65 158.24,30.65 158.45,30.86 158.57,30.86 158.68,30.75 158.68,30.65 158.46,30.43 158.46,30.32 158.57,30.21 158.69,30.21 158.87,30.4 159,30.4 159.13,30.27 159.13,30.15 158.93,29.95 158.93,29.86 159.32,29.46 159.32,28.97 159.56,28.73 160.85,28.73 162.61,26.97 174.59,26.97 175.26,26.31 179.12,26.31 179.21,26.22 179.21,25.68 179.27,25.61 179.43,25.61 179.52,25.71 179.52,26.22 179.6,26.3 179.76,26.3 179.84,26.22 179.84,25.68 179.9,25.61 180.06,25.61 180.15,25.71 180.15,26.22 180.23,26.3 180.39,26.3 180.47,26.22 180.47,25.68 180.53,25.61 180.71,25.61 180.79,25.69 180.79,26.21 180.88,26.3 v2(183.28,26.3)
  BOTTOM w0.076: v2(136.42,67.12) 136.48,67.18 138.91,67.18 UH1.BN11
  BOTTOM w0.14: v2(183.28,26.3) 183.53,26.3 184.18,26.94 JDIMM2.3
DDR_B_D6: length 88.7
  IN1 w0.079: v2(187.01,21.85) 186,22.85 186,25.58 183.51,28.07 176.01,28.07 175.52,28.56 163.47,28.56 157.67,34.35 147.91,34.35 135.88,46.38 135.88,52.57 135.93,52.61 135.93,55.47 135.57,55.82 135.57,57.66 137.4,59.49 137.4,62.59 136.02,63.97 v2(135.32,63.97)
  BOTTOM w0.14: UH1.BT9 136.35,65.9 135.13,64.68 135.13,64.16 v2(135.32,63.97) ; JDIMM2.16 187.43,21.43 v2(187.01,21.85)
DDR_B_D7: length 90.2
  IN1 w0.079: v2(187.01,25.66) 187.01,25.77 183.75,29.03 178.22,29.03 177.3,29.94 163.28,29.94 158,35.22 155.3,35.22 155.22,35.3 155.22,35.8 155.14,35.88 154.98,35.88 154.9,35.8 154.9,35.3 154.83,35.22 154.67,35.22 154.59,35.3 154.59,35.8 154.51,35.88 154.35,35.88 154.27,35.8 154.27,35.3 154.2,35.22 154.04,35.22 153.96,35.3 153.96,35.8 153.88,35.88 153.72,35.88 153.64,35.8 153.64,35.3 153.57,35.22 153.41,35.22 153.33,35.3 153.33,35.8 153.25,35.88 153.09,35.88 153.01,35.8 153.01,35.3 152.94,35.22 152.78,35.22 152.7,35.3 152.7,35.8 152.62,35.88 152.46,35.88 152.38,35.8 152.38,35.3 152.31,35.22 152.13,35.22 151.5,35.84 147.62,35.84 136.73,46.73 136.73,55.7 136.13,56.29 136.13,57.46 137.96,59.28 137.96,64.4 v2(136.88,65.48)
  BOTTOM w0.076: UH1.BN8 139.11,65.4 138.76,65.4 138.59,65.57 136.97,65.57 v2(136.88,65.48)
  BOTTOM w0.14: v2(187.01,25.66) 187.68,26.33 JDIMM2.17
DDR_B_D8: length 90.6
  IN1 w0.079: v2(189.42,23.12) 188.66,23.88 188.66,25.2 184.06,29.79 178.62,29.79 177.71,30.71 163.59,30.71 157.03,37.27 154.53,37.27 154.45,37.19 154.45,36.96 154.37,36.88 154.22,36.88 154.13,36.97 154.13,37.19 154.06,37.27 153.87,37.27 153.31,36.7 147.84,36.7 137.49,47.05 137.49,56.2 140.55,59.26 140.55,60.54 139.48,61.62 139.48,63.21 139.83,63.57 139.83,65.61 140.66,66.43 140.66,66.55 v2(141.17,67.07)
  BOTTOM w0.089: UH1.BL11 141.09,67.07 v2(141.17,67.07)
  BOTTOM w0.14: v2(189.42,23.12) 190.01,22.53 190.01,22.32 190.43,21.9 JDIMM2.28
DDR_B_D9: length 88.5
  IN1 w0.079: v2(140.38,65.51) 140.06,65.19 140.06,63.45 139.64,63.02 139.64,61.72 140.73,60.63 140.73,59.2 137.78,56.24 137.78,47.17 147.96,36.99 148.14,36.99 148.22,37.06 148.22,37.48 148.3,37.55 148.45,37.55 148.53,37.48 148.53,37.06 148.61,36.99 148.77,36.99 148.85,37.06 148.85,37.47 148.93,37.55 149.08,37.55 149.16,37.47 149.16,37.06 149.24,36.99 153.15,36.99 153.71,37.55 157.15,37.55 163.71,30.99 177.84,30.99 178.76,30.08 184.18,30.08 188.94,25.32 188.94,24.87 v2(189.42,24.39)
  BOTTOM w0.089: v2(140.38,65.51) 140.38,65.44 UH1.BL8
  BOTTOM w0.14: JDIMM2.29 190.68,26.42 190.02,25.77 190.02,24.99 v2(189.42,24.39)
DDR_B_D10: length 89.4
  IN1 w0.079: v2(142.05,65.12) 141.67,64.74 141.67,64.35 143.04,62.98 143.04,59 140.82,56.78 140.82,55.39 140.52,55.09 140.52,47.86 148.4,39.98 158.16,39.98 164.62,33.52 181.51,33.52 181.59,33.44 181.59,33.02 181.67,32.94 181.82,32.94 181.9,33.02 181.9,33.44 181.98,33.52 182.16,33.52 182.24,33.44 182.24,32.76 182.32,32.68 182.48,32.68 182.56,32.76 182.56,33.44 182.63,33.52 182.79,33.52 182.87,33.44 182.87,32.76 182.95,32.68 186.36,32.68 189.7,29.34 189.7,28.41 192.15,25.96 192.15,24.81 v2(192.57,24.39)
  BOTTOM w0.089: UH1.BJ8 141.72,64.8 v2(142.05,65.12)
  BOTTOM w0.14: JDIMM2.41 193.67,25.49 v2(192.57,24.39)
DDR_B_D11: length 90.6
  IN1 w0.079: v2(192.57,23.12) 192.29,22.84 192,22.84 191.93,22.91 191.93,23.75 191.87,23.82 191.87,25.84 188.84,28.87 188.84,29.16 186.72,31.28 186.72,31.39 186.93,31.6 186.93,31.71 186.82,31.82 186.7,31.82 186.5,31.61 186.38,31.61 186.27,31.73 186.27,31.84 186.48,32.05 186.48,32.16 186.37,32.27 186.26,32.27 186.05,32.06 185.94,32.06 185.6,32.4 181.59,32.4 180.76,33.24 164.5,33.24 158.04,39.7 148.28,39.7 140.24,47.74 140.24,55.24 140.64,55.64 140.64,56.84 142.87,59.07 142.87,62.91 141.5,64.28 141.5,65.23 v2(142.05,65.77)
  BOTTOM w0.089: v2(142.05,65.77) 141.91,65.77 UH1.BJ10
  BOTTOM w0.14: JDIMM2.42 193.92,21.76 v2(192.57,23.12)
DDR_B_D12: length 90.7
  IN1 w0.079: v2(140.38,67.08) 140.38,66.53 139.56,65.71 139.56,64.62 139.12,64.18 139.12,63.43 139.3,63.24 139.3,61.55 140.37,60.49 140.37,59.31 137.21,56.15 137.21,46.93 147.75,36.4 154.66,36.4 154.75,36.48 154.75,36.88 154.83,36.96 154.99,36.96 155.07,36.89 155.07,36.52 155.14,36.45 155.3,36.45 155.38,36.53 155.38,36.9 155.46,36.98 156.92,36.98 163.48,30.43 177.57,30.43 178.49,29.51 183.95,29.51 188.38,25.08 188.38,22.89 v2(189.42,21.85)
  BOTTOM w0.089: v2(140.38,67.08) 140.38,67.15 UH1.BL12
  BOTTOM w0.14: v2(189.42,21.85) 189.43,21.84 JDIMM2.24
DDR_B_D13: length 87.8
  IN1 w0.079: v2(140.42,64.69) 140.42,63.45 139.81,62.84 139.81,61.79 140.9,60.7 140.9,59.13 138.06,56.29 138.06,47.29 147.51,37.84 149.48,37.84 149.55,37.76 149.55,37.52 149.63,37.44 149.79,37.44 149.87,37.52 149.87,37.76 149.95,37.84 150.11,37.84 150.18,37.76 150.18,37.35 150.26,37.27 150.42,37.27 150.5,37.35 150.5,37.76 150.58,37.84 150.74,37.84 150.81,37.76 150.81,37.35 150.89,37.27 151.05,37.27 151.13,37.35 151.13,37.76 151.21,37.84 151.37,37.84 151.44,37.76 151.44,37.35 151.52,37.27 151.68,37.27 151.76,37.35 151.76,37.76 151.84,37.84 152,37.84 152.07,37.76 152.07,37.35 152.15,37.27 152.31,37.27 152.39,37.35 152.39,37.76 152.47,37.84 152.63,37.84 152.7,37.76 152.7,37.35 152.78,37.27 152.94,37.27 153.02,37.35 153.02,37.76 153.1,37.84 157.27,37.84 163.83,31.28 178,31.28 178.91,30.36 184.3,30.36 189,25.66 v2(189.42,25.66)
  BOTTOM w0.089: v2(140.42,64.69) 140.42,64.5 UH1.BL7
  BOTTOM w0.14: JDIMM2.25 189.68,25.91 v2(189.42,25.66)
DDR_B_D14: length 90.8
  IN1 w0.079: v2(192.57,21.85) 192.19,21.85 191.64,22.4 191.64,23.65 191.59,23.7 191.59,25.73 188.56,28.76 188.56,29.04 185.48,32.12 181.46,32.12 180.62,32.96 180.44,32.96 180.37,32.88 180.37,32.52 180.29,32.44 180.13,32.44 180.05,32.52 180.05,32.88 179.97,32.96 179.81,32.96 179.74,32.88 179.74,32.52 179.66,32.44 179.5,32.44 179.42,32.52 179.42,32.88 179.34,32.96 164.39,32.96 157.92,39.42 148.16,39.42 139.96,47.62 139.96,55.41 140.44,55.89 140.44,56.87 142.7,59.14 142.7,62.84 141.33,64.21 141.33,65.35 141.63,65.65 141.63,66.01 v2(142.05,66.42)
  BOTTOM w0.089: UH1.BJ11 141.91,66.42 v2(142.05,66.42)
  BOTTOM w0.14: JDIMM2.38 192.92,21.49 v2(192.57,21.85)
DDR_B_D15: length 89
  IN1 w0.079: v2(142.05,64.47) 143.2,63.31 143.2,58.93 141.01,56.74 141.01,55.18 140.8,54.97 140.8,52.05 140.9,51.95 141.34,51.95 141.43,51.86 141.43,51.73 141.34,51.64 140.9,51.64 140.8,51.55 140.8,51.42 140.9,51.32 141.34,51.32 141.43,51.23 141.43,51.1 141.34,51.01 140.9,51.01 140.8,50.92 140.8,47.97 148.51,40.27 158.27,40.27 164.74,33.8 183.11,33.8 183.19,33.72 183.19,33.03 183.25,32.97 183.43,32.97 183.5,33.04 183.5,33.74 183.56,33.8 183.76,33.8 183.82,33.74 183.82,33.04 183.89,32.97 184.06,32.97 184.13,33.04 184.13,33.73 184.2,33.8 184.38,33.8 184.45,33.73 184.45,33.04 184.52,32.97 184.7,32.97 184.76,33.03 184.76,33.44 184.84,33.52 185.01,33.52 185.08,33.45 185.08,33.03 185.14,32.97 186.47,32.97 189.98,29.46 189.98,28.53 192.57,25.94 v2(192.57,25.66)
  BOTTOM w0.089: UH1.BJ7 141.72,64.15 v2(142.05,64.47)
  BOTTOM w0.14: JDIMM2.37 192.68,25.76 v2(192.57,25.66)
DDR_B_D16: length 93
  IN1 w0.079: v2(194.93,23.12) 194.66,22.84 193.78,22.84 193.24,23.38 193.24,25.95 190.47,28.73 190.47,29.66 186.67,33.45 185.76,33.45 184.93,34.29 164.94,34.29 158.47,40.75 148.71,40.75 141.63,47.83 141.63,48.09 141.55,48.17 141.38,48.17 141.3,48.25 141.3,48.41 141.38,48.48 141.55,48.48 141.63,48.56 141.63,48.74 141.55,48.82 141.37,48.82 141.29,48.9 141.29,49.06 141.37,49.14 141.55,49.14 141.63,49.22 141.63,49.37 141.55,49.45 141.37,49.45 141.29,49.53 141.29,49.69 141.37,49.77 141.55,49.77 141.63,49.85 141.63,50 141.55,50.08 141.37,50.08 141.29,50.16 141.29,50.32 141.37,50.4 141.55,50.4 141.63,50.48 141.63,52.2 141.21,52.62 141.21,56.7 143.37,58.86 143.37,63.73 143.08,64.02 143.08,64.68 143.33,64.93 143.33,66.51 v2(143.87,67.06)
  BOTTOM w0.089: UH1.BG11 143.73,67.06 v2(143.87,67.06)
  BOTTOM w0.14: JDIMM2.50 195.92,22.12 v2(194.93,23.12)
DDR_B_D17: length 92.7
  IN1 w0.079: v2(194.93,24.39) 194.49,24.83 194.49,25.11 190.75,28.85 190.75,29.78 186.79,33.73 185.88,33.73 185.04,34.57 165.05,34.57 158.59,41.03 151.37,41.03 151.3,41.1 151.3,41.63 151.25,41.68 151.04,41.68 150.98,41.62 150.98,41.09 150.93,41.03 150.71,41.03 150.65,41.09 150.65,41.63 150.6,41.68 150.39,41.68 150.33,41.62 150.33,41.08 150.28,41.03 150.07,41.03 150.02,41.08 150.02,41.63 149.97,41.68 149.76,41.68 149.7,41.62 149.7,41.1 149.64,41.03 149.45,41.03 149.39,41.09 149.39,41.62 149.34,41.68 149.13,41.68 149.07,41.62 149.07,41.08 149.02,41.03 148.83,41.03 148.76,41.1 148.76,41.6 148.68,41.68 148.19,41.68 141.92,47.95 141.92,52.33 141.43,52.82 141.43,56.68 143.54,58.79 143.54,63.8 143.25,64.09 143.25,64.61 143.51,64.87 143.51,66.06 v2(143.87,66.42)
  BOTTOM w0.089: UH1.BG10 143.74,66.42 v2(143.87,66.42)
  BOTTOM w0.14: v2(194.93,24.39) 195.67,25.13 JDIMM2.49
DDR_B_D18: length 93.6
  IN1 w0.079: v2(144.79,67.06) 145.33,66.51 145.33,65.02 145.56,64.79 145.56,64.17 146.1,63.63 146.1,57.33 144.29,55.53 144.29,51.18 144.98,50.5 144.98,49.93 147.64,47.26 147.64,47.15 147.41,46.91 147.41,46.8 147.52,46.69 147.63,46.69 147.87,46.93 147.98,46.93 148.09,46.81 148.09,46.7 147.85,46.47 147.85,46.36 147.96,46.24 148.07,46.24 148.31,46.48 148.42,46.48 148.53,46.37 148.53,46.26 148.3,46.02 148.3,45.91 148.41,45.8 148.52,45.8 148.76,46.03 148.87,46.03 149.22,45.68 158.28,45.68 166.38,37.58 186.26,37.58 187.12,36.72 188.62,36.72 194.78,30.57 194.78,29.38 195.65,28.5 196.22,28.5 198.38,26.33 198.9,26.33 199.56,25.67 199.56,22.79 v2(198.61,21.85)
  BOTTOM w0.089: v2(144.79,67.06) 144.64,67.06 UH1.BF11
  BOTTOM w0.14: JDIMM2.62 198.92,21.54 v2(198.61,21.85)
DDR_B_D19: length 92.2
  IN1 w0.079: v2(144.77,65.13) 144.77,65.01 145.16,64.62 145.16,64.1 145.76,63.5 145.76,57.47 143.96,55.66 143.96,50.95 144.41,50.5 144.41,49 148.72,44.68 149.02,44.68 149.1,44.76 149.1,45.02 149.18,45.1 149.33,45.1 149.41,45.02 149.41,44.76 149.49,44.68 149.65,44.68 149.73,44.76 149.73,45.02 149.81,45.1 149.96,45.1 150.04,45.02 150.04,44.76 150.12,44.68 150.28,44.68 150.36,44.76 150.36,45.02 150.44,45.1 150.59,45.1 150.67,45.02 150.67,44.76 150.75,44.68 150.91,44.68 150.99,44.76 150.99,45.02 151.07,45.1 151.22,45.1 151.3,45.02 151.3,44.76 151.38,44.68 151.54,44.68 151.62,44.76 151.62,45.02 151.7,45.1 151.85,45.1 151.93,45.02 151.93,44.76 152.01,44.68 152.17,44.68 152.25,44.76 152.25,45.02 152.33,45.1 152.48,45.1 152.56,45.02 152.56,44.76 152.64,44.68 152.8,44.68 152.88,44.76 152.88,45.02 152.96,45.1 153.11,45.1 153.19,45.02 153.19,44.76 153.27,44.68 153.43,44.68 153.51,44.76 153.51,45.02 153.59,45.1 153.74,45.1 153.82,45.02 153.82,44.76 153.9,44.68 154.06,44.68 154.14,44.76 154.14,45.02 154.22,45.1 154.37,45.1 154.45,45.02 154.45,44.76 154.53,44.68 154.69,44.68 154.77,44.76 154.77,45.02 154.85,45.1 155,45.1 155.08,45.02 155.08,44.76 155.16,44.68 155.32,44.68 155.4,44.76 155.4,45.02 155.48,45.1 155.63,45.1 155.71,45.02 155.71,44.76 155.79,44.68 158.45,44.68 166.14,37 186.05,37 186.89,36.16 188.35,36.16 194.21,30.3 194.21,29.15 195.42,27.94 195.98,27.94 198.31,25.61 v2(198.61,25.61)
  BOTTOM w0.089: v2(144.77,65.13) 144.67,65.13 UH1.BF8
  BOTTOM w0.14: v2(198.61,25.61) 199.18,26.18 JDIMM2.63
DDR_B_D20: length 90.7
  IN1 w0.079: v2(143.87,64.47) 143.87,58.65 141.83,56.61 141.83,53.4 142.5,52.73 142.5,48.16 148.42,42.24 151.96,42.24 152.04,42.17 152.04,41.7 152.11,41.62 152.27,41.62 152.35,41.71 152.35,42.17 152.43,42.24 152.59,42.24 152.67,42.17 152.67,41.7 152.74,41.62 152.9,41.62 152.98,41.71 152.98,42.17 153.06,42.24 153.22,42.24 153.3,42.17 153.3,41.7 153.38,41.62 153.53,41.62 153.61,41.7 153.61,42.17 153.69,42.24 158.18,42.24 165.29,35.13 185.28,35.13 186.11,34.3 187.58,34.3 191.87,30.01 191.87,28.53 194.32,26.07 195.07,26.07 195.45,25.69 195.45,22.1 195.2,21.85 v2(194.93,21.85)
  BOTTOM w0.089: UH1.BG7 143.74,64.47 v2(143.87,64.47)
  BOTTOM w0.14: v2(194.93,21.85) 194.92,21.84 JDIMM2.46
DDR_B_D21: length 91.1
  IN1 w0.079: v2(194.93,25.66) 194.34,25.66 191.59,28.41 191.59,29.89 187.46,34.01 186,34.01 185.16,34.85 165.17,34.85 158.68,41.34 158.27,41.34 158.19,41.42 158.19,41.66 158.11,41.74 157.95,41.74 157.87,41.66 157.87,41.42 157.79,41.34 157.61,41.34 157.53,41.42 157.53,41.88 157.46,41.96 157.3,41.96 157.22,41.88 157.22,41.42 157.14,41.34 156.98,41.34 156.9,41.42 156.9,41.88 156.83,41.96 156.67,41.96 156.59,41.88 156.59,41.42 156.51,41.34 156.35,41.34 156.27,41.42 156.27,41.88 156.2,41.96 156.04,41.96 155.96,41.88 155.96,41.42 155.88,41.34 155.72,41.34 155.64,41.42 155.64,41.88 155.57,41.96 155.41,41.96 155.33,41.88 155.33,41.42 155.25,41.34 155.09,41.34 155.01,41.42 155.01,41.88 154.94,41.96 154.78,41.96 154.7,41.88 154.7,41.42 154.62,41.34 154.46,41.34 154.38,41.42 154.38,41.88 154.31,41.96 154.15,41.96 154.07,41.88 154.07,41.42 153.99,41.34 151.99,41.34 151.37,41.96 148.3,41.96 142.21,48.05 142.21,52.5 141.66,53.04 141.66,56.68 143.71,58.72 143.71,63.87 143.46,64.12 143.46,64.58 143.87,64.99 v2(143.87,65.12)
  BOTTOM w0.089: v2(143.87,65.12) 143.74,65.12 UH1.BG8
  BOTTOM w0.14: JDIMM2.45 194.67,25.91 v2(194.93,25.66)
DDR_B_D22: length 93.5
  IN1 w0.079: v2(198.61,23.12) 199.04,23.12 199.28,23.35 199.28,25.55 198.78,26.05 198.27,26.05 196.1,28.22 195.54,28.22 194.49,29.26 194.49,30.41 188.47,36.44 187,36.44 186.15,37.3 166.26,37.3 158.18,45.38 148.43,45.38 146.84,46.96 146.84,47.08 147.08,47.31 147.08,47.42 146.97,47.53 146.86,47.53 146.62,47.3 146.51,47.3 146.4,47.41 146.4,47.52 146.63,47.76 146.63,47.87 146.52,47.98 146.41,47.98 146.17,47.74 146.06,47.74 145.95,47.86 145.95,47.97 146.19,48.2 146.19,48.31 146.08,48.43 145.97,48.43 145.73,48.19 145.62,48.19 144.69,49.11 144.69,50.5 144.12,51.07 144.12,55.59 145.93,57.4 145.93,63.56 145.36,64.14 145.36,64.71 145.14,64.92 145.14,66.07 v2(144.79,66.42)
  BOTTOM w0.089: v2(144.79,66.42) 144.66,66.42 UH1.BF10
  BOTTOM w0.14: JDIMM2.58 197.92,22.43 v2(198.61,23.12)
DDR_B_D23: length 91.8
  IN1 w0.079: v2(198.61,24.39) 198.23,24.39 198.02,24.59 198.02,25.5 195.87,27.66 195.3,27.66 193.93,29.03 193.93,30.18 188.23,35.88 186.77,35.88 185.93,36.72 165.94,36.72 158.83,43.83 156.52,43.83 156.45,43.9 156.45,44.32 156.37,44.4 156.21,44.4 156.13,44.32 156.13,43.9 156.05,43.83 155.88,43.83 155.8,43.9 155.8,44.32 155.72,44.4 155.57,44.4 155.49,44.32 155.49,43.9 155.41,43.83 155.25,43.83 155.16,43.92 155.16,44.31 155.08,44.39 154.92,44.39 154.84,44.31 154.84,43.92 154.76,43.84 154.61,43.84 154.53,43.92 154.53,44.31 154.45,44.39 154.29,44.39 154.21,44.31 154.21,43.92 154.13,43.84 153.98,43.84 153.9,43.92 153.9,44.31 153.82,44.39 153.66,44.39 153.58,44.31 153.58,43.92 153.5,43.84 153.35,43.84 153.27,43.92 153.27,44.32 153.19,44.4 148.5,44.4 144.13,48.77 144.13,50.46 143.79,50.81 143.79,55.73 145.59,57.53 145.59,63.31 144.79,64.11 v2(144.79,64.47)
  BOTTOM w0.089: UH1.BF7 144.66,64.47 v2(144.79,64.47)
  BOTTOM w0.14: JDIMM2.59 198.18,24.83 v2(198.61,24.39)
DDR_B_D24: length 91.8
  IN1 w0.079: v2(146.62,67.06) 146.07,66.51 146.07,64.94 145.9,64.77 145.9,64.07 146.27,63.7 146.27,57.26 144.46,55.46 144.46,51.81 145.84,50.43 145.84,50.32 145.63,50.11 145.63,50 145.74,49.89 145.86,49.89 146.06,50.1 146.17,50.1 146.28,49.98 146.28,49.87 146.08,49.67 146.08,49.56 146.19,49.44 146.3,49.44 146.51,49.65 146.62,49.65 150.1,46.16 158.49,46.16 166.58,38.07 186.47,38.07 187.32,37.21 188.82,37.21 196.22,29.81 196.22,29.18 198.59,26.82 199.1,26.82 200.04,25.87 200.04,22.81 v2(201,21.85)
  BOTTOM w0.089: v2(146.62,67.06) 146.47,67.06 UH1.BC11
  BOTTOM w0.14: v2(201,21.85) 200.92,21.77 JDIMM2.70
DDR_B_D25: length 90.2
  IN1 w0.079: v2(201,24.39) 200.61,24.78 200.61,26.11 199.33,27.38 198.82,27.38 196.79,29.41 196.79,30.04 189.05,37.77 187.56,37.77 186.7,38.63 166.82,38.63 158.72,46.73 150.57,46.73 149.52,47.78 149.52,47.88 149.68,48.04 149.68,48.15 149.56,48.27 149.45,48.27 149.29,48.11 149.19,48.11 149.07,48.23 149.07,48.33 149.22,48.48 149.22,48.6 149.1,48.71 148.99,48.71 148.83,48.55 148.74,48.55 148.62,48.66 148.62,48.78 148.76,48.91 148.76,49.03 148.65,49.15 148.54,49.15 148.39,49 148.29,49 148.13,49.16 148.13,49.21 148.26,49.34 148.26,49.45 148.15,49.57 148.04,49.57 147.92,49.44 147.84,49.44 147.71,49.58 147.71,49.63 147.85,49.78 147.85,49.89 147.74,50 147.63,50 147.52,49.89 147.4,49.89 147.28,50.01 147.28,50.08 147.43,50.23 147.43,50.33 147.3,50.46 147.2,50.46 147.08,50.33 146.96,50.33 144.79,52.5 144.79,55.32 146.6,57.12 146.6,63.9 146.26,64.25 146.26,64.62 146.62,64.98 v2(146.62,65.12)
  BOTTOM w0.089: v2(146.62,65.12) 146.49,65.12 UH1.BC8
  BOTTOM w0.14: JDIMM2.71 201.18,26.5 201.61,26.07 201.61,24.99 v2(201,24.39)
DDR_B_D26: length 92.3
  IN1 w0.079: v2(204.68,25.66) 204.68,25.87 199.81,30.74 199.81,30.85 190.18,40.48 188.68,40.48 187.82,41.34 169.01,41.34 163.92,46.42 163.92,46.53 164.3,46.92 164.3,47.03 164.19,47.14 164.08,47.14 163.7,46.76 163.59,46.76 163.48,46.87 163.48,46.98 163.86,47.36 163.86,47.47 163.75,47.58 163.64,47.58 163.25,47.2 163.14,47.2 163.03,47.31 163.03,47.43 163.41,47.81 163.41,47.92 163.3,48.03 163.19,48.03 162.81,47.65 162.7,47.65 162.59,47.76 162.59,47.87 162.97,48.25 162.97,48.36 162.86,48.48 162.75,48.48 162.36,48.09 162.25,48.09 162.14,48.21 162.14,48.32 162.52,48.7 162.52,48.81 162.41,48.92 162.3,48.92 161.96,48.58 161.92,48.54 161.81,48.54 161.7,48.65 161.7,48.76 161.96,49.03 162.08,49.14 162.08,49.26 161.97,49.37 161.85,49.37 161.47,48.99 161.36,48.99 160.01,50.33 151.34,50.33 149.15,52.52 149.15,55.9 148.97,56.08 148.97,64.05 148.08,64.95 148.08,66.53 v2(147.53,67.07)
  BOTTOM w0.089: v2(147.53,67.07) 147.4,67.07 UH1.BB11
  BOTTOM w0.14: JDIMM2.83 204.18,26.16 v2(204.68,25.66)
DDR_B_D27: length 90.5
  IN1 w0.079: v2(204.68,21.85) 204.68,21.73 204.55,21.61 203.49,21.61 203.36,21.73 203.36,21.91 203.44,21.99 203.9,21.99 203.98,22.07 203.98,22.31 203.9,22.38 203.44,22.38 203.36,22.46 203.36,22.7 203.44,22.78 203.64,22.78 203.72,22.86 203.72,23.09 203.64,23.17 203.44,23.17 203.36,23.25 203.36,23.49 203.44,23.57 203.64,23.57 203.72,23.64 203.72,23.88 203.64,23.96 203.44,23.96 203.36,24.04 203.36,24.27 203.44,24.35 203.64,24.35 203.72,24.43 203.72,24.67 203.64,24.75 203.44,24.75 203.36,24.83 203.36,25.06 203.44,25.14 203.64,25.14 203.72,25.22 203.72,25.46 203.64,25.53 203.44,25.53 203.36,25.61 203.36,25.99 198.96,30.39 198.96,30.5 189.83,39.64 188.33,39.64 187.47,40.49 168.66,40.49 162.7,46.45 161.64,46.45 158.93,49.16 151.32,49.16 148.65,51.83 148.65,55.69 148.16,56.18 148.16,63.84 v2(147.53,64.47)
  BOTTOM w0.089: v2(147.53,64.47) 147.4,64.47 UH1.BB7
  BOTTOM w0.14: v2(204.68,21.85) 204.68,20.83 204.43,20.57 JDIMM2.84
DDR_B_D28: length 90.9
  IN1 w0.079: v2(201,23.12) 200.59,23.12 200.37,23.34 200.37,23.48 200.4,23.51 200.52,23.51 200.6,23.59 200.6,23.75 200.52,23.83 200.4,23.83 200.33,23.91 200.33,24.07 200.4,24.14 200.52,24.14 200.6,24.22 200.6,24.38 200.52,24.46 200.4,24.46 200.33,24.54 200.33,25.99 199.21,27.1 198.7,27.1 196.51,29.3 196.51,29.92 188.94,37.49 187.44,37.49 186.58,38.35 166.7,38.35 158.6,46.44 150.27,46.44 144.63,52.08 144.63,55.39 146.43,57.19 146.43,63.83 146.08,64.19 146.08,64.7 146.25,64.87 146.25,66.05 v2(146.62,66.42)
  BOTTOM w0.089: UH1.BC10 146.49,66.42 v2(146.62,66.42)
  BOTTOM w0.14: v2(201,23.12) 200.46,22.58 200.46,21.19 199.92,20.66 JDIMM2.66
DDR_B_D29: length 88.7
  IN1 w0.079: v2(201.01,25.61) 201.01,25.61 201.01,26.1 199.45,27.67 198.94,27.67 197.07,29.53 197.07,30.16 189.17,38.06 187.67,38.06 186.82,38.91 166.93,38.91 158.81,47.04 155.1,47.04 155.02,47.12 155.02,47.5 154.95,47.58 154.79,47.58 154.71,47.5 154.71,47.12 154.63,47.04 154.47,47.04 154.39,47.12 154.39,47.5 154.32,47.58 154.16,47.58 154.08,47.5 154.08,47.12 154,47.04 153.84,47.04 153.76,47.12 153.76,47.5 153.69,47.58 153.53,47.58 153.45,47.5 153.45,47.12 153.37,47.04 153.21,47.04 153.14,47.12 153.14,47.5 153.06,47.58 152.9,47.58 152.82,47.5 152.82,47.12 152.74,47.04 152.58,47.04 152.51,47.12 152.51,47.5 152.43,47.58 152.27,47.58 152.19,47.5 152.19,47.12 152.11,47.04 151.95,47.04 151.88,47.12 151.88,47.5 151.8,47.58 151.64,47.58 151.56,47.5 151.56,47.12 151.48,47.04 151.19,47.04 145.66,52.57 145.66,54.64 147.4,56.38 147.4,63.45 146.62,64.23 v2(146.62,64.47)
  BOTTOM w0.089: v2(146.62,64.47) 146.49,64.47 UH1.BC7
  BOTTOM w0.14: JDIMM2.67 200.18,26.44 v2(201.01,25.61)
DDR_B_D30: length 92.4
  IN1 w0.079: v2(147.53,66.42) 147.9,66.05 147.9,64.87 148.68,64.09 148.68,56.13 148.98,55.83 148.98,52.29 151.55,49.73 151.86,49.73 151.94,49.81 151.94,49.97 152.02,50.05 152.17,50.05 152.25,49.97 152.25,49.81 152.33,49.73 152.49,49.73 152.57,49.81 152.57,49.97 152.65,50.05 152.8,50.05 152.88,49.97 152.88,49.81 152.96,49.73 153.12,49.73 153.2,49.81 153.2,49.97 153.28,50.05 153.43,50.05 153.51,49.97 153.51,49.81 153.59,49.73 153.75,49.73 153.83,49.81 153.83,49.97 153.91,50.05 154.06,50.05 154.14,49.97 154.14,49.81 154.22,49.73 154.38,49.73 154.46,49.81 154.46,49.97 154.54,50.05 154.69,50.05 154.77,49.97 154.77,49.81 154.85,49.73 155.01,49.73 155.09,49.81 155.09,49.97 155.17,50.05 155.32,50.05 155.4,49.97 155.4,49.81 155.48,49.73 155.64,49.73 155.72,49.81 155.72,49.97 155.8,50.05 155.95,50.05 156.03,49.97 156.03,49.81 156.11,49.73 156.27,49.73 156.35,49.81 156.35,49.97 156.43,50.05 156.58,50.05 156.66,49.97 156.66,49.81 156.74,49.73 156.9,49.73 156.98,49.81 156.98,49.97 157.06,50.05 157.21,50.05 157.29,49.97 157.29,49.81 157.37,49.73 157.53,49.73 157.61,49.81 157.61,49.97 157.69,50.05 157.84,50.05 157.92,49.97 157.92,49.81 158,49.73 158.16,49.73 158.24,49.81 158.24,49.97 158.32,50.05 158.47,50.05 158.55,49.97 158.55,49.81 158.63,49.73 160.22,49.73 168.89,41.06 187.71,41.06 188.56,40.2 190.06,40.2 199.53,30.74 199.53,30.62 204.29,25.86 204.29,24.78 v2(204.68,24.39)
  BOTTOM w0.089: v2(147.53,66.42) 147.4,66.42 UH1.BB10
  BOTTOM w0.14: JDIMM2.79 203.18,25.89 v2(204.68,24.39)
DDR_B_D31: length 90.8
  IN1 w0.079: v2(147.53,65.12) 147.71,64.94 147.71,64.81 148.4,64.12 148.4,56.17 148.82,55.76 148.82,52.06 151.43,49.45 160.1,49.45 160.48,49.07 160.48,48.93 160.16,48.62 160.16,48.54 160.37,48.33 160.48,48.33 160.81,48.65 160.89,48.65 161.08,48.47 161.08,48.36 160.68,47.96 160.68,47.84 160.85,47.68 160.96,47.68 161.36,48.08 161.47,48.08 161.64,47.91 161.64,47.8 161.24,47.4 161.24,47.29 161.4,47.12 162.43,47.12 168.77,40.78 187.59,40.78 188.45,39.92 189.94,39.92 199.24,30.62 199.24,30.51 204,25.75 204,23.27 204.16,23.12 v2(204.68,23.12)
  BOTTOM w0.089: v2(147.53,65.12) 147.4,65.12 UH1.BB8
  BOTTOM w0.14: JDIMM2.80 203.43,20.46 204.16,21.19 204.16,22.6 v2(204.68,23.12)
DDR_B_D32: length 99.8
  IN1 w0.079: v2(163.08,67.07) 162.58,66.58 162.58,66.29 162.3,66.01 162.3,64.15 162.86,63.6 162.86,57.26 164.09,56.03 164.09,50.57 172.83,41.83 188.02,41.83 188.88,40.97 190.38,40.97 201.32,30.03 201.74,30.03 202.41,29.36 202.41,28.98 204.66,26.73 227.4,26.73 227.72,26.41 227.72,22.18 228.01,21.89 v2(228.83,21.89)
  BOTTOM w0.089: v2(163.08,67.07) 162.94,67.07 UH1.AC11
  BOTTOM w0.14: JDIMM2.174 228.93,21.79 v2(228.83,21.89)
DDR_B_D33: length 97.2
  IN1 w0.079: v2(228.83,25.7) 228.83,26.5 227.75,27.58 208.98,27.58 208.43,28.13 208.32,28.13 207.76,27.58 207.63,27.58 207.54,27.67 207.54,27.8 208.09,28.35 208.09,28.46 207.98,28.58 207.87,28.58 207,27.71 206.87,27.71 206.78,27.8 206.78,27.93 207.65,28.8 207.65,28.91 207.54,29.02 207.43,29.02 206.56,28.16 206.43,28.16 205.83,28.76 203.83,28.76 203.26,29.33 203.26,29.71 202.09,30.88 201.67,30.88 190.64,41.9 189.15,41.9 188.38,42.67 173.18,42.67 164.93,50.92 164.93,56.12 163.5,57.55 163.5,63.78 163.08,64.2 v2(163.08,64.47)
  BOTTOM w0.089: UH1.AC7 162.94,64.47 v2(163.08,64.47)
  BOTTOM w0.14: v2(228.83,25.7) 228.67,25.85 JDIMM2.173
DDR_B_D34: length 101.9
  IN1 w0.079: v2(232.37,25.72) 232.37,26.38 229.82,28.94 229.82,29.83 228.59,31.06 214.79,31.06 213.68,32.17 204.23,32.17 202.89,33.51 202.57,33.51 191.68,44.41 190.29,44.41 189.6,45.1 174.48,45.1 172.31,47.27 172.31,49.14 168.99,52.46 168.88,52.46 168.77,52.34 168.77,52.23 170.52,50.48 170.52,50.37 170.41,50.26 170.29,50.26 168.42,52.14 168.42,55.32 165.28,58.45 165.28,63.29 164.86,63.71 164.86,64.71 164.54,65.03 164.54,66.19 164.46,66.27 164.46,66.48 163.99,66.94 v2(163.99,67.07)
  BOTTOM w0.089: UH1.AA11 163.86,67.07 v2(163.99,67.07)
  BOTTOM w0.14: v2(232.37,25.72) 232.18,25.92 JDIMM2.187
DDR_B_D35: length 98.9
  IN1 w0.079: v2(232.37,21.91) 231.34,22.94 231.34,26.22 228.97,28.59 228.97,29.47 228.23,30.21 214.26,30.21 213.15,31.32 203.88,31.32 202.54,32.67 202.15,32.67 191.26,43.56 189.94,43.56 189.25,44.25 173.84,44.25 166.38,51.71 166.38,52.97 166.46,53.05 166.74,53.05 166.81,53.13 166.81,53.28 166.74,53.36 166.46,53.36 166.38,53.44 166.38,53.6 166.46,53.68 166.74,53.68 166.81,53.76 166.81,53.91 166.74,53.99 166.46,53.99 166.38,54.07 166.38,55.63 164.11,57.89 164.11,64.01 163.99,64.13 v2(163.99,64.47)
  BOTTOM w0.089: v2(163.99,64.47) 163.86,64.47 UH1.AA7
  BOTTOM w0.14: JDIMM2.186 231.93,21.46 v2(232.37,21.91)
DDR_B_D36: length 99.4
  IN1 w0.079: v2(163.08,66.42) 162.5,65.85 162.5,64.24 163.08,63.66 163.08,57.4 164.37,56.12 164.37,50.69 172.95,42.11 188.14,42.11 189,41.25 190.5,41.25 201.43,30.31 201.86,30.31 202.69,29.48 202.69,29.1 203.94,27.85 204.06,27.85 204.23,28.03 204.35,28.03 204.46,27.92 204.46,27.81 204.28,27.63 204.28,27.52 204.78,27.01 227.51,27.01 228,26.52 228,23.99 v2(228.83,23.16)
  BOTTOM w0.076: v2(163.08,66.42) 162.75,66.1 UH1.AC10
  BOTTOM w0.14: v2(228.83,23.16) 227.93,22.26 JDIMM2.170
DDR_B_D37: length 97.9
  IN1 w0.079: v2(163.08,65.12) 162.71,64.75 162.71,64.28 163.3,63.69 163.3,57.5 164.65,56.15 164.65,50.8 173.06,42.39 188.26,42.39 189.03,41.62 190.52,41.62 201.55,30.6 201.97,30.6 202.98,29.59 202.98,29.22 203.77,28.42 204.39,28.42 204.95,27.87 204.95,27.76 204.78,27.59 204.78,27.48 204.89,27.37 205.03,27.37 205.18,27.52 205.29,27.52 205.52,27.3 205.7,27.3 205.78,27.37 205.78,27.95 205.86,28.03 206.02,28.03 206.09,27.95 206.09,27.37 206.17,27.3 227.63,27.3 228.28,26.64 228.28,24.97 v2(228.83,24.43)
  BOTTOM w0.089: UH1.AC8 162.94,65.12 v2(163.08,65.12)
  BOTTOM w0.14: v2(228.83,24.43) 227.67,25.58 JDIMM2.169
DDR_B_D38: length 101.5
  IN1 w0.079: v2(163.99,66.42) 164.36,66.05 164.36,64.92 164.68,64.6 164.68,63.65 165.08,63.26 165.08,58.41 168.17,55.32 168.17,51.86 169.27,50.76 169.27,50.62 169.17,50.52 169.06,50.52 168.56,51.03 168.44,51.03 168.33,50.92 168.33,50.81 169.34,49.8 171.25,49.8 172.03,49.02 172.03,47.15 174.36,44.82 189.48,44.82 190.18,44.13 191.56,44.13 202.45,33.23 202.77,33.23 204.12,31.89 213.39,31.89 214.5,30.78 228.47,30.78 229.54,29.71 229.54,28.82 231.95,26.4 231.95,24.6 232.11,24.45 v2(232.37,24.45)
  BOTTOM w0.089: v2(163.99,66.42) 163.86,66.42 UH1.AA10
  BOTTOM w0.14: JDIMM2.183 231.18,25.65 v2(232.37,24.45)
DDR_B_D39: length 99.7
  IN1 w0.079: v2(163.99,65.12) 164.05,65.06 164.05,64.95 164.48,64.51 164.48,63.62 164.88,63.22 164.88,58.31 167.96,55.23 167.96,54.01 167.88,53.93 167.68,53.93 167.6,53.86 167.6,53.7 167.68,53.62 167.88,53.62 167.96,53.54 167.96,53.38 167.88,53.3 167.68,53.3 167.6,53.23 167.6,53.07 167.68,52.99 167.88,52.99 167.96,52.91 167.96,50.53 173.95,44.54 189.37,44.54 190.06,43.84 191.44,43.84 202.34,32.95 202.66,32.95 204,31.61 213.27,31.61 214.38,30.5 228.35,30.5 229.26,29.59 229.26,28.7 231.67,26.29 231.67,24.48 231.67,24.48 231.67,23.88 v2(232.37,23.18)
  BOTTOM w0.089: UH1.AA8 163.86,65.12 v2(163.99,65.12)
  BOTTOM w0.14: JDIMM2.182 230.93,20.43 231.39,20.89 231.39,22.19 v2(232.37,23.18)
DDR_B_D40: length 101
  IN1 w0.079: v2(165.82,64.53) 165.43,64.14 165.43,63.86 165.9,63.39 165.9,58.65 171.05,53.5 171.05,51.88 171.47,51.46 171.58,51.46 171.75,51.64 171.86,51.64 171.98,51.53 171.98,51.42 171.8,51.24 171.8,51.13 171.91,51.02 172.02,51.02 172.2,51.19 172.31,51.19 172.42,51.08 172.42,50.97 172.25,50.8 172.25,50.68 172.36,50.57 172.47,50.57 172.64,50.75 172.76,50.75 172.87,50.64 172.87,50.53 172.69,50.35 172.69,50.24 174.03,48.9 174.03,48.16 173.95,48.08 173.79,48.08 173.71,48.16 173.71,48.66 173.61,48.77 173.48,48.77 173.4,48.69 173.4,47.79 174.65,46.54 174.77,46.54 174.88,46.65 174.88,46.76 173.96,47.68 173.96,47.79 174.07,47.9 174.18,47.9 175.93,46.15 191.42,46.15 203.01,34.56 203.33,34.56 204.67,33.22 214.12,33.22 215.23,32.11 229.02,32.11 231.46,29.67 231.46,29.01 234.66,25.81 v2(234.66,25.72)
  BOTTOM w0.089: UH1.W8 165.63,64.53 v2(165.82,64.53)
  BOTTOM w0.14: v2(234.66,25.72) 234.18,26.2 JDIMM2.195
DDR_B_D41: length 100.5
  IN1 w0.079: v2(234.66,21.91) 235.15,22.39 235.15,25.79 233.28,27.66 233.21,27.66 231.75,29.12 231.75,29.78 229.14,32.39 215.34,32.39 214.23,33.5 204.78,33.5 203.44,34.84 203.12,34.84 191.54,46.43 176.58,46.43 174.63,48.39 174.63,48.5 174.74,48.61 174.85,48.61 176.02,47.44 176.13,47.44 176.22,47.53 176.22,47.68 171.21,52.69 171.21,53.59 166.07,58.73 166.07,63.72 v2(165.82,63.97)
  BOTTOM w0.089: v2(165.82,63.97) 165.54,63.97 UH1.W7
  BOTTOM w0.14: JDIMM2.194 233.94,21.01 234.66,21.72 v2(234.66,21.91)
DDR_B_D42: length 102.2
  IN1 w0.079: v2(237.89,25.72) 237.29,26.32 237.29,26.7 234.62,29.37 234.62,30.02 230.11,34.54 216.23,34.54 215.12,35.65 206.49,35.65 205.07,37.08 203.93,37.08 199.81,41.19 199.81,41.3 199.93,41.41 200.04,41.41 202.13,39.32 202.24,39.32 202.33,39.41 202.33,39.56 198.79,43.1 197.9,43.1 192.42,48.58 178.36,48.58 174.13,52.81 174.13,53.12 167.64,59.61 167.64,63.62 167.29,63.96 167.29,64.68 167.1,64.87 167.1,66.02 v2(166.7,66.42)
  BOTTOM w0.089: v2(166.7,66.42) 166.6,66.42 UH1.V10
  BOTTOM w0.14: v2(237.89,25.72) 237.85,25.72 237.18,26.39 JDIMM2.207
DDR_B_D43: length 103
  IN1 w0.079: v2(237.89,21.91) 238.64,22.65 238.64,25.75 234.9,29.49 234.9,30.14 230.22,34.82 216.35,34.82 215.24,35.93 206.61,35.93 205.18,37.36 204.04,37.36 202.84,38.56 202.84,38.67 202.95,38.78 203.07,38.78 203.64,38.2 203.76,38.2 203.87,38.31 203.87,38.42 198.91,43.39 198.01,43.39 192.54,48.86 178.48,48.86 174.3,53.04 174.3,53.19 167.82,59.67 167.82,63.69 167.58,63.92 167.58,64.73 167.28,65.03 167.28,66.5 v2(166.71,67.07)
  BOTTOM w0.089: v2(166.71,67.07) 166.6,67.07 UH1.V11
  BOTTOM w0.14: JDIMM2.208 237.42,20.8 237.89,21.27 v2(237.89,21.91)
DDR_B_D44: length 103.1
  IN1 w0.079: v2(165.82,66.42) 165.42,66.02 165.42,64.83 165.24,64.64 165.24,63.81 165.69,63.36 165.69,58.6 169.55,54.75 169.55,53.88 169.67,53.76 169.78,53.76 170.06,54.04 170.17,54.04 170.28,53.93 170.28,53.82 170,53.54 170,53.42 170.11,53.31 170.22,53.31 170.5,53.59 170.61,53.59 170.73,53.48 170.73,53.37 170.45,53.09 170.45,52.98 170.71,52.71 170.71,52.6 170.6,52.49 170.49,52.49 169.91,53.07 169.74,53.07 169.66,52.99 169.66,52.88 173.08,49.46 173.08,47.58 174.79,45.87 191.3,45.87 202.89,34.28 203.21,34.28 204.55,32.94 214,32.94 215.11,31.83 228.9,31.83 231.18,29.55 231.18,28.89 234.15,25.92 234.15,24.96 v2(234.66,24.45)
  BOTTOM w0.076: v2(165.82,66.42) 165.49,66.75 UH1.W11
  BOTTOM w0.14: JDIMM2.191 233.18,25.93 v2(234.66,24.45)
DDR_B_D45: length 102.7
  IN1 w0.079: v2(164.92,65.88) 164.92,65.22 165.06,65.08 165.06,63.75 165.49,63.33 165.49,58.55 168.66,55.38 168.66,53.51 168.75,53.41 168.88,53.41 168.97,53.51 168.97,54.35 169.05,54.43 169.18,54.43 169.29,54.32 169.29,52.84 172.79,49.34 172.79,47.47 174.68,45.58 191.18,45.58 202.77,34 203.09,34 204.43,32.65 213.88,32.65 214.99,31.55 228.79,31.55 230.9,29.43 230.9,28.77 233.87,25.8 233.87,23.1 234,22.97 234.45,22.97 v2(234.66,23.18)
  BOTTOM w0.076: v2(164.92,65.88) 165.14,66.1 UH1.W10
  BOTTOM w0.14: v2(234.66,23.18) 234.11,22.63 234.11,21.82 232.94,20.65 JDIMM2.190
DDR_B_D46: length 100.9
  IN1 w0.079: v2(237.89,24.45) 237.36,24.98 237.36,25.63 237.01,25.98 237.01,26.58 234.34,29.25 234.34,29.9 229.99,34.26 216.11,34.26 215.01,35.36 206.38,35.36 204.95,36.79 203.81,36.79 198.25,42.35 198.25,42.47 198.35,42.57 198.48,42.57 199.49,41.55 199.61,41.55 199.72,41.67 199.72,41.78 198.67,42.82 197.78,42.82 192.31,48.29 178.25,48.29 173.83,52.71 173.83,53.07 167.44,59.45 167.44,63.55 167.12,63.87 167.12,64.61 166.73,64.99 v2(166.73,65.12)
  BOTTOM w0.089: UH1.V8 166.6,65.12 v2(166.73,65.12)
  BOTTOM w0.14: JDIMM2.203 236.18,26.17 v2(237.89,24.45)
DDR_B_D47: length 100.2
  IN1 w0.079: v2(166.73,64.47) 166.73,63.92 166.65,63.83 166.65,58.97 172.3,53.32 172.83,53.32 178.13,48.01 192.19,48.01 203.78,36.42 204.1,36.42 204.31,36.21 204.42,36.21 204.72,36.51 204.83,36.51 204.94,36.4 204.94,36.29 204.64,35.99 204.64,35.88 204.76,35.77 204.87,35.77 205.17,36.07 205.28,36.07 205.39,35.95 205.39,35.84 205.09,35.54 205.09,35.43 205.44,35.08 214.89,35.08 216,33.97 229.87,33.97 234.06,29.79 234.06,29.14 236.73,26.46 236.73,24.4 237.26,23.86 237.26,23.36 237.45,23.18 v2(237.89,23.18)
  BOTTOM w0.089: UH1.V7 166.6,64.47 v2(166.73,64.47)
  BOTTOM w0.14: v2(237.89,23.18) 237.31,22.59 237.31,21.69 236.42,20.81 JDIMM2.204
DDR_B_D48: length 104.4
  IN1 w0.079: v2(240.18,21.91) 239.12,22.96 239.12,25.95 236.6,28.47 236.6,29.3 230.59,35.3 216.55,35.3 215.4,36.45 206.77,36.45 205.38,37.84 205.13,37.84 199.11,43.87 198.21,43.87 192.74,49.34 178.68,49.34 176.1,51.92 176.1,52.07 176.2,52.16 176.31,52.16 177.18,51.29 177.29,51.29 177.4,51.4 177.4,51.52 176.48,52.43 175.59,52.43 172.48,55.54 172.18,55.54 168.2,59.53 168.2,63.78 167.84,64.13 167.84,64.77 168.02,64.95 168.02,66.13 168.17,66.28 168.17,66.68 v2(168.56,67.07)
  BOTTOM w0.089: UH1.R11 168.43,67.07 v2(168.56,67.07)
  BOTTOM w0.14: v2(240.18,21.91) 240.18,21.36 239.42,20.6 JDIMM2.216
DDR_B_D49: length 98.7
  IN1 w0.079: v2(168.56,64.47) 168.73,64.31 168.73,59.71 172.39,56.05 173.17,56.05 175.94,53.28 177,53.28 180.09,50.19 193.09,50.19 196.8,46.48 197.73,46.48 198.49,45.72 198.81,45.72 199.18,45.36 199.18,45.25 201.25,43.18 202.08,43.18 205.19,40.07 205.19,39.94 205.08,39.84 204.97,39.84 203.77,41.04 203.65,41.04 203.54,40.93 203.54,40.82 205.5,38.86 205.76,38.86 207.32,37.3 215.75,37.3 216.9,36.15 230.94,36.15 237.45,29.65 237.45,28.82 240.18,26.09 v2(240.18,25.72)
  BOTTOM w0.089: v2(168.56,64.47) 168.43,64.47 UH1.R7
  BOTTOM w0.14: v2(240.18,25.72) 239.18,26.72 JDIMM2.215
DDR_B_D50: length 100.4
  IN1 w0.079: v2(243.48,21.91) 242.55,21.91 242.44,22.01 242.44,26.07 239.71,28.8 239.71,29.62 231.6,37.73 217.56,37.73 216.41,38.88 208.61,38.88 202.6,44.9 202.01,44.9 198.82,48.09 197.43,48.09 196.18,49.34 196.18,49.34 193.75,51.77 187.36,51.77 187.19,51.93 183.36,51.93 183.2,51.77 180.74,51.77 180.63,51.88 176.82,55.7 174.41,55.7 173.38,56.72 173.23,56.72 170.11,59.84 170.11,62.59 169.48,63.23 v2(169.48,64.47)
  BOTTOM w0.089: v2(169.48,64.47) 169.35,64.47 UH1.P7
  BOTTOM w0.14: JDIMM2.228 242.42,21.11 243.23,21.91 v2(243.48,21.91)
