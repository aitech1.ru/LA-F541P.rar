# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_HTX_C_GRX_P14: length 7.2
  BOTTOM w0.076: UV18.AP26 194.64,79.7 194.55,79.8 194.23,79.8 194.01,80.01 193.89,80.01 193.87,80.03
  BOTTOM w0.152: 193.87,80.03 192.57,81.33 v3(192.14,81.33) 190.81,81.33 190.52,81.62 188.72,81.62 CH7.2
PEG_HTX_C_GRX_P15: length 9.4
  BOTTOM w0.076: UV18.AN27 195.61,80.15 195.79,80.15 195.93,80.29 195.93,80.44 195.83,80.54 195.02,80.54 194.81,80.74 194.43,80.74 194.21,80.96 194.08,80.96 194.07,80.98
  BOTTOM w0.152: CH5.2 188.72,83.67 189.18,83.67 189.45,83.4 190.15,82.7 v3(190.72,82.7) 192.34,82.7 194.07,80.98
PEG_HTX_GRX_N0: length 13.9
  BOTTOM w0.076: 181.52,65.3 181.5,65.31 181.38,65.31 181.03,65.66 178.51,65.66 178.35,65.83 177.17,65.83 177.06,65.93 177.06,66.1 177.13,66.17 177.39,66.17 UH1.B10
  BOTTOM w0.152: CH36.1 189.1,65.99 188.46,65.99 187.25,64.78 v3(184.2,64.78) 182.03,64.78 181.52,65.3
PEG_HTX_GRX_N1: length 14.3
  BOTTOM w0.076: UH1.B11 177.91,66.44 178.45,66.44 178.49,66.48 178.94,66.48 179.24,66.18 181.19,66.18 181.28,66.09 181.3,66.09
  BOTTOM w0.152: 181.3,66.09 181.58,66.09 182.43,65.24 v3(182.83,65.24) 186.37,65.24 188.38,67.25 189.95,67.25 CH34.1
PEG_HTX_GRX_N2: length 13.6
  BOTTOM w0.076: 179.93,67.25 179.91,67.25 179.82,67.16 178.6,67.16 178.38,67.38 177.32,67.38 177.13,67.57 177.13,67.68 177.21,67.77 177.37,67.77 UH1.B12
  BOTTOM w0.152: CH32.1 188.55,68.76 188.21,68.76 187.63,68.18 187.23,68.18 v3(185.88,66.83) 185.42,66.37 183.05,66.37 182.17,67.25 179.93,67.25
PEG_HTX_GRX_N3: length 14.5
  BOTTOM w0.076: 180.02,67.76 180,67.76 179.91,67.84 179.2,67.84 178.96,68.09 178.47,68.09 178.37,67.99 177.81,67.99 177.56,68.24 177.56,68.36 UH1.B13
  BOTTOM w0.152: CH30.1 189.84,69.97 188.51,69.97 187.52,68.97 186.77,68.97 185.03,67.23 v3(183.97,67.23) 183,67.23 182.48,67.76 180.02,67.76
PEG_HTX_GRX_N4: length 13.3
  BOTTOM w0.076: UH1.B14 177.18,69.28 177.08,69.17 177.08,69.06 177.2,68.94 178.42,68.94 178.57,68.8 179.9,68.8 179.99,68.89 180.01,68.89
  BOTTOM w0.152: CH28.1 188.44,71.25 188.16,71.25 187.25,70.35 186.46,70.35 185,68.89 v3(183.72,68.89) 180.01,68.89
PEG_HTX_GRX_N5: length 14.3
  BOTTOM w0.076: UH1.B15 177.56,69.94 177.56,69.81 177.8,69.57 178.31,69.57 178.48,69.75 178.9,69.75 179.19,69.46 179.75,69.46 179.84,69.37 179.86,69.37
  BOTTOM w0.152: CH26.1 189.84,72.06 188.27,72.06 187.42,71.21 186.68,71.21 185.43,69.97 184.93,69.97 184.33,69.37 v3(182.41,69.37) 179.86,69.37
PEG_HTX_GRX_N6: length 13.5
  BOTTOM w0.076: 179.64,70.52 179.62,70.52 179.53,70.44 178.51,70.44 178.38,70.56 177.19,70.56 177.06,70.69 177.06,70.79 177.12,70.85 UH1.B16
  BOTTOM w0.152: CH24.1 188.51,73.48 187.34,73.48 185.08,71.23 184.44,71.23 183.73,70.52 v3(181.79,70.52) 179.64,70.52
PEG_HTX_GRX_N7: length 14.4
  BOTTOM w0.076: UH1.B17 177.54,71.53 177.54,71.38 177.79,71.14 178.41,71.14 178.55,71.28 179,71.28 179.21,71.07 179.79,71.07 179.88,70.98 179.9,70.98
  BOTTOM w0.152: CH22.1 189.83,74.11 187.27,74.11 v3(186.95,73.79) 185.07,71.91 184.47,71.91 183.54,70.98 179.9,70.98
PEG_HTX_GRX_N8: length 13.8
  BOTTOM w0.076: UH1.C18 177.08,72.73 177.55,72.73 177.75,72.53 177.75,72.27 177.87,72.14 178.47,72.14 178.58,72.04 180.06,72.04 180.15,72.12 180.17,72.12
  BOTTOM w0.152: 180.17,72.12 v3(181.89,72.12) 183.1,72.12 184.3,73.32 184.9,73.32 186.99,75.41 188.41,75.41 CH20.1
PEG_HTX_GRX_N9: length 14.5
  BOTTOM w0.076: UH1.A19 178.01,73.29 177.88,73.29 177.8,73.21 177.8,73.07 178,72.86 178.32,72.86 178.44,72.98 178.99,72.98 179.13,72.84 180.13,72.84 180.22,72.92 180.23,72.92
  BOTTOM w0.152: CH18.1 189.87,76.43 189.37,76.43 189.26,76.32 187.94,76.32 187.84,76.21 186.07,76.21 v3(184.19,74.33) 182.78,72.92 180.23,72.92
PEG_HTX_GRX_N10: length 13.2
  BOTTOM w0.076: 179.73,73.47 179.71,73.47 179.62,73.55 177.12,73.55 176.93,73.74 176.93,73.85 UH1.C20
  BOTTOM w0.152: CH16.1 188.02,76.92 186.13,76.92 182.67,73.47 v3(180.95,73.47) 179.73,73.47
PEG_HTX_GRX_N11: length 14.1
  BOTTOM w0.076: UH1.A21 177.82,74.79 177.7,74.67 177.7,74.55 177.8,74.46 178.26,74.46 178.43,74.62 179.11,74.62 179.19,74.54 179.6,74.54 179.69,74.63 179.71,74.63
  BOTTOM w0.152: 179.71,74.63 182.11,74.63 v3(182.52,75.04) 185.82,78.34 189.3,78.34 CH14.1
PEG_HTX_GRX_N12: length 13.5
  BOTTOM w0.076: UH1.C22 176.89,75.46 176.89,75.26 177.07,75.08 178.26,75.08 178.34,75.01 178.88,75.01 179.05,75.18 179.63,75.18 179.72,75.09 179.74,75.09
  BOTTOM w0.152: 179.74,75.09 181.92,75.09 v3(184.39,77.56) 186.11,79.28 187.8,79.28 CH12.1
PEG_HTX_GRX_N13: length 14.4
  BOTTOM w0.076: UH1.A23 177.81,76.36 177.72,76.28 177.72,76.14 177.84,76.02 178.42,76.02 178.54,76.14 180.77,76.14 180.85,76.23 180.87,76.23
  BOTTOM w0.152: CH10.1 189.29,80.68 189.07,80.68 188.92,80.83 v3(186.5,80.83) 186.08,80.83 181.48,76.23 180.87,76.23
PEG_HTX_GRX_N14: length 14
  BOTTOM w0.076: 180.74,77.32 180.73,77.3 180.73,77.18 180.29,76.74 178.49,76.74 178.37,76.86 177.96,76.86 177.74,77.08 177.74,77.24 177.52,77.46 177.09,77.46 UH1.C24
  BOTTOM w0.152: CH8.1 187.83,81.95 186.09,81.95 v3(184.21,80.07) 182.08,77.94 181.37,77.94 180.74,77.32
PEG_HTX_GRX_N15: length 13.5
  BOTTOM w0.076: 180.3,78.23 180.28,78.22 180.28,78.09 180.08,77.89 179.89,77.69 178.44,77.69 178.35,77.6 177.94,77.6 177.88,77.66 177.8,77.74 177.8,77.86 177.88,77.94 UH1.A25
  BOTTOM w0.152: CH6.1 187.85,84.01 187.43,84.01 v3(186.45,83.03) 186.17,82.75 185.78,82.75 181.76,78.74 180.81,78.74 180.3,78.23
PEG_HTX_GRX_P0: length 13.9
  BOTTOM w0.076: 181.28,65.07 181.27,65.08 181.27,65.21 181.12,65.36 180.96,65.51 178.44,65.51 178.28,65.67 177.1,65.67 176.91,65.87 176.91,66 UH1.C10
  BOTTOM w0.152: 181.28,65.07 181.9,64.45 v3(186.18,64.45) 187.39,64.45 188.6,65.66 189.24,65.66 CH35.1
PEG_HTX_GRX_P1: length 14.3
  BOTTOM w0.076: 181.3,66.42 181.28,66.42 181.19,66.33 179.31,66.33 179.01,66.63 178.43,66.63 178.38,66.59 177.97,66.59 177.8,66.76 177.8,66.89 177.9,66.99 178.01,66.99 UH1.A11
  BOTTOM w0.152: 181.3,66.42 181.72,66.42 182.57,65.57 186.24,65.57 v3(187.11,66.45) 188.24,67.58 189.9,67.58 CH33.1
PEG_HTX_GRX_P2: length 13.7
  BOTTOM w0.076: UH1.C12 177.26,67.23 178.32,67.23 178.54,67.01 179.82,67.01 179.91,66.92 179.93,66.92
  BOTTOM w0.152: 179.93,66.92 182.04,66.92 182.91,66.04 v3(184.65,66.04) 185.56,66.04 187.37,67.85 187.77,67.85 188.34,68.43 188.52,68.43 CH31.1
PEG_HTX_GRX_P3: length 14.5
  BOTTOM w0.076: 180.02,68.09 180,68.09 179.91,68 179.26,68 179.02,68.24 178.4,68.24 178.3,68.14 177.87,68.14 177.71,68.3 177.71,68.42 177.78,68.49 UH1.A13
  BOTTOM w0.152: CH29.1 189.89,70.3 188.37,70.3 187.38,69.3 186.63,69.3 v3(186.11,68.78) 184.89,67.57 183.13,67.57 182.61,68.09 180.02,68.09
PEG_HTX_GRX_P4: length 13.2
  BOTTOM w0.076: 180.01,68.56 179.99,68.56 179.9,68.64 178.51,68.64 178.36,68.79 177.14,68.79 176.93,69 176.93,69.13 UH1.C14
  BOTTOM w0.152: 180.01,68.56 v3(181.33,68.56) 185.14,68.56 186.6,70.02 187.39,70.02 188.29,70.92 188.5,70.92 CH27.1
PEG_HTX_GRX_P5: length 14.3
  BOTTOM w0.076: 179.86,69.7 179.84,69.7 179.75,69.61 179.25,69.61 178.96,69.9 178.42,69.9 178.24,69.72 177.86,69.72 177.71,69.87 177.71,69.98 177.79,70.07 UH1.A15
  BOTTOM w0.152: CH25.1 189.89,72.39 188.13,72.39 187.28,71.54 v3(186.93,71.54) 186.54,71.54 185.3,70.3 184.79,70.3 184.19,69.7 179.86,69.7
PEG_HTX_GRX_P6: length 13.5
  BOTTOM w0.076: UH1.C16 176.91,70.73 176.91,70.63 177.13,70.4 178.32,70.4 178.44,70.28 179.53,70.28 179.62,70.19 179.64,70.19
  BOTTOM w0.152: CH23.1 188.43,73.15 187.48,73.15 185.22,70.9 184.57,70.9 183.87,70.19 v3(183.41,70.19) 179.64,70.19
PEG_HTX_GRX_P7: length 14.4
  BOTTOM w0.076: UH1.A17 177.8,71.64 177.7,71.54 177.7,71.45 177.85,71.29 178.35,71.29 178.49,71.43 179.07,71.43 179.27,71.22 179.79,71.22 179.88,71.31 179.9,71.31
  BOTTOM w0.152: 179.9,71.31 v3(180.46,71.31) 183.41,71.31 184.33,72.24 184.93,72.24 187.13,74.44 189.9,74.44 CH21.1
PEG_HTX_GRX_P8: length 13.8
  BOTTOM w0.076: UH1.B18 177.29,72.57 177.19,72.57 177.07,72.44 177.07,72.19 177.14,72.12 177.68,72.12 177.81,71.99 178.41,71.99 178.52,71.88 180.06,71.88 180.15,71.79 180.17,71.79
  BOTTOM w0.152: 180.17,71.79 183.24,71.79 184.43,72.99 185.04,72.99 v3(185.22,73.17) 187.13,75.08 188.41,75.08 CH19.1
PEG_HTX_GRX_P9: length 14.5
  BOTTOM w0.076: UH1.B19 177.94,72.71 178.39,72.71 178.5,72.82 178.93,72.82 179.07,72.68 180.13,72.68 180.22,72.59 180.23,72.59
  BOTTOM w0.152: 180.23,72.59 182.92,72.59 v3(183.34,73.02) 186.21,75.88 187.97,75.88 188.08,75.99 189.4,75.99 189.51,76.1 189.87,76.1 CH17.1
PEG_HTX_GRX_P10: length 13.2
  BOTTOM w0.076: UH1.B20 177.15,74 177.08,73.94 177.08,73.8 177.18,73.71 179.62,73.71 179.71,73.8 179.73,73.8
  BOTTOM w0.152: CH15.1 188.02,77.26 186,77.26 v3(185.22,76.48) 182.54,73.8 179.73,73.8
PEG_HTX_GRX_P11: length 14.1
  BOTTOM w0.076: 179.71,74.3 179.69,74.3 179.6,74.38 179.13,74.38 179.05,74.47 178.49,74.47 178.33,74.3 177.73,74.3 177.55,74.49 177.55,74.68 UH1.B21
  BOTTOM w0.152: CH13.1 189.29,78.01 185.96,78.01 183.84,75.89 v3(183.84,75.88) 183.82,75.88 182.24,74.3 179.71,74.3
PEG_HTX_GRX_P12: length 13.5
  BOTTOM w0.076: 179.74,75.42 179.72,75.42 179.63,75.33 178.99,75.33 178.82,75.16 178.4,75.16 178.32,75.23 177.14,75.23 177.05,75.33 177.05,75.49 177.13,75.58 UH1.B22
  BOTTOM w0.152: 179.74,75.42 181.78,75.42 v3(185.17,78.81) 185.98,79.61 187.88,79.61 CH11.1
PEG_HTX_GRX_P13: length 14.4
  BOTTOM w0.076: UH1.B23 177.57,76.22 177.57,76.08 177.78,75.87 178.48,75.87 178.6,75.99 180.77,75.99 180.85,75.9 180.87,75.9
  BOTTOM w0.152: CH9.1 189.29,80.35 188.93,80.35 188.79,80.5 186.21,80.5 v3(182.46,76.74) 181.62,75.9 180.87,75.9
PEG_HTX_GRX_P14: length 14
  BOTTOM w0.076: UH1.B24 177.43,77.24 177.37,77.3 177.15,77.3 177.06,77.22 177.06,76.95 177.14,76.87 177.74,76.87 177.9,76.71 178.31,76.71 178.43,76.59 180.36,76.59 180.84,77.07 180.96,77.07 180.98,77.08
  BOTTOM w0.152: 180.98,77.08 181.5,77.61 182.22,77.61 v3(182.66,78.06) 186.23,81.62 187.83,81.62 CH7.1
PEG_HTX_GRX_P15: length 13.4
  BOTTOM w0.076: 180.53,78 180.52,77.98 180.39,77.98 179.95,77.54 178.51,77.54 178.41,77.45 177.88,77.45 177.78,77.55 177.65,77.67 177.65,77.72 UH1.B25
  BOTTOM w0.152: CH5.1 187.85,83.68 187.57,83.68 186.31,82.42 185.91,82.42 v3(185.08,81.59) 181.9,78.41 180.94,78.41 180.53,78
PEG_RCOMP: length 7
  BOTTOM w0.076: RH24.2 174.39,56.09 v1(173.86,55.56)
  BOTTOM w0.254: UH1.G2 174.88,60.46 174.88,59.51 175.26,59.13
  BOTTOM w0.381: 175.26,59.13 175.67,58.72 175.67,57.52 174.66,56.51 RH24.2
PEX_TERMP: length 7.2
  BOTTOM w0.102: UV18.AP29 194.46,81.9 192.72,83.63
  BOTTOM w0.14: v1(189.59,85.66) 189.85,85.4 RV578.2 191.91,85.4 192.72,84.58 192.72,83.63
PEX_TSTCLK_OUT: length 1.2
  TOP w0.14: v2(199.07,78.93) 199.25,79.11 T4991.1
  BOTTOM w0.102: UV18.AJ26 198.69,79.32 v2(199.07,78.93)
PEX_TSTCLK_OUT#: length 1.6
  TOP w0.14: T4992.1 197.88,79.3 v2(198.31,78.87)
  BOTTOM w0.102: v2(198.31,78.87) 197.84,79.34 UV18.AK26
PEX_VDD_EN: length 117
  TOP w0.14: U33.20 204.77,53.04 203.84,53.98 v2(203.65,53.98)
  IN6 w0.099: v2(246.84,111.34) 247.37,111.34 248.43,110.29 248.43,108.31 248.01,107.89 248.01,99.08 251.57,95.52 251.57,67.93 251.07,67.43 251.07,55.27 250.28,54.48 249.88,54.48 247.97,52.58 240.58,52.58 238.37,50.37 235.37,50.37 232.98,47.98 229.64,47.98 229.07,47.41 228.03,47.41 227.43,48.01 223.52,48.01 222.51,46.99 221.36,46.99 220.98,47.37 216.66,47.37 215.9,48.13 215.9,49.4 215.42,49.89 213.34,49.89 210.47,52.76 204.6,52.76 203.65,53.71 v2(203.65,53.98)
  BOTTOM w0.14: PR907.1 246.55,111.05 v2(246.84,111.34)
PIN5_PD#: length 1.4
  TOP w0.14: UI3.5 319.29,34.79 RI36.1
PJRSVD1: length 1.3
  TOP w0.089: v2(92.67,14.35) 92.87,14.56 93.31,14.56 T4960.1
  BOTTOM w0.089: v2(92.67,14.35) 92.81,14.2 UH2.AH14
PJRSVD2: length 1.2
  TOP w0.089: v2(92.1,13.22) 92.46,13.58 T4959.1
  BOTTOM w0.089: UH2.AH15 92.04,13.29 v2(92.1,13.22)
PJRSVD3: length 1.8
  TOP w0.089: v2(84.84,20.49) 84.95,20.6 T4957.1
  BOTTOM w0.089: UH2.N32 84.28,21.06 v2(84.84,20.49)
PJRSVD4: length 1.3
  TOP w0.089: v2(84.59,19.99) 84.51,20.07 T4958.1
  BOTTOM w0.089: UH2.R32 84.29,19.99 v2(84.59,19.99)
PJRSVD5: length 2.1
  TOP w0.089: T4956.1 82.37,19.28 v2(81.76,18.68)
  BOTTOM w0.089: v2(81.76,18.68) 81.76,18.85 82.08,19.16 UH2.U35
PJRSVD6: length 1.2
  TOP w0.089: T4955.1 81.43,18.93 v2(81.22,18.72)
  BOTTOM w0.089: v2(81.22,18.72) 81.59,19.09 UH2.U37
PJRSVD7: length 1.6
  TOP w0.089: v2(93.2,17.14) 93.2,17.58 T4953.1
  BOTTOM w0.089: v2(93.2,17.14) 93.2,17.53 UH2.Y14
PJRSVD8: length 1.9
  TOP w0.089: T4954.1 92.61,16.65 v2(92.61,17.13)
  BOTTOM w0.089: v2(92.61,17.13) 92.04,17.7 UH2.Y15
PLTRST_CPU#: length 135.5
  TOP w0.14: v2(132.18,85.88) 131.67,85.88 v5(131.59,85.79) 130.64,84.84 128.52,84.84 128.36,84.99 121.26,84.99 120.27,85.98 120.27,90.77 119.19,91.85 RH480.1
  IN1 w0.099: v2(132.18,85.88) 132.46,85.59 132.46,84.43 132.16,84.13 130.69,84.13 130.2,84.62 129.44,84.62 128.96,84.14 128.96,83.47 130.38,82.04 130.38,79.96 128.21,77.79 128.21,65.61 124.47,61.88 124.47,58.14 124.98,57.63 124.98,56.43 124.83,56.27 124.83,55.68 v2(124.93,55.58)
  IN2 w0.089: 101.98,26.75 99.38,24.14 99.38,23.25 97.97,21.84 97.97,19.88 94.59,16.5 94.59,15.01 95.41,14.2 95.93,14.2 v2(96.35,14.62)
  IN2 w0.099: v2(124.93,55.58) 124.93,49.5 119.52,44.09 119.52,36.4 121.9,34.01 121.9,28.78 121.44,28.33 110.9,28.33 110.25,28.98 106.94,28.98 105.44,27.48 102.72,27.48 101.98,26.75
  BOTTOM w0.076: UH1.BP35 138.43,84.47 137.73,84.47 137.64,84.38 136.71,84.38 135.31,85.77 134.62,85.77
  BOTTOM w0.089: v2(96.35,14.62) 96.35,14.5 96.55,14.3 UH2.AG5
  BOTTOM w0.14: 134.62,85.77 134.52,85.88 v2(132.18,85.88)
PM_LANPHY_ENABLE: length 4.4
  BOTTOM w0.089: 79.71,1.91 79.71,2.04 79.77,2.1 79.77,2.25 79.5,2.52 79.5,2.9 78.8,3.61 78.8,3.82 79.33,4.35 79.38,4.4 79.38,5.13 UH2.BF41
  BOTTOM w0.14: 79.71,1.91 RH5842.1
PMRSVD1: length 5.3
  BOTTOM w0.089: 101.98,6.89 99.51,6.89 UH2.BC1
  BOTTOM w0.14: 101.98,6.89 102.41,6.89 103.52,8 T4961.1
PMRSVD2: length 1.7
  TOP w0.089: v2(82.97,17.27) 82.55,17.69 T4963.1
  BOTTOM w0.089: UH2.Y35 82.46,17.78 v2(82.97,17.27)
PMRSVD3: length 1.7
  TOP w0.089: v2(82.37,17.22) 82.63,16.97 T4962.1
  BOTTOM w0.089: v2(82.37,17.22) 81.69,17.91 UH2.Y36
POWER_SW_IN#: length 18.4
  TOP w0.14: v2(296.96,13.37) UE3.D5 ; v2(288.62,13.39) 288.8,13.56 288.8,14.15 288.37,14.58 CE30.1 RE34.2 RE110.1 RE36.1 v1(289.38,18.16)
  IN6 w0.076: v2(296.96,13.37) 296.57,12.97 295.17,12.97 294.82,13.32 293.56,13.32
  IN6 w0.099: v2(288.62,13.39) 288.62,12.93 289.18,12.37 289.95,12.37 290.07,12.24 290.07,11.62 290.44,11.26 291.46,11.26 292.11,11.91 292.11,12.95 292.7,13.54 293.23,13.54 293.45,13.32 293.56,13.32
PP_HV: length 1.2
  TOP w0.14: 22.58,54.79 v1(21.43,54.79)
  vias: v2(23.59,54.91) v2(23.9,54.39)
PROC_DETECT#: length 123.9
  TOP w0.127: 82.98,34.21 82.46,33.69 82.46,31.81 80.93,30.28 80.74,30.28 79.58,29.12 78.92,29.12 78.39,28.59 78.39,27.64 78.03,27.28 77.3,27.28 76.84,26.82 74.92,26.82 73.93,25.83 73.93,24.53 73.66,24.26 v1(73.34,24.26) 73.17,24.08 v2(72.7,24.08)
  TOP w0.14: v2(103.34,33.24) 103.34,32.86 103.66,32.54 103.66,32.26 103.08,31.68 86.09,31.68 84.86,32.91 84.86,33.31 83.96,34.21 82.98,34.21
  IN2 w0.089: 75.96,14.92 75.96,14.7 77.29,13.36 78.88,13.36 79.23,13.01 79.23,12.71 79.65,12.29 v2(79.65,11.69) ; 74.48,18.57 74.48,16.4 75.88,15
  IN2 w0.099: 74.48,18.57 74.48,18.98 73.7,19.76 73.7,20.58 73.15,21.13 73.15,22.94 73.41,23.19 73.41,23.69 73.01,24.08 v2(72.7,24.08) ; 75.96,14.92 75.88,15
  IN4 w0.091: v2(103.34,33.24) 103.21,33.37 103.21,34.04 104.2,35.03 104.2,36.36 104.74,36.9 106.93,36.9 110.54,40.51 110.54,41.3 112.68,43.44 113.53,43.44 114.97,44.88 117.75,44.88 120.01,47.14 120.01,49.87 120.28,50.14 120.28,54.09 120.87,54.68 120.87,57.12 120.78,57.21 120.78,60.11 122.52,61.85 122.52,62.58 126.86,66.92 126.86,80.25 129.05,82.44 129.05,83.82 129.31,84.08 v2(129.53,84.08)
  BOTTOM w0.089: UH2.AP41 79.63,11.22 79.63,11.66 v2(79.65,11.69)
  BOTTOM w0.14: v2(129.53,84.08) 130.11,84.08 130.24,83.95 RH519.1
PROC_DETECT#_R: length 8.4
  BOTTOM w0.076: UH1.BR33 137.75,82.87 136.76,82.87 136.58,83.05 134.68,83.05 134.66,83.06 134.62,83.06
  BOTTOM w0.14: 134.62,83.06 133.77,83.06 133.65,82.94 133.2,82.94 132.97,83.18 132.65,83.18 v1(132.22,83.61) 131.88,83.95 RH519.2 131.22,84.58 RH1958.2
PROCHOT#_ISL88738: length 18.5
  TOP w0.203: PU1900.23 51.37,16.11 52.62,17.36 v2(53.29,17.36) 53.29,17.53 53.79,18.04 PR1919.2
  IN3 w0.254: v2(53.29,17.36) 54.55,16.09 56.26,16.09 56.82,15.53 56.82,14.71 57.73,13.79 58.68,13.79 58.86,13.98 60.85,13.98 62.3,15.43 62.67,15.43 v2(62.87,15.62)
  BOTTOM w0.14: v1(63.48,14.34) 63.48,15.01 v2(62.87,15.62)
  BOTTOM w0.254: PQ224.1 62.88,16.17 62.88,15.64 v2(62.87,15.62)
PS8713_PD#: length 18.4
  TOP w0.14: v2(321.63,44.71) RI46.2 ; RI36.2 318.01,34.8 315.98,36.83 v1(315.98,37.21) v2(315.98,38.61)
  IN4 w0.099: v2(321.63,44.71) 322.58,43.75 322.58,39.75 321.69,38.86 316.23,38.86 v2(315.98,38.61)
PS8713_PD#_R: length 3.6
  TOP w0.14: RI46.1 323.61,44.64 v1(324.61,44.64) 324.93,44.96 326.58,44.96 QI10.1
PS_ID: length 384.5
  TOP w0.076: UE3.J6 v2(300.96,14.17)
  TOP w0.14: v2(23.42,90.16) 22.62,90.16 v1(22.58,90.12) 22.05,89.59 PR101.2 22.05,86.92 22.23,86.74 22.66,86.74 PR100.2 22.66,86.35 22.53,86.23 PQ100.3
  IN2 w0.099: v2(60.04,22.82) 60.04,21.58 60.47,21.15 60.61,21.15 61.65,20.11 61.85,20.11 62.71,19.25 62.71,18.16 63.39,17.49 63.39,15.55 63.81,15.13 63.81,13.62 63.45,13.26 v2(63.45,11.61)
  IN4 w0.091: v2(60.04,22.82) 60.14,22.92 60.14,31.18 57.66,33.66 45.39,33.66 44.06,34.98 39.26,34.98 34.95,39.29 34.95,41.72 35.4,42.17 36.96,42.17 37.21,42.42 37.21,43.37 35.25,45.61 34.43,46.66 29.97,51.22 29.97,52.7 29.05,53.62 29.05,55.77 27.85,56.96 27.85,66.2 27.86,66.21 27.86,74.41 27.69,74.59 27.69,80.94 27.86,81.12 27.86,87.34 26.26,88.95 24.64,88.95 v2(23.42,90.16)
  IN5 w0.089: 101.98,9.8 101.67,9.8 ; 79.46,11.2 78.82,11.84 76.22,11.84 75.74,12.32 75.74,12.91 74.78,13.87 74.68,13.87 74.56,13.98 73.72,13.98 73.61,13.87 73.28,13.87
  IN5 w0.099: v2(300.96,14.17) 303.38,14.17 303.78,14.57 303.78,15.24 303.54,15.48 303.54,18.93 302.11,20.36 300.71,20.36 300.49,20.58 299.82,20.58 299.65,20.4 299.14,20.4 298.52,21.01 298.52,21.97 297.57,22.92 294.94,22.92 294.12,22.1 291.47,22.1 291.35,21.98 288.98,21.98 288.02,21.02 288.02,19.19 286.96,18.13 275.99,18.13 274.65,16.79 267.5,16.79 265.17,14.46 263.14,14.46 262.86,14.74 256.95,14.74 256.37,14.16 253.2,14.16 252.28,15.07 250.75,15.07 248.62,17.21 215.49,17.21 215.17,17.53 205.99,17.53 204.73,18.78 181.25,18.78 177.02,14.56 164.71,14.56 164.25,15.02 145.01,15.02 143.9,13.9 140.16,13.9 139.61,13.35 132.15,13.35 131.85,13.06 122.91,13.06 121.48,11.62 115.51,11.62 115.03,11.15 113.56,11.15 113.24,10.83 112.21,10.83 111.28,9.89 108.19,9.89 108.01,9.71 106.74,9.71 105.85,8.82 104.5,8.82 103.52,9.8 101.98,9.8 ; 101.67,9.8 101.27,9.8 100.7,9.23 99.5,9.23 98.9,9.82 97.08,9.82 96.6,10.3 95.98,10.3 95.48,10.8 94.78,10.8 94.29,10.31 92.61,10.31 91.94,9.65 89.65,9.65 89.57,9.73 87.27,9.73 86.36,10.64 85.05,10.64 84.94,10.53 81.59,10.53 80.75,11.38 80.09,11.38 79.92,11.2 79.46,11.2 ; v2(63.45,11.61) 63.45,11.15 64.13,10.47 65.76,10.47 67.44,12.15 68.64,12.15 70.36,13.87 73.28,13.87
PSID: length 9
  TOP w0.14: v5(27.73,84.8) 27.73,83.71 27.34,83.33 PR102.1 27.13,83.33 26.65,83.81 25.92,83.81 v2(25.57,84.16)
  BOTTOM w0.14: v2(25.57,84.16) 24.88,84.85 ADP100.4
PSID-1: length 5.2
  TOP w0.14: v1(24.45,90.53) 25.16,89.81 PQ101.2 24.18,88.34 23.52,88.34 23.24,88.06 PR105.1 22.66,87.86 PR103.2
PSID-2: length 5.1
  TOP w0.14: v1(26.26,88.72) 25.52,88.72 PQ101.1 24.51,87.07 24.44,87 PR104.1 24.44,86.13 24.46,86.11 PQ100.2
PTP_DIS#: length 127.8
  TOP w0.14: v2(297.76,12.57) UE3.F4
  IN3 w0.091: v2(280.62,14.28) 271.58,14.28 270.38,13.08 266.57,13.08 263.91,10.42 227.46,10.42 v2(226.95,9.91)
  IN6 w0.076: v2(297.76,12.57) 297.35,12.16 295.52,12.16 294.56,13.12 293.56,13.12
  IN6 w0.099: 293.56,13.12 293.36,13.12 293.15,13.33 292.79,13.33 292.32,12.87 292.32,11.55 290.34,9.58 290.34,8.66 290.15,8.47 287.89,8.47 287.09,9.27 287.09,9.96 287.56,10.42 287.56,11.09 287.32,11.33 287.32,12.29 286.51,13.1 286.51,13.13 286.27,13.37 286.25,13.37 286.2,13.41 281.48,13.41 v2(280.62,14.28)
  BOTTOM w0.14: JTP.3 191,11.44 190.2,12.24 190.2,15.01 190.82,15.64 225.53,15.64 226.95,14.23 v2(226.95,9.91)
PTP_INT#: length 116.2
  TOP w0.089: DH1.1 84.89,2.77 84.5,3.16 v2(84.5,3.2)
  TOP w0.14: QE13.1 188.55,7.06 188.55,7.06 188.55,6.45 188.53,6.43 RE138.2 v1(187.45,5.98) 187.1,5.63 v2(187.1,4.83)
  IN3 w0.089: v2(84.5,3.2) 84.5,3.16 84.74,2.92 86.23,2.92 86.59,3.28 88.08,3.28 88.93,2.43 89.62,2.43 90.02,2.82 92.27,2.82 92.98,3.53 94.57,3.53 95.24,2.86 96.03,2.86 96.26,3.09 97.13,3.09 97.73,2.49 99.6,2.49 100.18,3.07 100.18,3.53 100.52,3.87 101.51,3.87 101.98,3.41 101.98,3.41
  IN3 w0.091: v2(187.1,4.83) 186.68,4.41 184.82,4.41 184.05,5.18 182.67,5.18 182.43,4.94 177.71,4.94 177.55,5.1 174.29,5.1 173.04,3.85 168.73,3.85 167.34,5.23 162.33,5.23 161.05,3.95 152.77,3.95 150.39,1.58 125.11,1.58 124.4,2.29 117.29,2.29 116.45,1.45 111.26,1.45 110.69,2.02 110.69,3.11 110.23,3.57 107.93,3.57 107.31,2.95 102.44,2.95 101.98,3.41
PTP_INT#_R: length 7.8
  TOP w0.14: v2(187.24,9.25) 187.54,9.25 QE13.3 187.9,10.22 188.09,10.41 RE87.2 v5(186.88,10.75)
  BOTTOM w0.14: JTP.4 190,9.73 189.6,9.33 187.32,9.33 v2(187.24,9.25)
PWM1_GT: length 34
  TOP w0.203: v2(113.42,103.57) 113.42,103.95 113.66,104.19 PU1100.12
  IN4 w0.254: v2(113.42,103.57) 106.44,103.57 105.16,102.29 105.16,96.32 104.95,96.11 104.95,93.31 103.33,91.69 103.33,81.69 v2(104.61,80.4)
  BOTTOM w0.254: PU1300.1 105.18,80.84 104.75,80.4 v2(104.61,80.4)
PWM1_VCORE: length 24.5
  TOP w0.203: v2(120.84,103.58) 120.84,103.89 120.54,104.19 PU1100.25
  IN2 w0.254: v2(120.84,103.58) 121.51,103.58 122.26,104.33 122.75,104.33 123.74,105.32 124.99,105.32 125.86,104.46 133.29,104.46 134.95,106.12 134.95,109.75 v2(135.41,110.21)
  BOTTOM w0.14: v2(120.84,103.58) v1(120.04,103.58)
  BOTTOM w0.254: v2(135.41,110.21) 135.45,110.21 136.35,111.1 136.35,111.77 136.52,111.94 PU1200.1
PWM2_GT: length 43.6
  TOP w0.14: v1(113.74,101.94) 114.16,102.36 v2(114.3,102.36)
  TOP w0.203: PU1100.13 114.87,102.99 114.64,102.76 114.64,102.7 v2(114.3,102.36)
  IN4 w0.254: v2(103.82,72.56) 103.3,73.08 103.3,77.08 105.26,79.03 105.26,81.18 104.04,82.4 104.04,91.4 105.66,93.02 105.66,95.81 105.87,96.02 105.87,101.99 106.68,102.81 112.39,102.81 112.84,102.36 v2(114.3,102.36)
  BOTTOM w0.254: PU1301.1 104.23,72.96 v2(103.82,72.56)
PWM2_VCORE: length 36.7
  TOP w0.203: v2(121.17,104.23) 121.06,104.23 120.7,104.59 PU1100.26
  IN2 w0.254: v2(121.17,104.23) 121.5,104.23 122.04,104.76 122.68,104.76 123.19,105.28 123.19,106.59 123.91,107.31 125.08,107.31 128.11,110.35 132.83,110.35 134.09,111.61 136.53,111.61 136.78,111.35 140.27,111.35 142.35,113.43 142.35,114.72 143.52,115.9 144.83,115.9 145.8,116.87 145.8,118.52 146.41,119.13 v2(147.07,119.13)
  BOTTOM w0.254: v2(147.07,119.13) 147.18,119.24 PU1201.1
PWM3_VCORE: length 47.3
  TOP w0.203: PU1100.27 120.97,104.99 v2(121.14,104.82)
  IN6 w0.254: v2(156.67,119.36) 155.66,120.36 147.51,120.36 146.91,119.76 146.34,119.76 145.39,118.81 145.39,117.01 144.73,116.35 143.01,116.35 141.77,115.1 141.77,113.56 140.07,111.86 137.46,111.86 137.21,112.11 133.96,112.11 132.55,110.7 127.97,110.7 124.93,107.67 123.76,107.67 122.84,106.74 122.84,105.42 122.53,105.12 121.76,105.12 121.45,104.82 v2(121.14,104.82)
  BOTTOM w0.254: PU1202.1 156.96,119.06 v2(156.67,119.36)
PWM_FAN1: length 249.8
  TOP w0.14: RE100.2 99.74,33.45 v2(99.77,33.42) ; v2(254.58,29.87) v5(254.01,29.87) ; UE3.L10 302.56,18.17 303.92,18.17 304.17,18.42 v2(305.03,18.42)
  IN1 w0.099: v2(254.58,29.87) 258.67,25.78 265.92,25.78 266.38,26.24 269.04,26.24 270.45,24.83 277.12,24.83 277.62,25.34 284.18,25.34 285.15,26.31 289.69,26.31 289.91,26.53 291.4,26.53 292.1,27.23 297.47,27.23 299.05,28.8 299.05,30.47 299.54,30.96 v2(304.55,30.96)
  IN3 w0.091: v2(99.77,33.42) 101.2,34.86 110.95,34.86 v2(113.81,32)
  IN4 w0.091: v2(254.58,29.87) 254.5,29.87 252.32,27.69 241.05,27.69 239.76,26.4 239.76,21.58 239.21,21.02 231.71,21.02 230.51,19.81 202.88,19.81 201.87,20.83 183.83,20.83 178.69,25.97 175.3,25.97 173.83,27.45 164.21,27.45 160.26,31.4 117.17,31.4 116.01,32.55 114.35,32.55 v2(113.81,32)
  BOTTOM w0.14: v2(305.03,18.42) 304.88,18.57 304.88,22.02 304.37,22.53 304.37,25.35 304.53,25.51 304.53,27.26 303.94,27.85 303.94,30.35 v2(304.55,30.96) ; v2(99.77,33.42) 99.54,33.42 98.56,34.4 95.25,34.4 94.6,35.05 JFAN1.1
PWM_FAN2: length 60.4
  TOP w0.14: v2(302.98,21.23) 302.98,21.23 302.98,21.07 302.64,20.73 302.64,19.05 UE3.L11
  IN1 w0.099: v2(302.98,21.23) 302.98,21.5 304.85,23.37 305.96,23.37 311.29,28.7 312.68,28.7 317.88,33.91 326.01,33.91 327.85,35.75 327.85,36.45 328.23,36.83 328.23,38.55 329.69,40.01 329.69,48.39 330.09,48.79 v2(331.74,48.79)
  BOTTOM w0.14: JFAN2.1 336.6,54.7 334.73,52.83 RE101.2 334.73,50.94 334.44,50.65 331.52,50.65 331.18,50.31 v1(331.18,49.79) 331.18,49.35 v2(331.74,48.79)
PWM_SA: length 20.1
  TOP w0.14: v1(121.58,109.64) 121.22,109.28 v2(121.21,109.28)
  TOP w0.203: PU1100.35 120.58,108.19 121.03,108.64 121.03,109.11 v2(121.21,109.28)
  IN1 w0.254: v2(121.21,109.28) 119.81,107.89 119.81,104.29 119.58,104.06 119.58,102.83 118.96,102.2 118.96,101.32 117.98,100.34 117.98,98.55 117.7,98.27 117.7,95.35 117.04,94.69 v2(116.98,94.69)
  BOTTOM w0.254: v2(116.98,94.69) 116.64,94.69 116.38,94.95 PU1302.3
PWR_BTN_DOCK1#: length 3.4
  TOP w0.14: v1(24.51,54.87) 25.34,54.04 QV89.3 25.77,54.67 25.87,54.78 RT194.2 25.99,55.23 RT182.2
PWR_DEBUG#_XDP: length 4.8
  TOP w0.14: JXDP.45 129.31,97.01 129.62,97.32 129.99,97.32 RH483.2 130.47,97.78 RH488.1 130.8,96.93 131.09,97.22 v1(131.74,97.22)
PWR_TB_DOCK#: length 297.4
  TOP w0.14: v2(286.75,16.51) 286.5,16.76 v1(286.5,17.03) 286.73,17.26 287.34,17.26 RE110.2 ; v2(27.95,49.24) 27.52,49.67 RT195.2
  IN1 w0.076: 101.98,14.96 98.89,14.96 97.65,16.2 95.08,16.2 v2(94.29,16.99)
  IN1 w0.099: v2(144.12,12.42) 143.59,12.96 140.1,12.96 138.07,14.99 130.84,14.99 128.47,17.35 112.05,17.35 109.65,14.95 103.86,14.95 103.84,14.96 101.98,14.96
  IN2 w0.089: 75.07,22.54 75.37,22.23 75.37,21.2 76.05,20.52 76.05,19.08 77.49,17.64 78.46,17.64 79.53,16.57 82.39,16.57 83.01,15.95 83.01,15.65 83.56,15.1 84.04,15.1 84.35,14.79 86.61,14.79 87.02,14.38 89.29,14.38 89.7,14.79 90.02,14.79 90.6,15.37 92.3,15.37 93.65,16.71 94.02,16.71 v2(94.29,16.99)
  IN2 w0.099: 75.07,22.54 74.41,23.2 74.41,24.62 73.7,25.32 70.6,25.32 70.34,25.06 67.98,25.06 67.6,24.68 65.11,24.68 63.62,26.17 63.62,27.05 61.79,28.88 47.51,28.88 45.83,30.56 45.83,32.54 43.88,34.49 41.52,34.49 39.89,32.87 38.66,32.87 38.11,33.42 38.11,35.69 37.38,36.41 36.48,36.41 34.23,38.67 34.23,42.07 33.04,43.25 32.5,43.25 30.52,45.24 30.52,46.26 29.38,47.39 29.11,47.39 28.7,47.8 28.7,48.26 27.95,49.01 v2(27.95,49.24)
  IN5 w0.099: v2(144.12,12.42) 145.46,13.76 163.8,13.76 164.22,13.35 177.52,13.35 180.86,16.7 202.35,16.7 202.72,16.32 214.61,16.32 215.19,15.75 246.59,15.75 249.38,12.96 256.87,12.96 257.45,13.54 262.36,13.54 262.66,13.24 265.72,13.24 266.29,13.81 267.81,13.81 268.57,13.05 271.06,13.05 273.51,15.5 275.21,15.5 276.59,16.87 286.39,16.87 v2(286.75,16.51)
PWR_VGA_CORE_BOOT1:
  vias: v1(196.5,115.84)
PWR_VGA_CORE_BOOT1_1: length 1.2
  TOP w0.635: PR706.1 PC708.2
PWR_VGA_CORE_LGATE1: length 11.7
  TOP w0.203: PU700.19 194.33,114.52
  IN3 w0.762: 201.8,119.25 200.92,118.37 197.11,118.37 194.06,115.32 v2(194.06,113.92)
  vias: v1(200.41,120.78) v2(193.42,113.92) v2(201.8,119.89) v2(202.44,119.89)
PWR_VGA_CORE_PHASE1:
  vias: v1(198.18,114.24) v2(199.71,115.7) v2(199.71,115.06) v2(203.74,117.1) v2(203.77,116.49) v2(203.78,115.77)
PWR_VGA_CORE_SS: length 2.3
  TOP w0.203: PC713.1 191.68,117.77 PU700.11
PWR_VGA_CORE_TON: length 3.9
  TOP w0.203: PR704.1 191,120.41 191.45,119.95 191.83,119.95 192.09,119.7 192.09,119.51 192.34,119.25 193.36,119.25 193.53,119.08 PU700.9
PWR_VGA_CORE_TON_1: length 3.1
  TOP w0.254: PR701.1 190.48,121.1 191.36,121.1 191.91,120.55 PR704.2 192.62,119.81 PC707.1
PWR_VGA_CORE_UGATE1: length 6.8
  TOP w0.203: 196.07,116.57 PU700.2
  TOP w0.762: 197.99,117.92 199.58,117.92 200.66,116.84 v1(200.66,114.43) 200.66,113.73
  vias: v2(200.53,112.97) v2(200.53,112.4)
RC_ID0: length 2.9
  TOP w0.076: UE3.F2 298.16,11.05 298.46,10.75 298.46,9.61 298.54,9.53
  TOP w0.14: 298.54,9.53 298.59,9.47 T4982.1
REFADJ_NVVDD: length 2.7
  BOTTOM w0.203: PU1001.6 167.32,117.56 166.96,117.93 166.11,117.93 165.52,118.51 PR1007.2
REFADJ_NVVDDS: length 1.6
  BOTTOM w0.203: PR1507.2 186.27,114.69 187.07,115.49 PU1501.6
REFIN_NVVDD: length 3.1
  BOTTOM w0.203: PU1001.7 167.72,117.88 167.9,118.05 PC1017.1
  BOTTOM w0.508: PC1017.1 167.1,118.58 PR1008.1 PR1006.1
REFIN_NVVDDS: length 6.1
  TOP w0.14: PR1509.1 v1(185.34,113.41)
  TOP w0.508: v2(186.15,115.36) 186.03,115.48 PR1508.1 185.2,114.69 185.33,114.56 PR1509.1
  BOTTOM w0.203: PC1518.1 185.53,115.89 PU1501.7
  BOTTOM w0.381: PC1518.1 185.47,115.48 185.6,115.36 v2(186.15,115.36)
REM_DIODE1_N: length 427.8
  TOP w0.127: CE69.1 158.54,72.37 158.54,71.96 QE15.3 v2(158.02,70.63) ; v2(290.95,15.74) 291.12,15.57 291.34,15.57 CE32.1 292,15.67 292.4,15.67 292.63,15.9 293.89,15.9 UE3.A8
  IN2 w0.127: v2(263.22,23.39) 263.03,23.58 262.9,23.58 262.49,23.58 259.76,26.31 259.76,32.74 258.58,33.92 258.58,38.72 255.88,41.42 255.88,41.66 255.52,42.01 255.52,44.68 256.2,45.36 256.2,49.01 254.09,51.11 254.09,52.77 251.74,55.12 251.74,59.61 251.08,60.27 251.08,69.72 251.43,70.07 251.43,94.27 251.07,94.62 251.07,96.66 250.61,97.13 249.44,97.13 249.13,97.44 249.13,106.72 249.76,107.35 249.76,110.95 249.28,111.43 248.54,111.43 247.88,112.08 247.88,114.48 245.51,116.84 241.28,116.84 240.54,116.1 235.79,116.1 233.55,118.34 227.86,118.34 225.53,120.68 215.93,120.68 215.39,120.14 208.68,120.14 208.19,120.63 199.88,120.63 198.31,119.06 194.07,119.06 192.41,120.73 190.2,120.73 189.49,120.02 188.72,120.02 188.01,120.73 184.03,120.73 183.29,119.99 183.29,118.9 182.32,117.93 181.24,117.93 180.69,118.49 176.17,118.49 175.49,119.18 174.19,119.18 173.88,118.87 173,118.87 172.69,119.18 163.57,119.18 161.84,120.92 127.75,120.92 126.8,119.97 126.8,116.74 125.68,115.61 117.33,115.61 116.97,115.97 116.97,116.44 v2(116.83,116.58)
  IN3 w0.127: v2(263.22,23.39) 263.08,23.53 261.2,23.53 258,26.73 254.26,26.73 253.09,27.9 253.09,30.91 251.14,32.86 231.92,32.86 217.53,47.25 215.55,47.25 214.3,48.49 214.3,49.28 213.37,50.2 210.78,50.2 209.88,51.1 207.81,51.1 207.41,51.5 206.06,51.5 205.17,50.61 202.87,50.61 202.63,50.85 192.99,50.85 192.76,50.62 179.64,50.62 170.82,59.44 170.82,62.5 169.86,63.47 169.86,67.45 169.76,67.55 166.24,67.55 165.97,67.83 165.97,68.89 165.3,69.56 160.15,69.56 159.23,68.63 158.83,68.63 158.26,69.2 158.26,70.38 158.02,70.61 v2(158.02,70.63)
  IN6 w0.127: v2(290.95,15.74) 290.95,15.72 290.82,15.58 290.69,15.58 290.49,15.79 285.83,15.79 284.91,16.7 282.28,16.7 281.24,17.74 273.12,17.74 269.99,20.87 268.39,20.87 267.86,21.4 263.4,21.4 262.42,22.38 262.42,23.56 262.5,23.64 262.97,23.64 v2(263.22,23.39)
  BOTTOM w0.127: QE7.1 113.51,111.91 QE7.2 114.71,112.02 114.94,112.02 CE45.1 115.66,112.03 116.13,112.03 116.31,112.21 116.31,113.92 116.5,114.11 116.5,114.97 116.97,115.44 116.97,116.44 v2(116.83,116.58)
REM_DIODE1_P: length 427.5
  TOP w0.127: v2(290.95,15.1) 291.17,15.32 291.44,15.32 CE32.2 292.1,15.42 292.51,15.42 292.74,15.65 293.88,15.65 UE3.A7 ; CE69.2 158.89,72.22 158.89,71.87 QE15.2 159.32,71.26 v2(158.67,70.61) QE15.1
  IN2 w0.127: v2(117.44,116.58) 117.22,116.36 117.22,116.08 117.44,115.86 125.57,115.86 126.55,116.84 126.55,120.08 127.64,121.17 161.94,121.17 163.68,119.43 172.8,119.43 173.1,119.13 173.78,119.13 174.08,119.43 175.59,119.43 176.28,118.74 180.79,118.74 181.35,118.19 182.22,118.19 183.03,119 183.03,120.09 183.92,120.98 188.12,120.98 188.83,120.27 189.38,120.27 190.09,120.98 192.51,120.98 194.18,119.32 198.21,119.32 199.78,120.89 208.3,120.89 208.79,120.4 215.29,120.4 215.82,120.93 225.63,120.93 227.97,118.59 233.66,118.59 235.89,116.36 240.44,116.36 241.17,117.1 245.62,117.1 248.13,114.58 248.13,112.19 248.64,111.68 249.39,111.68 250.01,111.05 250.01,107.25 249.38,106.62 249.38,97.55 249.55,97.38 250.71,97.38 251.33,96.77 251.33,94.73 251.68,94.37 251.68,69.97 251.33,69.62 251.33,60.38 251.99,59.72 251.99,55.22 254.34,52.87 254.34,51.22 256.45,49.11 256.45,45.25 255.78,44.58 255.78,42.12 256.13,41.76 256.13,41.52 258.83,38.82 258.83,34.03 260.01,32.85 260.01,26.41 262.6,23.83 262.9,23.83 263.03,23.83 v2(263.21,24.01)
  IN3 w0.127: v2(158.67,70.61) 158.51,70.45 158.51,69.31 158.93,68.89 159.12,68.89 160.05,69.81 165.41,69.81 166.22,69 166.22,67.93 166.35,67.81 169.86,67.81 170.11,67.56 170.11,63.57 171.08,62.61 171.08,59.55 179.75,50.88 192.66,50.88 192.89,51.11 202.73,51.11 202.98,50.86 205.06,50.86 205.95,51.75 207.52,51.75 207.92,51.35 209.99,51.35 210.88,50.46 213.48,50.46 214.55,49.38 214.55,48.6 215.65,47.5 217.64,47.5 232.03,33.11 251.25,33.11 253.34,31.02 253.34,28.01 254.36,26.99 258.11,26.99 261.31,23.79 262.85,23.79 263.07,24.01 v2(263.21,24.01)
  IN6 w0.127: v2(290.95,15.1) 290.73,15.33 290.59,15.33 290.38,15.53 285.72,15.53 284.81,16.45 282.17,16.45 281.13,17.49 273.01,17.49 269.89,20.61 268.29,20.61 267.75,21.15 263.3,21.15 262.17,22.27 262.17,23.67 262.4,23.89 263.09,23.89 v2(263.21,24.01)
  BOTTOM w0.127: QE7.3 114.66,111.76 115.01,111.76 CE45.2 115.61,111.77 116.23,111.77 116.56,112.1 116.56,113.82 116.75,114.01 116.75,114.87 117.22,115.34 117.22,116.36 v2(117.44,116.58)
REM_DIODE2_N: length 271.9
  TOP w0.127: v2(290.97,18.57) 290.97,18.54 291.12,18.39 291.36,18.39 CE33.1 292.02,18.44 292.49,18.44 293.43,17.5 293.89,17.5 UE3.A10 ; v2(261.07,7.27) 260.89,7.45 260.89,8.18 260.47,8.6 260.47,11.32 260.84,11.69 260.84,23.46 260.63,23.67 260.63,28.53 259.79,29.37 259.79,31.89 252.17,39.51 248.59,39.51 247.52,40.58 221.61,40.58 221.3,40.88 196.81,40.88 193.5,44.2 193.5,46.39 191.72,48.17 189.76,48.17 189.65,48.27 189.65,48.48 CE47.2 189.74,48.92 189.74,49.55 QE6.3 190.06,50.68 191.53,52.16 191.59,52.21 191.58,52.28 191.67,52.37 191.78,52.48 191.78,53.85 195.78,57.86 195.98,57.86 196.12,57.72 196.12,57.49 v2(195.98,57.36)
  IN1 w0.127: v2(193.55,94.36) 193.49,94.36 193.24,94.62 191.56,94.62 190.77,93.83 190.77,90.56 189.45,89.24 189.45,88.07 187.49,86.11 186.31,86.11 185.9,85.7 185.9,69.86 191.43,64.34 191.43,62.43 196.17,57.69 196.17,57.55 v2(195.98,57.36)
  IN3 w0.127: v2(290.97,18.57) 290.95,18.55 290.95,18.53 290.78,18.37 290.5,18.37 290.21,18.08 290.21,16.54 289.67,16 288.98,16 288.37,15.39 288.37,14.5 289.18,13.69 289.18,13.06 288.95,12.83 287.68,12.83 287.28,12.43 287.28,10.57 285.85,9.15 282.28,9.15 281.52,8.38 273.71,8.38 272.12,6.8 268.14,6.8 267.83,7.11 262.44,7.11 261.89,6.55 261.16,6.55 260.94,6.78 260.94,7.14 v2(261.07,7.27)
  IN6 w0.127: v2(173.89,120.12) 174.09,119.91 174.67,119.91 174.86,119.72 176.15,119.72 177.93,117.94 182.15,117.94 183.27,119.06 183.27,120.02 183.98,120.73 187.77,120.73 188.43,120.08 189.55,120.08 190.2,120.73 192.98,120.73 195.01,118.7 195.01,111.9 197.28,109.63 199.69,109.63 201.68,107.64 201.68,105.51 202.12,105.07 202.12,101.22 194.88,93.98 193.93,93.98 v2(193.55,94.36)
  BOTTOM w0.127: QE5.1 174.3,117.65 173.79,118.16 173.79,118.63 174.14,118.99 QE5.2 174.52,119.63 CE46.2 174.14,120.78 173.89,120.52 v2(173.89,120.12)
REM_DIODE2_P: length 270.8
  TOP w0.127: v2(196.61,57.36) 196.37,57.6 196.37,57.83 196.09,58.11 195.68,58.11 191.52,53.96 191.52,52.59 191.49,52.55 191.4,52.46 191.33,52.45 191.28,52.4 190.35,51.47 QE6.1 189.41,50.52 QE6.2 189.35,49.27 189.35,49.09 CE47.1 189.4,48.35 189.4,48.17 189.65,47.92 191.62,47.92 193.24,46.29 193.24,44.09 196.71,40.63 221.2,40.63 221.5,40.32 247.42,40.32 248.49,39.25 252.07,39.25 259.53,31.79 259.53,29.27 260.38,28.42 260.38,23.56 260.59,23.35 260.59,11.8 260.22,11.42 260.22,8.49 260.64,8.07 260.64,7.45 v2(260.46,7.27) ; UE3.A9 293.88,17.25 293.32,17.25 292.38,18.19 292.08,18.19 CE33.2 291.42,18.14 291.19,18.14 v2(290.98,17.93)
  IN1 w0.127: v2(196.61,57.36) 196.42,57.55 196.42,57.8 191.68,62.54 191.68,64.44 186.16,69.97 186.16,85.6 186.42,85.85 187.59,85.85 189.7,87.96 189.7,89.14 191.02,90.46 191.02,93.72 191.66,94.37 192.49,94.37 192.69,94.16 v2(192.99,94.16)
  IN3 w0.127: v2(290.98,17.93) 290.79,18.11 290.6,18.11 290.46,17.98 290.46,16.44 289.77,15.75 289.09,15.75 288.62,15.28 288.62,14.61 289.43,13.8 289.43,12.96 289.05,12.57 287.78,12.57 287.53,12.32 287.53,10.46 285.96,8.89 282.39,8.89 281.62,8.13 273.81,8.13 272.23,6.54 268.03,6.54 267.72,6.86 262.55,6.86 261.99,6.3 261.06,6.3 260.68,6.68 260.68,7.05 v2(260.46,7.27)
  IN6 w0.127: v2(192.99,94.16) 193.42,93.73 194.99,93.73 202.38,101.12 202.38,105.17 201.93,105.62 201.93,107.75 199.8,109.88 197.39,109.88 195.26,112.01 195.26,118.81 193.09,120.99 190.1,120.99 189.44,120.33 188.53,120.33 187.88,120.99 183.88,120.99 183.02,120.13 183.02,119.17 182.05,118.19 178.04,118.19 176.25,119.98 175.27,119.98 175.11,120.14 v2(175.07,120.14)
  BOTTOM w0.127: v2(175.07,120.14) 175.07,120.41 CE46.1 175.58,120.64 175.58,119.39 QE5.3
REM_DIODE3_N: length 330.7
  TOP w0.076: 292.99,16.7 293.01,16.7 293.03,16.67 294.66,16.67 UE3.B9
  TOP w0.127: 292.99,16.7 292.45,16.7 292,17.15 290.65,17.15 CE35.1 290.07,17.48 v2(289.64,17.04)
  IN1 w0.127: v2(39.64,39.07) 39.84,39.27 39.94,39.27 40.07,39.14 40.07,37.35 41.5,35.92 43.79,35.92 45.39,34.31 45.39,30.44 45.97,29.86 55.83,29.86 57.65,30.61 59.25,32.21 59.25,33.02 60.14,33.91 63.68,33.91 64.92,32.67 69.37,32.67 70.48,33.77 75.06,33.77 75.63,34.33 80.83,34.33 81.32,33.85 82.44,33.85 86.07,37.48 88.46,37.48 90.51,39.52 93.59,39.52 95.32,41.25 95.32,41.6 95.07,41.85 95.07,41.87 94.92,42.01 v2(94.92,42.2)
  IN2 w0.127: v2(118.64,36.22) 118.19,36.22 114.28,40.13 110.03,40.13 107.25,42.91 96.35,42.91 95.31,41.87 95.13,41.87 94.92,42.08 v2(94.92,42.2)
  IN3 w0.127: v2(190.07,53.36) 190.25,53.19 190.25,52.82 190.84,52.22 192.23,52.22 192.42,52.41 210.12,52.41 211.56,50.97 219.53,50.97 220.66,49.83 220.66,48.57 221.15,48.08 222.45,48.08 223.18,47.36 223.18,44.18 223.94,43.42 223.94,42.38 231.42,34.9 252.56,34.9 256.07,31.39 256.07,30.46 260.85,25.68 263.89,25.68 264.35,25.21 264.35,24.8 264.14,24.58 263.93,24.58 v2(263.8,24.71)
  IN6 w0.127: v2(263.8,24.71) 263.92,24.59 264.31,24.59 264.74,25.03 267.24,25.03 268.19,24.08 268.19,22.58 268.82,21.95 270.28,21.95 272.48,19.75 275.87,19.75 276.77,18.86 281.2,18.86 282.51,17.55 289.13,17.55 v2(289.64,17.04)
  BOTTOM w0.127: v2(118.64,36.22) 118.64,35.97 119.47,35.14 164.78,35.14 178.7,49.06 179.61,49.06 179.74,48.93 179.74,48.23 179.91,48.06 180.22,48.06 180.48,48.32 QE8.2 180.48,49.03 179.83,49.68 QE8.1 179.99,50.19 181.2,50.19 181.45,49.94 181.75,49.94 CE49.2 182.3,49.9 187.44,49.9 190.25,52.71 190.25,53.19 v2(190.07,53.36) ; v2(39.64,39.07) 39.85,39.28 40.04,39.28 40.32,39.57 40.32,40.38 37.54,43.16 37.54,43.98 34.41,47.12 34.41,47.84 32.27,49.98 31.71,49.98 30.98,50.71 30.98,50.91 29.74,52.14 CE68.2 29.12,51.66 29.12,50.08 28.93,49.89 QE11.3
REM_DIODE3_P: length 329.7
  TOP w0.076: 292.99,16.44 293.01,16.44 293.03,16.47 294.66,16.47 UE3.B8
  TOP w0.127: 292.99,16.44 292.35,16.44 291.9,16.89 v3(291.52,16.89) 290.65,16.89 CE35.2 290.16,16.4 289.28,16.4 289.15,16.52 v2(289.15,16.66)
  IN1 w0.127: v2(94.57,41.6) 94.96,41.6 95.06,41.5 95.06,41.36 93.49,39.78 90.4,39.78 88.35,37.73 85.97,37.73 82.34,34.1 81.43,34.1 80.94,34.59 75.52,34.59 74.96,34.03 70.37,34.03 69.27,32.92 65.03,32.92 63.78,34.16 60.03,34.16 58.99,33.13 58.99,32.31 57.5,30.83 55.78,30.11 46.08,30.11 45.64,30.54 45.64,34.42 43.89,36.17 41.61,36.17 40.32,37.46 40.32,39.24 40.04,39.52 39.82,39.52 v2(39.64,39.7)
  IN2 w0.127: v2(94.57,41.6) 95.02,41.6 95.03,41.62 95.41,41.62 96.45,42.66 107.14,42.66 109.93,39.87 114.18,39.87 118.19,35.86 v2(118.19,35.74)
  IN3 w0.127: v2(263.82,24.08) 263.89,24.08 264.14,24.33 264.24,24.33 264.61,24.69 264.61,25.32 263.99,25.93 260.96,25.93 256.33,30.57 256.33,31.49 252.67,35.15 231.53,35.15 224.19,42.48 224.19,43.53 223.43,44.29 223.43,47.46 222.56,48.34 221.25,48.34 220.92,48.67 220.92,49.94 219.63,51.22 211.67,51.22 210.22,52.67 192.32,52.67 192.13,52.48 190.95,52.48 190.5,52.92 190.5,53.21 v2(190.65,53.36)
  IN6 w0.127: v2(263.82,24.08) 264.08,24.34 264.41,24.34 264.85,24.78 267.13,24.78 267.94,23.97 267.94,22.47 268.72,21.69 270.18,21.69 272.38,19.5 275.77,19.5 276.66,18.6 281.09,18.6 282.4,17.29 289.03,17.29 289.15,17.17 v2(289.15,16.66)
  BOTTOM w0.127: v2(190.65,53.36) 190.5,53.21 190.5,52.6 187.54,49.64 182.37,49.64 CE49.1 181.51,49.28 181,49.79 180.82,49.79 180.69,49.65 180.69,49.3 181.18,48.81 181.18,48.02 180.81,47.65 179.96,47.65 QE8.3 178.44,48.43 164.89,34.89 119.36,34.89 118.51,35.74 v2(118.19,35.74) ; v2(39.64,39.7) 39.8,39.54 39.93,39.54 40.07,39.68 40.07,40.27 37.29,43.05 37.29,43.88 34.15,47.01 34.15,47.74 32.17,49.72 31.61,49.72 30.1,51.23 CE68.1 29.4,51.02 29.4,49.79 29.59,49.59 QE11.1 29.08,49.24 28.43,48.59 QE11.2
REM_DIODE4_N: length 140
  TOP w0.127: UE3.A11 294.09,18.5 293.95,18.5 292.51,19.94 v3(291.71,19.94) 290.65,19.94 CE36.1 289.97,19.91 289.61,19.91 v2(289.46,20.07)
  IN3 w0.127: v2(240.63,106.06) 240.79,105.89 241.33,105.89 242.01,105.21 242.01,103.65 241.35,102.99 241.35,101.73 242.67,100.41 242.67,98.48 243.11,98.05 245.42,98.05 248.44,95.02 250.65,95.02 251.61,94.06 251.61,72.2 251.15,71.74 251.15,59.34 251.97,58.52 251.97,55.43 254.47,52.92 254.47,44.67 256.41,42.73 256.41,40.87 259.04,38.24 259.04,32.74 259.65,32.13 259.65,30.42 261.33,28.74 269.21,28.74 272.07,25.88 277.75,25.88 278.58,25.06 278.58,24.39 v2(278.78,24.19)
  BOTTOM w0.127: QE9.3 241.63,109.35 241.63,107.39 241.38,107.14 CE72.1 v2(240.63,106.06) ; v2(289.46,20.07) 289.25,19.86 288.9,19.86 287.14,21.63 284.79,21.63 282.67,23.75 278.69,23.75 278.59,23.85 278.59,24 v2(278.78,24.19) 278.59,24.38 278.59,24.65 278.79,24.84 281.13,24.84 281.57,25.29 281.57,25.59 CE50.1 281.56,26.24 281.56,26.45 QE12.2 281.47,27.66 QE12.1
REM_DIODE4_P: length 140.2
  TOP w0.127: v2(289.5,19.43) 289.73,19.66 290.02,19.66 CE36.2 290.65,19.69 292.41,19.69 293.93,18.16 294.64,18.16 294.96,17.84 UE3.B10
  IN3 w0.127: v2(240.62,105.46) 240.79,105.64 241.22,105.64 241.76,105.11 241.76,103.76 241.1,103.1 241.1,101.63 242.42,100.31 242.42,98.38 243,97.79 245.31,97.79 248.34,94.77 250.55,94.77 251.36,93.96 251.36,72.3 250.9,71.84 250.9,59.23 251.72,58.42 251.72,55.32 254.22,52.82 254.22,44.56 256.16,42.62 256.16,40.77 258.79,38.14 258.79,32.64 259.4,32.03 259.4,30.31 261.22,28.49 269.1,28.49 271.96,25.63 277.65,25.63 278.32,24.95 278.32,24.33 v2(278.17,24.18)
  BOTTOM w0.127: v2(240.62,105.46) 240.49,105.46 240.11,105.84 240.11,106.45 CE72.2 241.11,107.45 QE9.1 241.11,108.83 QE9.2 ; QE12.3 281.31,26.53 281.31,26.24 CE50.2 281.32,25.57 281.32,25.39 281.03,25.1 278.68,25.1 278.34,24.76 278.34,24.34 v2(278.17,24.18) 278.33,24.02 278.33,23.75 278.58,23.5 282.56,23.5 284.68,21.38 287.03,21.38 288.8,19.61 289.33,19.61 v2(289.5,19.43)
RESET_IN#: length 4.1
  TOP w0.14: RE311.2 294.52,7.75 RE145.2 294.52,7.92 294.82,8.22 294.82,8.51 295.2,8.89 295.25,8.89 295.7,9.34 295.7,10.5 UE3.C1
RING2: length 14.7
  TOP w0.127: v2(9.88,58.48) v1(9.88,59.25)
  IN1 w1.27: 8.76,45.78 10.77,45.78 11.63,44.93 12.82,44.93 14.2,46.31 14.2,49.75 14.34,49.89 14.34,53.75 14.3,53.79
  vias: v2(8.64,44.74) v2(8.64,44.16) v2(9.26,58.5) v2(9.97,57.91) v2(10.55,57.95)
RING2_L: length 1.6
  TOP w0.127: JHP1.3 v1(3.2,58.5)
ROM_CS: length 1.2
  TOP w0.14: v2(216.67,62.16) 216.78,62.16 T205.1
  BOTTOM w0.102: v2(216.67,62.16) 216.24,62.59 UV18.H6
ROM_SCLK: length 21.4
  TOP w0.14: v2(230,51.12) RV644.2 230.01,51.8 RV641.1
  IN5 w0.099: v2(216.66,60.57) 216.97,60.27 216.97,59.62 217.29,59.3 217.29,56.66 220.93,53.02 226.4,53.02 227.73,51.69 229.44,51.69 v2(230,51.12)
  BOTTOM w0.102: v2(216.66,60.57) 216.24,60.99 UV18.H4
ROM_SI: length 15.8
  TOP w0.14: RV639.1 RV642.2 224.92,52.32 224.92,53.69 v1(223.45,55.16) 219.23,59.37 218.16,59.37 217.91,59.62 217.91,60.19 v2(216.69,61.41)
  BOTTOM w0.102: UV18.H5 216.3,61.8 v2(216.69,61.41)
ROM_SO: length 20.6
  TOP w0.102: 216.54,62.65 216.29,62.89 216.29,63.49 v2(215.85,63.93)
  TOP w0.14: 216.54,62.65 217.68,62.65 217.95,62.38 217.95,61.91 218.05,61.81 218.54,61.81 218.8,61.56 218.8,60.78 218.77,60.76 218.77,60.18 221.61,57.34 223.49,57.34 v1(224.59,56.24) 225.93,54.9 225.93,52.32 RV643.2 RV640.1
  BOTTOM w0.102: v2(215.85,63.93) 215.85,63.89 UV18.H7
RREF:
  vias: v1(336.87,34.93)
RT8812_PVCC: length 6.5
  TOP w0.203: PR700.1 190.53,113.13 v1(190.53,113.79) 190.61,113.87 PC706.1 191.77,114.3 192.09,114.62 193.61,114.62 193.93,114.94 PU700.18
RTCRST_ON: length 158.1
  TOP w0.076: UE3.F11 298.44,18.85 298.44,20.83
  TOP w0.14: v2(272.41,3.54) 272.41,16.09 v1(273.04,16.71) v2(275.07,18.74) ; 298.44,20.83 298.44,21.19 v2(297.84,21.79) ; QR104.2 176.76,7.38 RE143.2 176.1,6.86 175.97,6.73 C4.1 R277.1 174.37,6.73 QRTC.2 173.53,4.53 R3.2 174.13,4.7 v2(174.65,4.7) 174.77,4.7 175.59,3.87 D321.1
  IN1 w0.099: v2(275.07,18.74) 276.29,17.53 283.36,17.53 284.35,16.54 286.13,16.54 286.56,16.1 287.22,16.1 287.68,16.56 288.16,16.56 289.17,17.57 290.07,17.57 290.55,17.08 291.86,17.08 294.84,20.07 296.7,20.07 297.14,20.51 297.14,21.09 v2(297.84,21.79)
  IN2 w0.099: v2(272.41,3.54) 271.96,3.99 268.36,3.99 266.84,5.52 263.33,5.52 262.26,4.45 253.11,4.45 252.86,4.19 247.33,4.19 244.48,1.33 205.61,1.33 204.15,2.8 182.63,2.8 181.62,3.8 175.71,3.8 174.8,4.7 v2(174.65,4.7)
RTCRST_ON_R: length 12.4
  TOP w0.14: QRTC1.2 179.4,5.08 177.89,5.08 v1(177.27,4.46) 177.27,3.72 176.69,3.15 173.28,3.15 C2.1 R3.1 173.36,3.8 174.53,3.8 D321.2
RTD3_CIO_PWR_EN: length 114.2
  TOP w0.089: v2(89.92,11.22) 89.71,11.22 89.01,11.91 v1(88.95,11.91)
  IN1 w0.099: v2(19.99,49.44) 19.83,49.44 19.56,49.16 19.56,40.19 20.54,39.22 20.54,34.77 18.01,32.25 18.01,29.77 18.26,29.51 18.26,28.55 v2(21.18,25.63)
  IN6 w0.089: 74.22,18.72 74.5,18.44 74.5,17.29 76.26,15.53 76.26,14.25 77.31,13.2 79.03,13.2 79.25,12.98 79.25,12.8 79.49,12.55 79.89,12.55 80.17,12.83 86.35,12.83 87.4,11.79 89.13,11.79 89.71,11.22 v2(89.92,11.22)
  IN6 w0.099: 74.22,18.72 73.54,19.4 73.54,19.61 73.11,20.05 72.31,20.05 72.18,20.17 71.59,20.17 69.94,21.82 68.96,21.82 68.24,22.53 67.91,22.53 67.47,22.09 61.85,22.09 61.46,22.48 61.46,22.88 60.87,23.47 56.84,23.47 56.47,23.84 52.22,23.84 51.19,24.87 49.31,24.87 49.1,25.08 44.89,25.08 44.1,24.29 42.8,24.29 39.82,21.31 33.17,21.31 32.53,20.67 30.94,20.67 28.76,22.84 27.76,22.84 25.56,25.04 21.78,25.04 v2(21.18,25.63)
  BOTTOM w0.089: UH2.AP21 89.54,10.84 v2(89.92,11.22)
  BOTTOM w0.14: RT5842.2 19.23,50.9 19.67,50.46 20.27,50.46 20.45,50.28 20.45,49.69 20.2,49.44 v2(19.99,49.44) 19.72,49.44 19.58,49.57 RT39.2 RT5850.2
RTD3_CIO_PWR_EN_AR: length 12
  IN2 w0.089: v2(24.61,45.78) 24.04,46.36
  IN2 w0.099: 24.04,46.36 23.75,46.64 23.75,50.67 23.37,51.06 21.88,51.06 21.47,51.46 v2(20.11,51.46)
  BOTTOM w0.089: v2(24.61,45.78) 24.61,45.5 24.27,45.17 UT1.F1
  BOTTOM w0.14: v1(20.89,51.25) 20.68,51.46 v2(20.11,51.46) 20,51.46 19.91,51.55 19.42,51.55 RT5842.1
RTD3_USB_PWR_EN: length 10.5
  TOP w0.089: v4(22.85,43.48) 23.41,43.48 24.21,44.27 24.21,44.76 24.72,45.27 25.56,45.27 25.66,45.37 25.66,46.2 25.82,46.36
  TOP w0.14: 25.82,46.36 25.87,46.41 25.87,46.75 v1(26.18,47.05) 26.24,47.05 26.64,47.45 26.64,47.85 26.73,47.94 RT40.2 26.57,48.12 26.28,48.41 26.28,49.53 25.8,50.01 RT5841.2
  BOTTOM w0.089: UT1.D4 23.13,43.79 22.85,43.51 v4(22.85,43.48)
RUN_ON#: length 2.8
  TOP w0.14: v1(283.87,4.78) 283.87,3.89 RE56.2 284.06,3.8 QE4.6 QE4.5
RUN_ON_EC: length 402.2
  TOP w0.076: UE3.E8 v2(296.96,16.57)
  TOP w0.14: v2(113.21,53.75) 113.18,53.78 UZ20.1 ; v2(303.32,23.94) 303.27,23.94 302.9,23.56 RE35.1 ; QE4.2 286.7,4.45 286.5,4.65 286.03,4.65 285.66,4.28 v2(285.66,4.09) ; v2(240.16,3.3) 239.28,4.18 UZ6.1 236.4,2.92 v1(234.95,2.92) 234.7,3.18 RZ1956.1 231.06,8.51 230.76,8.51 230,9.27 230,10.03 230.32,10.35 230.7,10.35 231.33,9.72 UZ33.3 ; UZ1.5 263.72,39.32 264.16,38.88 RZ43.2 264.3,38.66 264.75,38.66 265.05,38.36 v2(265.05,37.92) 264.82,37.92 264.48,38.27 263.39,38.27 263.13,38.52 UZ1.3 ; v2(128.27,10.22) 128.27,10.22 129.39,11.34 129.39,15.08 127.56,16.91 119.17,16.91 118.31,17.77 117.44,17.77 116.16,19.05 115.09,19.05 114.12,20.02 112.43,20.02 111.24,21.22 111.24,26.02 108.65,28.61 108.65,36.78 111.68,39.81 116.11,39.81 122.31,46.02 122.31,48.84 121.88,49.28 v2(121.61,49.28)
  IN2 w0.099: v2(121.61,49.28) 121.61,48.92 120.86,48.17 120.23,48.17 119.81,48.59 119.81,51.57 117.1,54.27 116.25,54.27 114.83,52.85 113.42,52.85 113.21,53.05 v2(113.21,53.75)
  IN3 w0.076: 298.55,19.69 298.55,17.89 298.23,17.57 298.23,17.14 298.05,16.96 297.35,16.96 v2(296.96,16.57)
  IN3 w0.091: 298.55,19.69 298.55,20.68 300.24,22.37 304.13,22.37 304.22,22.28 305.43,22.28 305.78,22.63 305.78,23.2 305.28,23.7 303.56,23.7 v2(303.32,23.94)
  IN5 w0.099: v2(128.27,10.22) 131.91,10.22 132.68,9.45 135.81,9.45 136.4,8.86 139.55,8.86 141.02,10.34 146.38,10.34 147.25,9.47 148.33,9.47 149.14,8.65 168.17,8.65 168.92,7.9 179,7.9 179.07,7.82 179.95,7.82 v2(180.41,7.36) ; v2(276.17,23.16) 276.66,23.16 277.42,22.4 287.02,22.4 288.88,24.26 292.23,24.26 v2(293.16,23.32)
  IN6 w0.099: v2(303.32,23.94) 303.47,24.1 303.47,25.04 304.9,26.47 304.9,28.74 308.81,32.64 308.81,34.06 307.72,35.15 304.37,35.15 303.57,34.36 301.6,34.36 300.98,33.73 298.39,33.73 298.13,33.48 282.1,33.48 282.05,33.53 280.82,33.53 280.73,33.62 277.85,33.62 277.31,34.16 275.76,34.16 275.26,34.66 273.71,34.66 272.97,35.4 271.32,35.4 270.14,36.58 266.4,36.58 v2(265.05,37.92) ; v2(180.41,7.36) 182.87,7.36 184.31,5.92 201.63,5.92 203.79,8.09 209.72,8.09 214.5,3.3 v2(240.16,3.3) 243.08,3.3 245.82,6.04 253.02,6.04 253.77,5.29 262.29,5.29 262.93,5.92 270.18,5.92 270.89,5.21 274.28,5.21 274.94,4.54 280.08,4.54 280.75,3.88 285.46,3.88 v2(285.66,4.09)
  BOTTOM w0.076: v2(296.96,16.57) 296.96,16.78 296.55,17.19 296.55,17.53 296.32,17.76 294.58,17.76
  BOTTOM w0.14: 294.58,17.76 293.75,18.59 293.75,19.41 293.16,20 v2(293.16,23.32) ; v2(285.66,4.09) 280.94,4.09 279.58,5.44 279.58,8.25 280.33,8.99 280.33,13.07 279.57,13.83 279.57,17.88 276.17,21.27 v2(276.17,23.16)
