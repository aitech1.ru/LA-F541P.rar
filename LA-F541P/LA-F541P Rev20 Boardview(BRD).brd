# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB20_N2: length 136.4
  IN2 w0.089: v2(92.86,21.92) 92.66,22.12 92.66,22.53 91.98,23.21 88.58,23.21 87.26,21.89 86.28,21.89 86.11,21.73 82.17,21.73 81.44,22.46 80.63,22.46 79.57,23.53 79.17,23.53 78.73,23.97 78.73,24.31 79.12,24.69 79.12,26.85 78.59,27.38 78.59,29.18 78.6,29.19 78.6,29.21
  IN2 w0.107: 78.6,29.21 78.6,29.42 79.01,29.83 79.01,31.4 78.42,31.99 75.17,31.99 73.13,29.95 68.55,29.95 68.46,30.03 66.95,30.03 63.65,33.33 49.94,33.33 47.27,35.99 45.59,35.99 45.04,36.55 40.68,36.55 38.69,38.55 38.69,39.35 38.15,39.88 38.15,43.31 36.12,45.34 36.12,45.51 34.11,47.51 34.11,48.18 33.3,49 33.3,49.36 32.16,50.5 32.16,51.51 30.29,53.38 30.29,53.98 29.14,55.13 29.14,58.03 28.45,58.73 28.45,61.51 28.04,61.92 28.04,69.65 27.96,69.73 27.96,86.98 25.55,89.39 25.55,90.27 24.26,91.57 24.26,93.64 26.41,95.8 26.41,96.2 v2(26.61,96.4)
  BOTTOM w0.089: v2(92.86,21.92) 92.7,21.75 92.7,21.58 UH2.N13
  BOTTOM w0.152: v2(26.61,96.4) 26.46,96.55 26.46,97.3 26.54,97.38 UI1.2
USB20_N4: length 304.8
  IN1 w0.076: 99.4,19.46 99.38,19.46 99.37,19.47 97.54,19.47 97.17,19.85 96.28,19.85 95.37,20.76 95.37,21.05 95.05,21.36 v2(94.85,21.36)
  IN1 w0.107: v2(328.41,79.96) 328.22,80.15 328,80.15 327.85,80 327.85,79.7 329.6,77.94 329.6,75.17 327.43,73 327.43,66.02 329.72,63.73 329.94,63.73 330.92,62.75 330.92,61.25 329.65,59.98 329.65,56.29 326.73,53.36 326.73,49.74 325.1,48.11 325.1,41 322.95,38.85 322.19,38.85 320.28,36.95 313.42,36.95 305.13,28.65 305.13,26.54 304.63,26.04 298.67,26.04 297.08,24.45 295.24,24.45 293.39,22.6 291.34,22.6 291.01,22.26 282.13,22.26 281.79,22.61 278.82,22.61 276.82,20.61 271.23,20.61 270.59,19.97 269.07,19.97 268.24,19.14 265.33,19.14 263.73,17.54 263.73,14.99 262.14,13.4 261.72,13.4 261.34,13.02 261.34,12.11 259.88,10.64 253.02,10.64 251.73,11.93 246.82,11.93 246.32,12.42 221.4,12.42 218.25,9.27 214.38,9.27 212.35,11.3 205.4,11.3 204.59,10.49 178.05,10.49 177.17,11.37 164.4,11.37 163.75,10.72 160.12,10.72 159.45,11.38 156.15,11.38 155.39,12.14 154.65,12.14 151.28,15.52 139.37,15.52 138.38,16.51 131.67,16.51 130.4,17.77 130.4,18.87 129.77,19.51 107.26,19.51 105.77,21 103.29,21 101.75,19.46 99.4,19.46
  BOTTOM w0.089: v2(94.85,21.36) 94.54,21.67 UH2.M10
  BOTTOM w0.152: LN1.1 329.75,80.42 329.3,79.96 v2(328.41,79.96)
USB20_N4_R: length 2.2
  BOTTOM w0.152: LN1.2 329.75,82.64 329.67,82.73 329.67,83.13 329.46,83.33 329.46,83.59 329.55,83.68 JNGFF1.5
USB20_N5: length 119.9
  IN3 w0.089: v2(99.95,21.5) 99.95,20.83 99.4,20.27 98.18,20.27 97.72,19.82 96.09,19.82 95.42,19.15 92.7,19.15 91.75,20.1 90.4,20.1 89.42,21.08 88.67,21.08 87.45,22.3 80.06,22.3 78.31,24.05 76.84,24.05 75.38,25.51 75.38,25.78 75.08,26.08 75.07,26.08 75.06,26.1
  IN3 w0.099: 75.06,26.1 74.7,26.46 73.76,27.39 72.42,27.39 70.67,25.64 60.85,25.64 60.31,26.17 53.17,26.17 52.5,26.85 48.66,26.85 48.43,26.62 46.54,26.62 45.75,27.41 43.24,27.41 39.95,30.7 39.95,31.35 38.89,32.41 38.61,32.41 36.67,34.35 35.68,34.35 34.68,35.36 34.68,35.54 34.49,35.73 33.87,35.73 33.55,36.05 33.55,36.71 34.11,37.28 34.11,45.29 33.26,46.14 33.26,47.9 33.07,48.42 32.95,48.62 30.13,51.43 30.13,52.02 28.86,53.29 28.86,55.76 27.85,56.77 27.85,61.12 26.48,62.49 26.48,64.35 25.68,65.15 22.94,65.15 22.61,64.82 21.61,64.82 21.43,65.01 21.25,65.19 21.14,65.19 v2(20.72,65.6)
  BOTTOM w0.089: v2(99.95,21.5) 99.52,21.93 99.13,21.93 UH2.M1
  BOTTOM w0.152: RT1143.1 22.61,66.55 22.61,66.84 22.19,67.26 21.76,67.26 20.72,66.23 v2(20.72,65.6)
USB20_N5_R: length 6.6
  BOTTOM w0.081: 22.8,61.72 22.8,61.7 22.73,61.63 22.73,60.72 22.87,60.59 22.87,60.13 UT4.K5
  BOTTOM w0.152: 22.8,61.72 22.8,62.62 22.61,62.81 22.61,65.03 22.8,65.22 RT1142.2 22.96,65.61 RT1143.2
USB20_N7: length 244.5
  IN1 w0.076: 101.84,22.81 101.82,22.8 101.82,22.77 101,21.95 100.9,21.95 v2(100.67,22.18)
  IN1 w0.107: v2(216.14,12.2) 216.35,12.2 216.47,12.08 216.47,11.88 216.28,11.69 215.24,11.69 213.83,13.09 199.24,13.09 198.09,11.94 178.66,11.94 177.64,12.96 156.89,12.96 155.88,13.97 154.85,13.97 151.87,16.95 141.81,16.95 139.63,19.13 134.75,19.13 130.18,23.7 130.18,25.54 129.33,26.38 109.2,26.38 107.81,27.76 106.89,27.76 105.77,26.64 105.31,26.64 102.67,24 102.67,23.64 101.84,22.81
  IN2 w0.107: v2(316.46,28.54) 316.67,28.54 316.78,28.64 316.78,29.26 316.53,29.52 315.55,29.52 314.36,28.32 304.67,28.32 302.71,26.35 302.33,26.35 301.55,25.57 300.01,25.57 299.72,25.27 299.72,24.13 299,23.41 294.5,23.41 293.49,22.4 291.92,22.4 291.22,21.71 288.31,21.71 285.86,19.25 284.97,19.25 282.63,16.92 282.49,16.92 281.77,16.2 275.66,16.2 275.08,15.62 266.7,15.62 264.95,13.87 257.54,13.87 256.6,12.92 254.53,12.92 252.17,10.57 217.54,10.57 216.46,11.65 216.46,12.09 216.35,12.2 v2(216.14,12.2)
  BOTTOM w0.089: v2(100.67,22.18) 100.58,22.18 100.36,22.4 99.56,22.4 99.3,22.66 98.26,22.66 98.04,22.44 97.89,22.44 UH2.L4
  BOTTOM w0.152: v2(316.46,28.54) 316.72,28.79 316.72,29.67 316.48,29.91 ML17.4
USB20_N9: length 274.3
  IN3 w0.089: 101.85,21.39 101.83,21.4 101.83,21.41 101.22,22.02 101.22,22.19 100.86,22.54 100.52,22.54 100.23,22.25 99.34,22.25 97.4,20.31 96.46,20.31 96.2,20.57 96.2,20.77 v2(96,20.96)
  IN3 w0.099: v2(342.84,43.12) 343.03,42.92 343.33,42.92 343.75,42.51 343.75,38.22 341.18,35.65 338.35,35.65 336.63,33.93 334.67,33.93 334.04,33.3 329.48,33.3 327.42,31.24 324.34,31.24 323.65,31.94 315.14,31.94 313.31,33.77 309.28,33.77 307.12,31.61 304.58,31.61 301.73,28.75 299.47,28.75 298.91,28.2 298.07,28.2 297.84,28.42 297.26,28.42 295.9,27.07 293.78,27.07 291.13,24.42 289.84,24.42 288.18,22.76 286.04,22.76 280.71,17.42 270.2,17.42 267.82,15.05 265.97,15.05 265.03,14.11 261.37,14.11 260.79,13.53 257.51,13.53 256.62,12.64 204.22,12.64 203.84,13.02 200.5,13.02 199.71,13.81 180.3,13.81 179.86,13.36 151.56,13.36 151.46,13.46 139.64,13.46 138.77,14.33 137.69,14.33 137.5,14.52 126.77,14.52 126.24,15.05 125.35,15.05 124.88,14.58 122.55,14.58 121.94,15.19 121.37,15.19 120.07,16.49 112.56,16.49 109.6,19.44 108.99,19.44 108.06,20.37 106.98,20.37 106.26,21.1 102.13,21.1 101.85,21.39
  BOTTOM w0.089: v2(96,20.96) 96,21.13 96.44,21.56 UH2.M6
  BOTTOM w0.152: LI1.4 343.34,43.3 343.3,43.27 343.18,43.27 343.05,43.13 343.01,43.13 342.99,43.12 v2(342.84,43.12)
USB20_N9_R: length 18.2
  BOTTOM w0.152: 347.35,44.73 347.56,44.95 347.56,48.63 348.35,49.42 348.61,49.42 v3(349.22,50.03) 350.1,50.9 350.1,52.83 349.47,53.46 349.19,53.46 348.79,53.86 348.79,54.91 349.19,55.31 349.57,55.31 349.8,55.54 JTS.4 ; 347.35,44.73 347.57,44.5 347.57,44.23 346.58,43.23 345.62,43.23 345.55,43.3 LI1.3 ; 347.35,44.73 DI3.2
USB20_N12: length 55
  IN1 w0.076: v2(100.56,24.23) 100.56,24.15 100.36,23.95 96.02,23.95 95.57,23.5 94.19,23.5 93.58,22.89 91.11,22.89 90.5,22.28 90.5,21.97 89.57,21.04 84.58,21.04 83.91,20.37 80.09,20.37 78.74,21.72 78.39,21.72 77.61,22.5 77.61,23.94 78.1,24.43 78.1,24.84 77.54,25.4 76.33,25.4 75.09,24.17 75.07,24.17 75.06,24.15
  IN1 w0.107: 75.06,24.15 73.92,23.02 71.59,23.02 70.19,21.61 67.93,21.61 66.17,23.38 65.16,23.38 64.44,24.09 58.29,24.09 58.2,24.19 58.2,24.28 v2(58.45,24.52)
  BOTTOM w0.089: UH2.G1 98.9,24.38 98.9,24.49 98.96,24.55 99.32,24.55 99.39,24.48 99.39,24.12 99.5,24.01 100.34,24.01 v2(100.56,24.23)
  BOTTOM w0.152: v2(58.45,24.52) 58.3,24.67 58.3,25.09 58.39,25.18 LV22.1
USB20_N12_R: length 18.2
  BOTTOM w0.152: JEDP1.31 52.73,35.82 52.64,35.73 52.64,35.19 54.48,33.35 56.54,33.35 58.59,31.3 58.83,31.3 60.11,30.02 v3(60.11,29.59) 60.11,29.29 59.77,28.94 59.42,28.94 DV12.3 58.09,28.12 57.92,28.29 57.92,28.81 57.79,28.93 57.61,28.93 57.43,28.74 57.43,28 57.71,27.73 57.99,27.73 58.32,27.39 58.32,27.05 58.39,26.98 LV22.2
USB20_P1: length 279.2
  IN1 w0.076: 101.98,23.91 101.97,23.9 101.95,23.9 101.16,23.12 100.25,23.12 100,22.87 v2(100,22.8)
  IN1 w0.107: 101.98,23.91 105.27,27.2 105.74,27.2 106.88,28.35 108.12,28.35 109.14,27.32 134.89,27.32 136.68,25.53 136.68,21.64 137.44,20.88 138.74,20.88 140.78,18.84 145.9,18.84 147,17.74 151.66,17.74 154.84,14.57 155.86,14.57 156.76,13.67 231.54,13.67 232.31,14.44 237.43,14.44 238.73,13.15 246.52,13.15 247.12,12.54 251.99,12.54 253.19,11.34 259.54,11.34 260.67,12.47 260.67,16.36 262.83,18.52 263.61,18.52 264.88,19.79 267.87,19.79 268.75,20.66 270.36,20.66 270.98,21.28 276.5,21.28 278.58,23.37 288.41,23.37 288.63,23.58 292.43,23.58 294.45,25.6 295.46,25.6 296.46,26.6 297.81,26.6 300.69,29.49 304.47,29.49 314.94,39.97 321.97,39.97 322.85,40.84 322.85,48.02 325.82,50.99 325.82,53.53 328.51,56.22 328.51,62.03 329.18,62.71 329.78,62.71 329.95,62.54 329.95,62.33 329.88,62.26 329.4,62.26 329.33,62.19 329.33,62.08 v2(329.57,61.85)
  BOTTOM w0.089: v2(100,22.8) 99.59,23.21 98.43,23.21 98.35,23.13 UH2.J2
  BOTTOM w0.152: UI2.3 329.57,62.32 329.65,62.23 329.65,61.94 v2(329.57,61.85)
USB20_P2: length 136.4
  IN2 w0.089: v2(92.28,21.92) 92.48,22.12 92.48,22.45 91.9,23.03 88.66,23.03 87.34,21.71 86.36,21.71 86.19,21.54 82.09,21.54 81.36,22.28 80.56,22.28 79.49,23.34 79.1,23.34 78.55,23.89 78.55,24.38 78.93,24.77 78.93,26.77 78.4,27.3 78.4,29.18 78.39,29.19 78.39,29.21
  IN2 w0.107: v2(26.03,96.4) 26.21,96.21 26.21,95.88 24.05,93.73 24.05,91.48 25.35,90.19 25.35,89.31 27.76,86.9 27.76,69.64 27.84,69.56 27.84,61.84 28.25,61.43 28.25,58.64 28.94,57.95 28.94,55.05 30.09,53.9 30.09,53.29 31.95,51.43 31.95,50.42 33.1,49.28 33.1,48.91 33.91,48.1 33.91,47.42 35.91,45.42 35.91,45.26 37.95,43.22 37.95,39.79 38.48,39.26 38.48,38.46 40.59,36.35 44.95,36.35 45.51,35.79 47.19,35.79 49.85,33.12 63.57,33.12 66.86,29.83 68.38,29.83 68.46,29.74 73.21,29.74 75.25,31.78 78.33,31.78 78.8,31.31 78.8,29.92 78.39,29.51 78.39,29.21
  BOTTOM w0.089: UH2.N15 92.43,21.6 92.43,21.78 92.29,21.92 v2(92.28,21.92)
  BOTTOM w0.152: UI1.3 26.04,97.41 26.12,97.32 26.12,96.55 26.13,96.55 26.13,96.5 v2(26.03,96.4)
USB20_P4: length 304.8
  IN1 w0.076: 99.4,19.66 99.38,19.66 99.37,19.65 97.62,19.65 97.24,20.02 96.35,20.02 95.54,20.83 95.54,21.12 95.23,21.43 v2(95.16,21.84)
  IN1 w0.107: v2(328.41,80.64) 328.41,80.47 328.29,80.35 327.91,80.35 327.65,80.09 327.65,79.61 329.4,77.86 329.4,75.25 327.23,73.08 327.23,65.93 329.63,63.53 329.86,63.53 330.72,62.67 330.72,61.33 329.45,60.07 329.45,56.37 326.53,53.45 326.53,49.83 324.89,48.19 324.89,41.08 322.86,39.05 322.1,39.05 320.2,37.15 313.34,37.15 304.93,28.74 304.93,26.62 304.55,26.24 298.58,26.24 297,24.65 295.16,24.65 293.31,22.8 291.26,22.8 290.93,22.47 282.22,22.47 281.87,22.81 278.73,22.81 276.73,20.81 271.14,20.81 270.5,20.17 268.98,20.17 268.16,19.34 265.24,19.34 263.53,17.63 263.53,15.07 262.06,13.6 261.63,13.6 261.14,13.11 261.14,12.19 259.79,10.85 253.1,10.85 251.82,12.13 246.9,12.13 246.41,12.62 221.32,12.62 218.17,9.48 214.46,9.48 212.43,11.51 205.31,11.51 204.5,10.7 178.13,10.7 177.25,11.57 164.32,11.57 163.67,10.92 160.2,10.92 159.54,11.58 156.24,11.58 155.47,12.35 154.74,12.35 151.36,15.72 139.45,15.72 138.46,16.71 131.75,16.71 130.61,17.86 130.61,18.96 129.85,19.71 107.34,19.71 105.85,21.2 103.21,21.2 101.67,19.66 99.4,19.66
  BOTTOM w0.089: UH2.L9 95.07,22.32 94.92,22.16 94.92,21.94 95.02,21.84 v2(95.16,21.84)
  BOTTOM w0.152: v2(328.41,80.64) 328.76,80.29 329.16,80.29 329.33,80.46 329.33,80.69 329.25,80.77 LN1.4
USB20_P4_R: length 2.2
  BOTTOM w0.152: JNGFF1.3 329.05,83.7 329.13,83.62 329.13,83.19 329.33,82.99 329.33,82.73 329.25,82.65 LN1.3
USB20_P5: length 120.2
  IN3 w0.089: 75.19,26.23 75.21,26.22 75.21,26.21 75.36,26.06 75.56,25.86 75.56,25.58 76.91,24.23 78.39,24.23 80.14,22.48 87.52,22.48 88.74,21.26 89.5,21.26 90.48,20.28 91.82,20.28 92.77,19.33 95.35,19.33 96.01,20 97.65,20 98.11,20.46 99.32,20.46 99.77,20.9 99.77,21.08 99.7,21.15 99.59,21.15 99.46,21.02 99.32,21.02 99.17,21.17 99.17,21.36 v2(99.32,21.5)
  IN3 w0.099: v2(21.33,65.62) 21.75,66.03 21.94,66.03 22.04,65.94 22.04,65.74 21.57,65.27 21.57,65.13 21.69,65.01 22.53,65.01 22.86,65.34 25.76,65.34 26.67,64.42 26.67,62.57 28.04,61.2 28.04,56.85 29.05,55.84 29.05,53.37 30.32,52.1 30.32,51.51 33.1,48.74 33.24,48.51 33.45,47.94 33.45,46.22 34.3,45.37 34.3,37.2 33.74,36.63 33.74,36.12 33.95,35.92 34.57,35.92 34.87,35.62 34.87,35.44 35.76,34.55 36.75,34.55 38.69,32.6 38.97,32.6 40.14,31.43 40.14,30.78 43.32,27.6 45.83,27.6 46.62,26.81 48.35,26.81 48.58,27.04 52.58,27.04 53.25,26.36 60.39,26.36 60.93,25.83 70.59,25.83 72.35,27.58 73.84,27.58 75.19,26.23
  BOTTOM w0.089: UH2.L2 98.57,21.88 98.95,21.5 v2(99.32,21.5)
  BOTTOM w0.152: RT1144.1 22.28,66.55 22.28,66.71 22.05,66.93 21.89,66.93 21.05,66.09 21.05,65.9 v2(21.33,65.62)
USB20_P5_R: length 6.2
  BOTTOM w0.081: UT4.L5 22.43,60.38 22.38,60.42 22.38,60.54 22.55,60.7 22.55,61.63 22.47,61.7 22.47,61.72
  BOTTOM w0.152: RT1144.2 21.92,65.61 RT1141.2 22.11,65.22 22.28,65.05 v3(22.28,63.58) 22.28,62.68 22.47,62.48 22.47,61.72
USB20_P7: length 244.5
  IN1 w0.076: 101.98,22.67 101.97,22.65 101.95,22.65 101.08,21.78 100.86,21.78 v2(100.67,21.59)
  IN1 w0.107: 101.98,22.67 102.87,23.56 102.87,23.92 105.4,26.44 105.85,26.44 106.97,27.56 107.73,27.56 109.11,26.18 129.25,26.18 129.97,25.45 129.97,23.61 134.66,18.92 139.55,18.92 141.73,16.75 151.79,16.75 154.77,13.77 155.8,13.77 156.81,12.76 177.56,12.76 178.58,11.74 198.17,11.74 199.33,12.89 213.74,12.89 215.15,11.48 216.37,11.48 216.98,12.1 v2(216.98,12.2)
  IN2 w0.107: v2(317.3,28.54) 317.09,28.54 316.98,28.64 316.98,29.35 316.61,29.72 315.47,29.72 314.27,28.52 304.59,28.52 302.62,26.56 302.25,26.56 301.46,25.77 299.93,25.77 299.52,25.36 299.52,24.22 298.91,23.61 294.41,23.61 293.41,22.61 291.84,22.61 291.14,21.91 288.23,21.91 285.78,19.46 284.89,19.46 282.55,17.12 282.4,17.12 281.69,16.4 275.58,16.4 275,15.83 266.62,15.83 264.86,14.07 257.46,14.07 256.52,13.13 254.45,13.13 252.09,10.77 217.62,10.77 216.66,11.73 216.66,12.09 216.77,12.2 v2(216.98,12.2)
  BOTTOM w0.089: UH2.L3 98.17,22.2 98.37,22.39 99.19,22.39 99.45,22.14 100.25,22.14 100.31,22.08 100.31,21.59 100.41,21.48 100.57,21.48 v2(100.67,21.59)
  BOTTOM w0.152: v2(317.3,28.54) 317.05,28.79 317.05,29.77 317.33,30.06 ML17.1
USB20_P9: length 274.3
  IN3 w0.089: 101.98,21.52 101.97,21.54 101.96,21.54 101.4,22.1 101.4,22.26 100.94,22.72 100.45,22.72 100.16,22.43 99.27,22.43 97.33,20.49 96.53,20.49 96.38,20.64 96.38,20.77 96.58,20.96 v2(96.58,20.97)
  IN3 w0.099: 101.98,21.52 102.21,21.29 106.34,21.29 107.06,20.56 108.14,20.56 109.07,19.63 109.68,19.63 112.64,16.68 120.15,16.68 121.45,15.38 122.02,15.38 122.63,14.77 124.8,14.77 125.27,15.24 126.32,15.24 126.85,14.71 137.58,14.71 137.77,14.52 138.85,14.52 139.72,13.65 151.54,13.65 151.64,13.55 179.78,13.55 180.22,14 199.79,14 200.58,13.21 203.92,13.21 204.3,12.83 256.54,12.83 257.43,13.72 260.71,13.72 261.29,14.3 264.95,14.3 265.89,15.24 267.74,15.24 270.12,17.61 280.63,17.61 285.96,22.95 288.1,22.95 289.76,24.61 291.05,24.61 293.7,27.26 295.83,27.26 297.18,28.61 297.92,28.61 298.15,28.39 298.83,28.39 299.39,28.94 301.65,28.94 304.5,31.8 307.04,31.8 309.2,33.96 313.38,33.96 315.22,32.13 323.72,32.13 324.42,31.43 327.34,31.43 329.4,33.5 333.96,33.5 334.59,34.13 336.55,34.13 338.27,35.84 341.1,35.84 343.56,38.3 343.56,42.43 343.25,42.73 343.03,42.73 v2(342.84,42.53)
  BOTTOM w0.089: UH2.N8 95.64,21.25 95.64,20.81 95.85,20.6 96.21,20.6 v2(96.58,20.97)
  BOTTOM w0.152: LI1.1 343.15,42.8 342.88,42.53 v2(342.84,42.53)
USB20_P9_R: length 18.2
  BOTTOM w0.152: 348.13,44.73 347.89,44.97 347.89,48.49 348.49,49.09 348.75,49.09 350.43,50.77 v3(350.43,51.32) 350.43,52.97 349.61,53.79 349.32,53.79 349.12,54 349.12,54.77 349.33,54.98 349.52,54.98 349.75,54.74 JTS.5 ; 348.13,44.73 347.9,44.5 347.9,44.09 346.71,42.9 345.55,42.9 345.46,42.8 LI1.2 ; 348.13,44.73 DI3.3
USB20_P12: length 55
  IN1 w0.076: 75.2,24.01 75.22,24.02 75.22,24.05 76.4,25.23 77.47,25.23 77.93,24.77 77.93,24.5 77.44,24.01 77.44,22.42 78.32,21.55 78.67,21.55 80.02,20.2 83.98,20.2 84.65,20.87 89.64,20.87 90.67,21.9 90.67,22.21 91.18,22.72 93.65,22.72 94.26,23.33 95.64,23.33 96.09,23.78 100.42,23.78 v2(100.56,23.64)
  IN1 w0.107: 75.2,24.01 74.01,22.82 71.68,22.82 70.27,21.41 67.85,21.41 66.08,23.17 65.08,23.17 64.36,23.89 58.21,23.89 58,24.1 58,24.39 v2(57.86,24.52)
  BOTTOM w0.089: UH2.G2 98.66,24.17 98.89,23.94 99.2,23.94 99.39,23.75 100.45,23.75 v2(100.56,23.64)
  BOTTOM w0.152: v2(57.86,24.52) 57.97,24.63 57.97,25.11 57.89,25.19 LV22.4
USB20_P12_R: length 18.2
  BOTTOM w0.152: JEDP1.32 52.23,35.8 52.31,35.72 52.31,35.05 54.35,33.02 56.4,33.02 57.18,32.24 v3(57.96,31.46) 58.45,30.97 58.69,30.97 59.78,29.88 59.78,29.42 59.63,29.27 59.35,29.27 DV12.1 58.34,30.02 58.29,30.07 57.76,30.07 57.48,29.8 57.48,29.26 57.1,28.88 57.1,27.86 57.57,27.4 57.85,27.4 57.99,27.26 57.99,27.05 57.89,26.95 LV22.3
USB8723_TEST: length 1.7
  TOP w0.14: RI24.1 325.91,34.29 325.41,34.79 UI3.14
USB_DET#_L: length 402.4
  TOP w0.14: v1(284.48,15.88) 284.74,15.62 v2(284.94,15.62) CE71.1 284.95,14.81 RE89.2
  IN2 w0.089: 73.28,10.09 73.61,10.09 74.15,9.55 76.22,9.55 76.92,8.85 77.85,8.85 78.03,9.02 78.03,9.02 78.33,9.32 78.33,9.85 78.57,10.1 79.27,10.1 79.41,9.96 79.82,9.96 80.41,10.54 84.77,10.54 85.64,11.42 86.18,11.42 86.79,10.8 87.44,10.8 88.04,11.41 89.07,11.41 89.96,12.29 91.37,12.29 91.77,11.89 91.77,10.87 92.89,9.75 92.89,9.37 93.15,9.11 94.58,9.11 94.8,9.33 94.8,9.61 95.48,10.29 96.83,10.29 97.17,9.95 97.74,9.95 98.1,10.31 98.1,11.04 98.57,11.51 99.18,11.51 99.26,11.42 100.49,11.42 100.64,11.57 101.35,11.57 101.98,12.21
  IN2 w0.099: 73.28,10.09 73.14,10.09 72.89,10.34 72.89,10.7 73.13,10.94 73.13,12.36 70.88,14.62 70.88,17.47 70.43,17.92 70.43,18.75 68.79,20.38 66.83,20.38 65.92,21.29 65.56,21.29 64.85,21.99 64.85,23.2 64.23,23.82 63.72,23.82 62.1,25.45 60.94,25.45 60.8,25.59 56.46,25.59 56.17,25.3 49.14,25.3 48.89,25.05 45.41,25.05 44.53,25.93 38.94,25.93 38.05,26.82 37.87,26.82 v2(37.59,26.54) ; 101.98,12.21 103.21,13.44 103.84,13.44 104.38,13.98 108.84,13.98 109.03,14.16 109.57,14.16 112.01,16.6 113.43,16.6 113.88,17.04 115.41,17.04 115.62,17.25 121.32,17.25 122,16.57 122.54,16.57 123.58,15.53 128.79,15.53 129.33,14.99 140.67,14.99 143.11,12.55 143.56,12.55 143.84,12.83 145.47,12.83 v2(145.92,12.39)
  IN5 w0.099: v2(284.94,15.62) 284.33,16.23 279.09,16.23 276.88,14.02 273.42,14.02 271.84,12.44 266.49,12.44 266.3,12.63 262.99,12.63 262.47,12.11 249.37,12.11 246.49,14.99 231.65,14.99 231,14.34 226.51,14.34 226.11,14.74 215.35,14.74 214.36,15.72 202.08,15.72 202,15.8 180.82,15.8 177.77,12.75 163.97,12.75 163.55,13.16 146.69,13.16 v2(145.92,12.39)
  IN6 w0.089: 23.84,33.53 23.84,33.61 23.51,33.93 ; 22.03,43.49 21.69,43.83 20.58,43.83
  IN6 w0.099: 23.51,33.93 23.29,34.16 23.29,34.96 22.61,35.64 22.61,37.11 22.03,37.7 22.03,43.49 ; v2(37.59,26.54) 37.59,27.28 37.08,27.8 33.29,27.8 32.62,27.13 32.62,25.77 32.09,25.24 27.13,25.24 25.25,27.12 25.25,29.55 24.56,30.24 24.01,30.24 23.82,30.44 23.82,30.88 23.56,31.13 23.56,31.61 24.21,32.25 24.21,33.16 23.84,33.53 ; JUSB1.10 23,108.57 24.82,106.76 24.82,104.85 26.92,102.75 26.92,100.51 27.85,99.58 27.85,96.1 26.99,95.23 25.39,95.23 22.45,92.29 22.45,82.87 16.41,76.83 16.41,73.02 16.22,72.83 13.28,72.83 12.93,72.48 12.93,71.65 14.45,70.13 14.71,70.13 17.56,67.29 17.56,58.91 18.14,58.33 18.14,53.41 19.58,51.96 19.58,44.65 20.4,43.83 20.58,43.83
USB_DET#_R: length 118
  TOP w0.14: v2(291.93,3.28) 291.59,3.28 290.92,3.95 CE37.1 291.67,4.09 RE54.2 ; v1(324.99,47.5) 326.59,47.5 QI10.2 328.63,47.63 332.49,47.63 335.76,50.9 v2(335.76,54.51)
  IN1 w0.099: v2(335.76,54.51) 332.87,51.61 332.87,45.59 330.96,43.69 330.96,39.5 329.95,38.48 329.95,36.2 326.52,32.77 326.52,32.39 326.01,31.88 321.18,31.88 320.68,31.37 320.68,23.62 318.64,21.59 316.71,21.59 312.36,17.24 312.36,12.92 311.79,12.35 311.79,7.35 310.7,6.27 310.7,5.63 309.24,4.17 308.61,4.17 308.31,4.47 306.86,4.47 306.78,4.39 302.05,4.39 301.29,3.63 297.13,3.63 297.02,3.52 292.67,3.52 292.43,3.28 v2(291.93,3.28)
  IN3 w0.091: JUSB2.10 336.93,68.58 335.22,66.87 335.22,62.98 336.49,61.71 336.49,55.24 v2(335.76,54.51)
USB_DET_EC#_L: length 13.4
  TOP w0.14: RE90.2 285.01,13.89 RE89.1 285.84,13.92 CE70.1 286.97,13.93 v2(288.31,13.93) ; UE3.E4 297.32,12.97 v2(296.91,12.56)
  IN1 w0.076: v2(296.91,12.56) 296.51,12.96 295.21,12.96 294.81,13.36 292.93,13.36
  IN1 w0.099: v2(288.31,13.93) 288.87,13.93 289.74,13.06 290.17,13.06 290.48,13.36 292.93,13.36
USB_DET_EC#_R: length 12.7
  TOP w0.14: v2(296.16,12.57) UE3.D4 ; v1(291.21,6.06) 291.21,5.47 290.98,5.24 RE50.2 291.7,4.94 RE54.1 CE38.1 292.76,4.95 293.44,5.64 v2(293.44,5.74)
  BOTTOM w0.14: v2(293.44,5.74) 293.44,5.76 295.8,8.12 295.8,9.53 295.72,9.6 295.72,12.13 v2(296.16,12.57)
USB_ILIM_SEL: length 47.7
  TOP w0.076: v2(302.57,17.42) 302.92,17.77 UE3.M10
  TOP w0.14: v2(326.45,40.75) v1(325.83,40.75)
  IN1 w0.076: 304.17,18.5 303.08,17.42 v2(302.57,17.42)
  IN1 w0.099: 304.17,18.5 304.48,18.82 305.59,18.82 306.2,19.43 306.2,20.91 307.95,22.66 309.86,22.66 311.66,24.46 311.66,24.64 313.48,26.46 317.92,26.46 318.9,27.43 318.9,31.88 320.17,33.15 324.99,33.15 v2(325.5,32.64)
  IN3 w0.091: v2(325.5,32.64) 326.45,33.59 v2(326.45,40.75)
  BOTTOM w0.14: RI35.1 327.8,42.72 DI12.1 327.83,40.75 v2(326.45,40.75)
USB_L_CTL: length 5.6
  BOTTOM w0.14: UI1.7 24.26,99.57 24.16,99.66 24.16,99.93 24.29,100.07 ; v1(21.79,98.29) 21.79,98.75 22.48,99.43 22.48,100.03 22.73,100.28 RI4.2 23.33,100.07 24.29,100.07 ; 24.29,100.07 UI1.8
USB_OC0#: length 335.9
  TOP w0.089: RH552.1 81.79,14.32 v1(81.79,13.59) v2(81.42,13.22)
  IN2 w0.089: v2(81.42,13.22) 81.82,13.62 82.63,13.62 83.72,12.52 86.82,12.52 87.3,12.04 88.59,12.04 89.39,12.85 91.6,12.85 91.88,12.56 92.18,12.56 93.06,11.68 95.03,11.68 96.06,10.64 97.05,10.64 98.82,12.41 100.9,12.41 101.46,12.97 101.98,12.97
  IN2 w0.099: 101.98,12.97 102.08,12.97 103.29,14.18 104.01,14.18 104.22,14.38 108.68,14.38 108.86,14.56 109.4,14.56 111.88,17.04 113.31,17.04 113.71,17.45 115.11,17.45 115.32,17.65 121.68,17.65 122.09,17.25 128.72,17.25 130.57,15.39 140.83,15.39 142.89,13.34 150.63,13.34 151.93,12.03 154.31,12.03 155.33,11.01 159.21,11.01 159.66,10.57 168.46,10.57 168.86,10.16 177.67,10.16 178.72,11.2 187.76,11.2 188.7,10.26 210.59,10.26 215.01,5.84 242.19,5.84 244.65,8.31 256.35,8.31 257.43,9.39 261.26,9.39 262.22,10.35 264.61,10.35 266.57,12.32 267.21,12.32 268.96,10.57 271.37,10.57 272.92,9.02 283.47,9.02 283.61,9.17 286.9,9.17 287.71,8.35 291.18,8.35 292.1,9.27 292.48,9.27 292.7,9.06 297.06,9.06 297.95,8.18 301.95,8.18 302.44,8.66 302.44,10.18 302.79,10.54 303.47,10.54 303.68,10.33 305.79,10.33 307.84,12.37 309.5,12.37 310.2,13.07 310.2,15.05 313.44,18.29 314.96,18.29 315.87,19.2 318.33,19.2 327.18,28.05 327.18,29.31 330.31,32.44 339.44,32.44 340.32,33.32 342.45,33.32 344.37,35.24 344.37,41.92 345.2,42.75 345.2,47.66 340.97,51.89 340.97,62.13 339.65,63.45 v2(338.89,63.45)
  BOTTOM w0.089: UH2.AH36 81.69,13.49 v2(81.42,13.22)
  BOTTOM w0.14: v2(338.89,63.45) 333.4,63.45 333,63.85 333,64.84 332.56,65.28 332.2,65.28 331.94,65.01 UI2.13
USB_OC1#: length 172.8
  TOP w0.089: RH553.1 77.31,13.57 78.55,13.57 78.75,13.37 80.01,13.37 v2(80.16,13.21)
  TOP w0.14: v2(25.15,103.25) v1(25.15,103.85)
  IN6 w0.089: 74.37,18.87 75.16,18.09 75.21,18.09 76.47,16.82 76.47,14.31 77.4,13.38 80,13.38 v2(80.16,13.21)
  IN6 w0.099: v2(25.15,103.25) 25.15,102.25 23.24,100.35 23.24,94.95 21.22,92.93 21.22,86.81 13.5,79.08 13.5,77.02 12.4,75.93 11.53,75.93 11,75.4 11,74.95 11.43,74.52 11.43,70.39 12.98,68.83 14.1,68.83 15.14,67.79 15.14,63.7 15.91,62.94 15.91,54.39 16.93,53.36 16.93,52.91 18.37,51.47 18.37,42.83 16.27,40.73 16.27,37.5 17.17,36.6 17.17,35.67 17.41,35.43 17.41,34.71 17.63,34.49 17.63,31.98 17.36,31.71 17.35,31.71 17.35,30.39 18.36,29.38 18.36,28.88 19.41,27.82 21.2,27.82 21.46,27.57 21.46,25.94 22.16,25.24 25.65,25.24 27.84,23.04 28.85,23.04 31.02,20.87 32.45,20.87 33.09,21.51 39.74,21.51 42.72,24.49 44,24.49 44.79,25.28 49.19,25.28 49.38,25.09 51.26,25.09 52.3,24.04 56.92,24.04 57.15,23.81 60.92,23.81 61.66,23.07 61.66,22.57 61.92,22.3 67.28,22.3 67.7,22.73 68.93,22.73 68.93,22.72 69.53,22.72 70.39,21.87 71.25,21.87 71.9,21.21 71.9,20.84 72.44,20.31 73.23,20.31 73.89,19.65 73.89,19.36 74.37,18.87
  BOTTOM w0.089: UH2.AL40 80.07,13.12 v2(80.16,13.21)
  BOTTOM w0.14: v2(25.15,103.25) 26.29,103.25 27.05,102.49 27.43,102.49 27.67,102.25 28.18,102.25 28.68,101.75 28.68,100.62 28.12,100.07 UI1.13
USB_OC2#: length 3.8
  TOP w0.089: v2(78.21,13.97) 77.83,14.35 77.09,14.35 76.71,14.73 RH554.1 76.58,15.14 v1(76.1,15.62)
  BOTTOM w0.089: v2(78.21,13.97) 78.21,13.91 77.92,13.62 77.92,13.38 UH2.AJ44
USB_OC3#: length 3.4
  TOP w0.089: RH555.1 77.05,13.12 v1(77.9,13.12) 78.04,13.12 78.11,13.19 79.38,13.19 v2(79.63,12.94)
  BOTTOM w0.089: UH2.AL41 79.34,12.66 79.63,12.96 v2(79.63,12.94)
USB_OC4#: length 11.2
  TOP w0.089: v2(72.72,15.38) 72.33,14.99 72.31,14.99
  TOP w0.14: RP8.3 71.68,15.24 71.93,14.99 72.31,14.99
  IN6 w0.099: v2(74.74,9.95) 74.95,9.95 75.37,10.37 75.37,11.04 74.56,11.84 74.56,13.1 74.74,13.28 74.74,13.8 73.16,15.38 v2(72.72,15.38)
  BOTTOM w0.089: UH2.AV47 76.58,9.2 76.25,9.2 75.75,9.2 75.55,9.39 75.17,9.39
  BOTTOM w0.14: 75.17,9.39 74.74,9.82 v2(74.74,9.95)
USB_OC5#: length 17.2
  TOP w0.089: 72.31,15.5 72.84,16.03 v1(72.84,16.19)
  TOP w0.14: 72.31,15.5 72.23,15.42 v2(72.15,15.42) 71.83,15.74 RP8.4
  IN6 w0.089: v2(82.37,10.97) 81.67,10.26 80.19,10.26 79.84,9.92 79.35,9.92 79.17,10.1 77.8,10.1 77.71,10.01 76.74,10.01 76.22,10.53 76.22,10.89 75.62,11.5 75.62,13.32 74.24,14.71 74.09,14.71 73.78,15.02 73.78,15.25 73.27,15.76 72.48,15.76 72.31,15.59
  IN6 w0.099: 72.31,15.59 72.13,15.42 72.13,15.42 v2(72.15,15.42)
  BOTTOM w0.089: v2(82.37,10.97) 82.33,10.93 UH2.AR35
USB_OC6#: length 14.8
  TOP w0.14: v2(73.6,14.42) 73.28,14.74 v1(72.94,14.74) RP8.2
  IN2 w0.089: 75.11,13.97 76.04,13.04 76.04,12.58 76.52,12.1 78.71,12.1 79.55,11.26 79.74,11.26 80.12,11.64 80.12,12.3 80.32,12.5 81.01,12.5 v2(81.41,12.11)
  IN2 w0.099: v2(73.6,14.42) 74.66,14.42 75.11,13.97
  BOTTOM w0.089: v2(81.41,12.11) 81.46,12.11 81.89,11.69 81.89,10.78 UH2.AR37
USB_OC7#: length 10.4
  TOP w0.089: v2(74.32,13.51) v1(73.95,13.88) 73.88,13.95 73.28,13.95 72.99,14.24 72.92,14.24
  TOP w0.14: 72.92,14.24 RP8.1
  IN2 w0.089: 74.28,12.89 74.28,11.77 76.4,9.65 v2(77.95,9.65)
  IN2 w0.099: v2(74.32,13.51) 74.28,13.47 74.28,12.89
  BOTTOM w0.089: UH2.AV43 78.47,9.14 v2(77.95,9.65)
USB_POWERSHARE_EN_L#: length 398.5
  TOP w0.14: v2(300.96,11.77) UE3.J3 ; v2(149.1,11.74) v1(149.1,12.36)
  IN1 w0.076: 72.31,15.84 75.86,15.84 76.46,15.25 76.46,14.86 76.96,14.35 79.36,14.35 79.54,14.18 83.24,14.18 84.21,13.2 85.05,13.2 85.46,13.62 85.46,14.04 85.92,14.5 86.19,14.5 86.99,15.3 86.99,15.51 87.41,15.93 90.2,15.93 90.82,16.54 93.65,16.54 95.01,15.18 98.09,15.18 98.72,14.54 101.77,14.54 101.77,14.55 101.98,14.55
  IN1 w0.099: 72.31,15.84 71.72,15.84 68.51,12.63 67.67,12.63 67.27,13.04 67.27,13.71 64.11,16.87 64.11,17.24 63.76,17.59 62.31,17.59 60.06,19.84 57.95,19.84 54.71,23.08 52.12,23.08 50.81,21.77 49.33,21.77 48.92,21.36 40.65,21.36 39.33,20.04 37.47,20.04 36.16,21.36 34.1,21.36 33.58,20.84 31,20.84 28.07,23.77 25.49,23.77 24.15,25.11 24.15,28.01 23.11,29.05 v2(23.04,29.05) ; 101.98,14.55 109.83,14.55 112.22,16.93 124.96,16.93 125.38,16.51 128.74,16.51 130.78,14.48 136.94,14.48 139.65,11.77 149.07,11.77 v2(149.1,11.74)
  IN5 w0.099: v2(300.96,11.77) 299.44,11.77 298.76,11.09 296.06,11.09 293.45,11.09 292.09,12.45 292.09,13.06 290.6,14.54 287.78,14.54 287.32,14.09 282.25,14.09 281.71,13.55 278.85,13.55 278.51,13.21 278.51,12.27 277.75,11.51 277.75,9.91 277.24,9.4 274.07,9.4 272.72,10.75 268.66,10.75 268.6,10.81 266.05,10.81 265.24,11.63 263.41,11.63 262.88,11.1 248.95,11.1 247,13.06 225.87,13.06 225.28,13.64 215.02,13.64 214.01,14.66 186.98,14.66 183.73,11.41 165.2,11.41 164.96,11.16 157.93,11.16 156.95,12.14 149.51,12.14 v2(149.1,11.74)
  IN6 w0.089: 20.58,42.67 20.64,42.6 20.64,40.73 21.26,40.12 21.26,37.54 21.95,36.85 21.95,35.35 22.61,34.69 22.61,33.53
  IN6 w0.099: v2(23.04,29.05) 23.04,29.62 22.61,30.05 22.61,33.53 ; v2(23.88,99.11) 23.88,100.45 24.83,101.39 25.19,101.39 25.5,101.08 25.5,100.61 25.27,100.37 25.27,97.19 24.67,96.59 24.67,95.36 21.85,92.54 21.85,85.29 14.1,77.54 14.1,76.77 12.2,74.87 12.2,70.47 13.13,69.53 14.42,69.53 16.95,67 16.95,63.39 16.51,62.95 16.51,54.64 17.53,53.61 17.53,53.16 18.97,51.72 18.97,44.27 20.58,42.67
  BOTTOM w0.14: RI5.2 23.85,99.11 v2(23.88,99.11) 23.93,99.07 UI1.6
USB_POWERSHARE_EN_R#: length 80.5
  TOP w0.076: UE3.K3 v2(301.76,11.77)
  IN6 w0.099: v2(333.31,57.53) 333.03,57.53 331.32,55.83 331.32,48.03 332.06,47.29 332.06,44.69 329.38,42.01 329.38,37.28 327.03,34.93 321.44,34.93 319.91,33.4 319.91,31.88 319.28,31.24 319.28,25.91 314.78,21.41 314.78,19.7 309.72,14.65 309.72,12.2 308.03,10.51 307.75,10.51 306.28,11.97 303.71,11.97 303.58,11.84 301.83,11.84 v2(301.76,11.77)
  BOTTOM w0.14: v2(333.31,57.53) 329.88,57.53 329.57,57.85 329.57,60.1 RI10.2 v1(328.05,61.61) 327.53,62.13 327.53,63.76 327.79,64.01 UI2.6
USB_POWERSHARE_VBUS_EN_L: length 405.7
  TOP w0.14: v2(300.94,10.94) 300.56,11.32 UE3.J2 ; v2(150.27,11.66) 150.27,11.04 v1(150.04,10.81)
  IN1 w0.076: v2(78.54,25.37) 78.54,25.88 78,26.42 76.03,26.42 75.51,25.89 75.51,25.43 75.06,24.98
  IN1 w0.099: 75.06,24.98 74.45,24.37 73.17,24.37 72.56,24.98 72.05,24.98 71.57,24.49 71.57,23.95 70.96,23.34 70.37,23.34 69.94,22.92 67.34,22.92 66.4,23.86 65.33,23.86 64.67,24.52 60.81,24.52 56.72,28.61 46.46,28.61 44.78,26.93 44.78,25.86 43.82,24.89 43.09,24.89 42.85,25.13 v2(42.85,25.32)
  IN5 w0.099: v2(300.94,10.94) 300.13,10.94 299.74,10.55 298.94,10.55 298.63,10.87 293.38,10.87 291.15,13.1 290.19,13.1 290.18,13.09 289.78,13.09 288.53,14.34 287.86,14.34 287.41,13.89 282.34,13.89 281.8,13.35 279.03,13.35 278.8,13.11 278.8,12.24 278,11.45 278,9.78 277.31,9.08 273.88,9.08 272.41,10.55 268.58,10.55 268.51,10.61 265.97,10.61 265.15,11.43 263.49,11.43 262.97,10.9 248.81,10.9 246.89,12.83 225.74,12.83 225.15,13.42 214.96,13.42 213.92,14.46 187.07,14.46 183.13,10.52 177.8,10.52 177.45,10.16 169.62,10.16 169.17,9.7 163.91,9.7 162.9,10.72 152.66,10.72 152.06,11.32 150.61,11.32 v2(150.27,11.66)
  IN6 w0.089: v2(78.54,25.37) 79.24,25.37 80.12,24.49 80.29,24.49 81.17,23.6 81.17,22.58 82.62,21.13 90,21.13 93.63,17.5 94.46,17.5 94.85,17.11 94.85,14.74 95.68,13.92 98.79,13.92 99.27,13.43 101.98,13.43 ; 21.67,38.5 21.67,43.11 21.37,43.41 20.58,43.41
  IN6 w0.099: v2(42.85,25.32) 42.7,25.32 39.5,22.12 33.91,22.12 32.39,23.64 28.44,23.64 25.05,27.04 25.05,28.22 22.81,30.46 22.81,33 22.83,33.02 22.83,34.82 22.22,35.42 22.22,36.83 21.67,37.38 21.67,38.5 ; v2(24.26,103.84) 25.26,103.84 26.52,102.58 26.52,100.35 27.45,99.42 27.45,96.27 26.82,95.63 25.22,95.63 22.05,92.46 22.05,83.14 15.89,76.98 15.89,73.37 15.76,73.24 13.07,73.24 12.4,72.57 12.4,71.61 14.28,69.73 14.51,69.73 17.15,67.09 17.15,63.31 16.71,62.86 16.71,54.77 17.73,53.74 17.73,53.24 19.17,51.8 19.17,44.48 20.24,43.41 20.58,43.41 ; 101.98,13.43 102.11,13.43 102.44,13.1 103.89,13.1 104.6,12.39 110.1,12.39 110.49,12.78 113.63,12.78 114.1,13.25 119.51,13.25 120.16,13.91 121.9,13.91 123.1,15.11 124.79,15.11 125.12,15.44 130.14,15.44 130.58,15.01 141.46,15.01 143.61,12.85 149.07,12.85 v2(150.27,11.66)
  BOTTOM w0.14: UI4.2 22.86,103.76 22.94,103.84 RI8.2 v2(24.26,103.84)
USB_POWERSHARE_VBUS_EN_R: length 76.2
  TOP w0.076: UE3.G5 v2(299.36,13.37)
  TOP w0.14: v2(331.74,48.19) 331.16,48.19 330.51,48.85 330.15,48.85 329.63,48.32 327.66,48.32 326.68,49.31 326.68,49.56 ; RI28.1 326.68,51.02 RI13.2 326.68,49.56 ; 326.68,49.56 325.76,48.64 324.99,48.64 324.71,48.92 v1(324.71,49.02) UI5.2
  IN6 w0.076: v2(299.36,13.37) 299.58,13.37 299.98,13.77 300.35,13.77 300.55,13.56 300.55,12.14 300.55,12.13
  IN6 w0.099: 300.55,12.13 300.55,11.57 300.76,11.36 303.52,11.36 303.94,11.77 306.2,11.77 307.73,10.25 308.09,10.25 308.69,10.84 309.99,10.84 310.83,11.69 311.49,11.69 311.93,12.12 311.93,13.63 313.35,15.05 313.35,16.05 314.43,17.13 314.43,19.05 318.9,23.52 318.9,24.77 319.53,25.4 319.53,30.86 322.45,33.78 326.26,33.78 329.58,37.1 329.58,41.93 332.27,44.62 332.27,47.66 v2(331.74,48.19)
USB_PWR_EN: length 494.8
  TOP w0.089: v6(87.57,2.54) 88.37,2.54 88.46,2.45 90.26,2.45 91.04,3.23 91.04,3.63 91.41,4 91.41,6.39 90.95,6.86 90.95,7.08 v6(90.99,7.12)
  TOP w0.14: v2(324.2,47.09) 324.2,50.14 324.06,50.27 UI5.1 ; v2(66.85,5.47) 66.85,5.2 67.4,4.65 RH544.1
  IN1 w0.076: 75.06,3.44 77.34,3.44 77.5,3.28 78.92,3.28 79.23,2.97 79.91,2.97 v2(80.39,3.46)
  IN1 w0.099: v2(66.85,5.47) 66.85,5.25 67.72,4.37 74.12,4.37 75.06,3.44
  IN2 w0.099: v2(24.43,29.78) 24.95,29.78 25.81,30.63 32.23,30.63 34.03,28.84 34.03,27.73 33.26,26.96 33.26,22.49 33.83,21.92 38.31,21.92 39.64,23.25 45.1,23.25 45.32,23.47 52,23.47 52.56,22.9 56.19,22.9 58.23,20.87 58.23,20.15 58.81,19.57 58.81,17.46 61.09,15.19 61.09,14.31 60.57,13.8 60.57,12.22 60.6,12.19 60.6,6.8 61.02,6.38 61.02,4.83 60.64,4.45 60.64,3.93 60.86,3.71 61.45,3.71 61.63,3.53 62.03,3.53 62.2,3.7 63.44,3.7 64.27,2.87 64.97,2.87 66.85,4.75 v2(66.85,5.47)
  IN5 w0.099: v2(278.13,26.66) 278.63,27.16 283.35,27.16 283.71,26.8 286.14,26.8 288.29,28.95 292.3,28.95 292.68,29.33 294.83,29.33 296.51,31.02 303.53,31.02 305.45,32.94 308.95,32.94 309.38,33.37 323.44,33.37 325.5,35.43 325.5,38.61 328.17,41.28 328.17,44.71 325.78,47.09 v2(324.2,47.09)
  IN6 w0.089: v2(80.39,3.46) 80.63,3.21 81.32,3.21 82.26,2.28 85.84,2.28 86.26,2.69 87.42,2.69 v6(87.57,2.54) 88.19,2.54 88.68,2.06 93.09,2.06 93.25,1.91 ; 95.12,1.91 95.12,2.05 96.12,3.05 97.04,3.05 98.19,1.91 ; 23.28,33.53 23.28,33.62 23.02,33.88 23.02,34.91 22.43,35.49 22.43,37.04 21.85,37.62 21.85,43.33 21.57,43.61 20.58,43.61
  IN6 w0.099: 20.58,43.61 20.33,43.61 19.37,44.57 19.37,51.88 17.93,53.32 17.93,53.83 16.91,54.85 16.91,62.78 17.36,63.23 17.36,67.17 14.59,69.93 14.37,69.93 12.64,71.66 12.64,72.47 13.21,73.04 15.85,73.04 15.85,73.05 16.02,73.05 16.15,73.17 16.15,76.95 22.25,83.05 22.25,92.38 25.31,95.43 26.9,95.43 27.65,96.18 27.65,99.5 26.72,100.43 26.72,102.66 24.96,104.42 v2(24.26,104.42) ; 98.19,1.91 98.8,1.3 149.36,1.3 151.45,3.39 164.89,3.39 165.26,3.76 165.26,4.39 166.39,5.52 174.34,5.52 174.43,5.43 176.79,5.43 179.42,8.06 182.74,8.06 183.31,7.49 202.31,7.49 203.31,8.49 210.46,8.49 214.76,4.19 243.24,4.19 245.49,6.44 253.18,6.44 253.94,5.69 262.13,5.69 263.35,6.91 268.36,6.91 268.95,6.33 270.54,6.33 271.15,5.72 274.45,5.72 275.08,5.08 276.71,5.08 v2(277.63,6) ; v2(24.43,29.78) 24.17,29.52 24.03,29.52 23.58,29.97 23.58,30.15 23.28,30.45 23.28,33.53 ; 93.25,1.91 93.66,1.49 94.71,1.49 95.12,1.91
  BOTTOM w0.089: UH2.BD17 91.31,6.13 91.31,6.68 90.99,7 v6(90.99,7.12)
  BOTTOM w0.14: UI4.1 24.25,104.41 v2(24.26,104.42) v1(24.26,105.03) ; v2(278.13,26.66) 276.1,24.63 274.89,24.63 274.27,24.01 274.27,22.79 278.26,18.8 278.26,12.32 277.62,11.69 277.62,6.01 v2(277.63,6)
USB_PWR_EN_L: length 11.9
  TOP w0.14: v1(25.02,99.09) 24.26,98.33 v2(23.9,98.33)
  IN1 w0.099: v2(23.9,98.33) 23.9,98.4 22.97,99.33 21.11,99.33 19.79,100.65 v2(19.66,100.65)
  BOTTOM w0.14: v2(19.66,100.65) 19.66,100.95 20.88,102.18 20.88,102.76 UI4.4 20.32,103.33 RI26.1 ; v2(23.9,98.33) 24.13,98.57 UI1.5
USB_PWR_EN_R: length 17.9
  TOP w0.14: RI28.2 326.47,52.01 325.69,52.01 325.36,52.34 UI5.4 325.36,53.76 RI27.1 325.88,53.98 326.09,54.19 326.09,56.17 v1(328.32,58.41) 329.77,58.41 v2(330.2,57.98)
  BOTTOM w0.14: UI2.5 327.96,63.51 327.83,63.39 327.83,62.44 329.15,61.12 329.35,61.12 329.88,60.59 329.88,58.29 v2(330.2,57.98)
USB_R_CTL: length 6.3
  BOTTOM w0.14: 327.53,64.51 327.53,64.83 327.71,65.01 UI2.8 ; 327.53,64.51 327.15,64.13 v1(327.15,62.97) 327.15,61.67 RI9.2 ; 327.53,64.51 UI2.7
USB_STATUS#_L: length 448.1
  TOP w0.14: v2(323.47,46.1) v1(324,46.1)
  IN5 w0.089: 75.06,21.04 75.96,21.04 77.09,22.17
  IN5 w0.099: v2(323.47,46.1) 326.14,46.1 327.79,44.45 327.79,41.4 325.12,38.74 325.12,38.1 324.23,37.21 321.44,37.21 320.68,36.45 320.68,35.43 319.03,33.78 309.51,33.78 308.87,33.14 305.36,33.14 303.44,31.22 296.43,31.22 294.74,29.53 292.6,29.53 292.24,29.18 287.11,29.18 285.82,27.89 278.69,27.89 276.23,25.43 270.06,25.43 269.07,24.43 268.49,24.43 265.44,27.48 261.44,27.48 253.34,35.57 181.75,35.57 177.96,31.77 177.52,31.77 174.85,29.11 174.85,25.53 176.13,24.26 176.13,23.52 174.66,22.06 174.66,21.08 173.69,20.11 130.97,20.11 130.45,20.63 107.49,20.63 104.72,23.4 104.72,25.39 103.02,27.08 98.5,27.08 98.34,27.23 97.03,27.23 96.7,26.9 96.7,26.64 96.32,26.26 90.19,26.26 88.53,24.6 88.53,23.83 87.13,22.43 80.57,22.43 80.19,22.82 79.06,22.82 78.41,22.17 77.09,22.17 ; v2(62.74,22.78) 62.75,22.78 63.68,23.7 67.14,23.7 67.73,23.11 71.78,23.11 73.3,21.58 73.96,21.58 74.51,21.04 75.06,21.04
  IN6 w0.089: 20.58,34.01 20.64,33.94 21.09,33.94 21.69,34.54 21.69,35.31 ; 21.01,38 21.01,40.03 20.7,40.34
  IN6 w0.099: 24.34,95.38 21.65,92.69 21.65,85.38 13.9,77.63 13.9,76.85 12,74.95 12,70.38 13.05,69.33 14.18,69.33 16.75,66.76 16.75,63.48 16.31,63.03 16.31,54.56 17.33,53.53 17.33,53.07 18.77,51.63 18.77,44.02 20.42,42.36 20.42,40.61 20.7,40.34 ; 21.01,38 21.01,37.47 21.69,36.79 21.69,35.31 ; 20.58,34.01 20.5,34.08 19.9,34.08 19.1,33.29 19.1,32.82 17.96,31.68 17.96,30.44 18.8,29.59 18.8,29.11 19.36,28.55 23.8,28.55 24.56,27.79 24.56,26.89 28.01,23.44 32.31,23.44 33.84,21.91 39.57,21.91 42.55,24.89 43.8,24.89 44.59,25.68 49.35,25.68 49.52,25.51 56.37,25.51 56.85,25.04 59.81,25.04 60.49,24.36 61.31,24.36 62.74,22.93 62.74,22.78 v2(62.74,22.78)
  IN6 w0.107: v2(25.06,100.87) 25.06,97.31 24.46,96.71 24.46,95.51 24.34,95.38
  BOTTOM w0.14: v2(323.47,46.1) 326.54,46.1 327,46.56 RI32.2 ; UI1.9 v2(25.06,100.87)
USB_STATUS#_R: length 27.8
  TOP w0.14: v2(326.71,63.48) v1(326.24,63.01)
  IN6 w0.099: v2(326.71,63.48) 327.78,62.41 327.78,53.89 v2(323.51,49.62)
  BOTTOM w0.14: RI33.2 329.06,46.97 327.29,48.74 324.4,48.74 v2(323.51,49.62) ; v2(326.71,63.48) 326.71,64.39 327.67,65.36 328.92,65.36 329.07,65.51 UI2.9
USBC_MCP23008_SMBCLK: length 262.4
  TOP w0.14: v2(89.1,32.22) 88.9,32.42 88.9,32.87 85.26,36.51 83.38,36.51 82.86,36 82.43,36 RE109.2 ; UE3.A12 294.16,19.56 292.89,20.83 292.17,20.83 v2(291.89,21.11) ; v2(296.11,21.55) 296.11,21.95 295.4,22.65 RE21.1 295.4,23.42 295.81,23.83 295.81,25.07 294.16,26.72 293.34,26.72 290.69,24.08 286.26,24.08 283.19,21.01 278.62,21.01 275.12,17.51 275.12,15.06 v2(275.29,14.89)
  IN2 w0.099: v2(291.89,21.11) 293.98,21.11 294.82,20.27 295.71,20.27 296.11,20.67 v2(296.11,21.55)
  IN6 w0.089: 88.2,29.05 88.19,29.05 87.23,28.09 86.14,27 84.79,25.65 84.79,24.07 85.06,23.8 85.06,22.82 85.43,22.45 88.18,22.45 88.41,22.69 91.32,22.69 91.91,22.1 91.91,20.21 93.8,18.33 94.99,18.33 96.79,16.52 97.61,16.52 99.18,14.95 101.95,14.95 101.96,14.95 101.98,14.95
  IN6 w0.099: 88.2,29.05 88.37,29.22 88.37,30.99 88.86,31.48 88.86,31.98 v2(89.1,32.22) ; v2(275.29,14.89) 275.11,15.07 275.11,15.4 274.75,15.76 268.28,15.76 264,11.48 243.78,11.48 242.44,12.82 228.78,12.82 225.69,15.91 176.09,15.91 175.83,16.17 165.26,16.17 164.96,15.86 131.74,15.86 131.01,16.59 124.77,16.59 124.16,15.98 122.54,15.98 122.04,15.48 121.32,15.48 120.82,14.99 120.08,14.99 119.98,15.09 114.08,15.09 112.64,13.65 106.47,13.65 105.75,14.37 102.82,14.37 102.23,14.95 101.98,14.95
USBC_MCP23008_SMBDAT: length 265.7
  TOP w0.076: UE3.N10 304.29,17.77
  TOP w0.14: v2(274.57,14.89) 274.73,15.04 274.73,17.67 278.46,21.4 283.03,21.4 286.1,24.47 290.53,24.47 293.17,27.11 294.33,27.11 295.66,25.78 RE20.1 296.26,25.56 v2(296.26,24.03) ; v2(304.42,17.84) 304.34,17.77 304.29,17.77 ; v2(88.37,32.22) 88.51,32.35 88.51,32.71 85.09,36.12 83.54,36.12 83.03,35.61 82.43,35.61 RE108.2
  IN5 w0.099: v2(304.42,17.84) 304.42,18.54 304.93,19.05 304.93,21.39 304.03,22.29 299.84,22.29 298.53,23.6 296.69,23.6 v2(296.26,24.03)
  IN6 w0.089: 101.98,14.6 101.96,14.6 101.95,14.61 99.04,14.61 97.47,16.18 96.65,16.18 94.84,17.98 93.66,17.98 91.57,20.07 91.57,21.96 91.18,22.35 88.56,22.35 88.32,22.11 85.29,22.11 84.72,22.68 84.72,23.66 84.45,23.93 84.45,25.79 85.9,27.24 86.99,28.33 87.85,29.19 87.85,29.2 87.86,29.21
  IN6 w0.099: v2(88.37,32.22) 88.51,32.08 88.51,31.62 88.02,31.14 88.02,29.37 87.86,29.21 ; 101.98,14.6 102.08,14.6 102.67,14.01 105.61,14.01 106.32,13.29 112.79,13.29 114.22,14.73 119.83,14.73 119.93,14.63 120.97,14.63 121.47,15.13 122.19,15.13 122.68,15.62 124.3,15.62 124.91,16.23 130.87,16.23 131.59,15.51 165.11,15.51 165.41,15.81 175.68,15.81 175.95,15.55 225.54,15.55 228.63,12.46 242.3,12.46 243.63,11.13 264.15,11.13 268.43,15.41 274.6,15.41 274.76,15.25 274.76,15.07 v2(274.57,14.89)
VCORE_B+: length 9.2
  BOTTOM w0.508: 126.94,114.17 126.82,114.05 120,114.05 118.87,112.92 118.76,112.92 PR1102.1
  vias: v1(136.06,114.85) v2(127.18,116) v2(127.2,115.4) v2(127.22,114.8) v2(127.83,115.96) v2(127.86,115.37) v2(127.87,114.77) v2(128.52,115.96) v2(128.54,115.37) v2(128.53,114.77) v2(129.18,115.96) v2(129.2,115.37) v2(129.21,114.77) v2(129.84,115.96) v2(129.83,115.36) v2(129.83,114.75) v2(131.01,115.53) v2(131.03,114.94) v2(131.63,115.53) v2(131.64,114.93) v2(132.26,115.51) v2(132.25,114.92) v2(132.85,115.52) v2(132.84,114.94) v2(133.45,115.52) v2(133.44,114.93) v2(134.04,115.51) v2(134.04,114.9) v2(137.77,119.71) v2(138.51,119.71) v2(138.58,118.96) v2(138.63,118.33) v2(152.55,119.66) v2(152.58,119.05) v2(153.14,119.66) v2(153.16,119.05) v2(153.72,119.66) v2(153.75,119.05) v2(154.34,119.65) v2(154.37,119.05) v2(155.01,119.67) v2(155.01,119.06) v2(160.96,119.81) v2(160.98,119.16) v2(161.03,118.53) v2(161.62,119.15) v2(161.73,119.77) v2(161.77,118.51) v2(162.24,119.18) v2(162.46,118.57) v2(163.13,118.64)
VGA_EDID_CLK: length 4.1
  BOTTOM w0.102: UV18.R2 210.44,59.18 210.05,58.79 210.05,58.45 210.17,58.34 210.17,58.08 210.19,58.07 210.19,58.04
  BOTTOM w0.14: RV572.1 209.08,56.25 209.08,56.64 210.19,57.74 210.19,58.04
VGA_EDID_DATA: length 5.1
  BOTTOM w0.102: 209.79,58.04 209.79,58.07 209.81,58.08 209.81,58.19 209.7,58.3 209.7,58.94 210.02,59.27 210.02,59.79 UV18.R3
  BOTTOM w0.14: RV573.1 208.69,56.3 208.69,56.8 209.79,57.9 209.79,58.04
VGA_IDENTIFY: length 11.9
  TOP w0.14: v2(302.57,16.57) 302.18,16.97 UE3.L9 ; v1(311.3,19.24) 311.66,18.89 v2(311.66,18.8) RE112.1
  IN6 w0.076: v2(302.57,16.57) 302.99,16.57 303.47,17.05
  IN6 w0.099: v2(311.66,18.8) 311.01,18.8 310.51,18.29 305.52,18.29 304.36,17.12 303.54,17.12 303.47,17.05
VR_ON: length 122.9
  TOP w0.14: UZ12.4 115.76,51.37 115.1,50.71 RZ71.1 114.99,50.66 RZ60.2 116.07,49.9 116.42,49.55 v1(117.34,49.55) 117.77,49.55 118.21,49.11 119.79,49.11 120.19,49.51 v2(120.57,49.51)
  TOP w0.254: PR1118.1 v2(111.99,113.22)
  IN1 w0.099: v2(120.57,49.51) 120.73,49.51 123.19,47.04 v2(129.54,47.04)
  IN4 w0.089: 134.62,77.53 137.58,77.53 138.47,78.43 138.47,80.56
  IN4 w0.091: v2(129.54,47.04) 129.54,47.88 134.37,52.71 134.37,58.73 134.38,65.22 134.38,66.1 133.3,67.17 133.3,71.27 132.23,72.34 132.23,76.21 133.55,77.53 134.62,77.53 ; v2(111.99,113.22) 112.46,113.69 113.13,113.69 113.39,113.44 113.39,112.88 114.47,111.8 120.24,111.8 123.24,108.8 123.24,105.16 125.62,102.78 132.56,102.78 135.78,99.55 135.78,95.74 136.25,95.27 136.25,84.73 136.53,84.44 136.53,83.83 136.42,83.72 136.42,82.94 138.47,80.89 138.47,80.56
  BOTTOM w0.14: RZ1955.1 120.41,57.55 120.89,57.07 120.89,53.63 120.52,53.26 120.52,49.56 v2(120.57,49.51)
VR_SVID_ALERT#: length 26.6
  TOP w0.14: v2(115.83,113.22) 115.87,113.17 PR1132.1 ; RH152.2 RH153.1 134.35,105.95 134.35,106.29 133.92,106.72 v1(132.96,106.72) v2(132.39,107.29)
  IN1 w0.099: v2(115.83,113.22) 116.61,114.01 116.61,114.45 117.04,114.89 124.04,114.89 128.06,110.87 130.13,110.87 132.39,108.61 v2(132.39,107.29)
VR_SVID_ALERT#_C: length 2.5
  TOP w0.14: PR1132.2 115.87,111.47 116.47,110.87 PU1100.44
VR_SVID_ALERT#_R: length 35.6
  TOP w0.14: RH153.2 133.72,104.38 134.11,103.99 134.11,103.85 134.38,103.59 134.38,103.15 v2(134.07,102.85)
  IN1 w0.099: v2(134.07,102.85) 134.07,102.11 134.95,101.23 134.95,100.23 135.84,99.35 136.84,99.35 137.07,99.11 137.68,99.11 v2(138.18,98.62)
  IN2 w0.099: v2(138.18,98.62) 138.18,97.98 137.85,97.66 137.85,93.88 134.37,90.4 134.37,83.32 135.18,82.52 137.58,82.52 138.58,81.51 140.81,81.51 140.89,81.43 141.56,81.43 142.01,81.88 v2(142.01,82.63)
  BOTTOM w0.076: v2(142.01,82.63) 142.09,82.63 UH1.BH31
VR_SVID_CLK: length 64
  TOP w0.14: PR1319.1 115.05,113.34 PR1131.2 114.41,113.59 v2(114.16,113.84)
  IN1 w0.099: v2(138.76,98.62) 137.74,99.65 137.24,99.65 137.14,99.75 136.01,99.75 135.36,100.4 135.36,100.85 135.42,100.92 135.42,101.47 134.77,102.12 134.77,103.1 134.27,103.59 134.27,106.33 133.08,107.53 133.08,108.51 130.32,111.28 128.22,111.28 124.16,115.34 115.67,115.34 v2(114.16,113.84)
  IN2 w0.099: v2(138.76,98.62) 138.96,98.43 138.96,93.96 134.93,89.93 134.93,83.6 135.74,82.79 138.06,82.79 138.42,82.44 139.87,82.44 139.93,82.37 140.62,82.37 140.84,82.6 140.84,83.59 140.95,83.69 141.6,83.69 v2(142.01,83.28)
  BOTTOM w0.076: UH1.BH32 142.33,82.96 v2(142.01,83.28)
VR_SVID_CLK_C: length 2.5
  TOP w0.14: PU1100.45 116.07,109.9 116.12,109.94 116.12,110.4 115.14,111.38 PR1319.2
VR_SVID_DATA: length 65.6
  TOP w0.14: RH151.2 133.41,102.59 v2(133.48,102.66) ; PR1318.1 PR1145.2 116.68,113.59 v2(117.45,114.36)
  IN1 w0.099: v2(137.59,98.59) 137.02,98.59 136.67,98.94 135.67,98.94 134.55,100.06 134.55,101.06 133.48,102.13 v2(133.48,102.66) 132.66,103.47 132.66,106.36 131.97,107.06 131.97,108.4 129.91,110.47 127.89,110.47 123.99,114.36 v2(117.45,114.36)
  IN2 w0.099: v2(137.59,98.59) 137.18,98.18 137.18,94.27 133.82,90.9 133.82,83.09 134.65,82.25 136.88,82.25 138.08,81.06 140.69,81.06 141,80.74 141.46,80.74 141.99,81.27 142.24,81.27 142.34,81.17 142.34,80.88 141.73,80.27 140.83,80.27 140.72,80.16 140.72,79.84 140.82,79.74 141.92,79.74 142.19,80.01 v2(142.88,80.01)
  BOTTOM w0.076: UH1.BH29 142.53,80.83 142.88,80.49 v2(142.88,80.01)
VR_SVID_DATA_C: length 2.5
  TOP w0.14: PR1318.2 117,111.34 v1(117,110.63) 117,110.21 116.87,110.08 PU1100.43
VRALERT#: length 4.8
  BOTTOM w0.089: UH2.BE32 83.86,5.63 83.63,5.39 83.63,4.25 83.08,3.71 83.08,3 82.26,2.17 82.26,1.91
  BOTTOM w0.14: 82.26,1.91 RH5837.2
VREF_NVVDD: length 2.5
  BOTTOM w0.203: PU1001.8 168.12,117.81 168.78,118.47 PC1005.1
  BOTTOM w0.508: PC1005.1 PR1005.1
VREF_NVVDDS: length 2.9
  BOTTOM w0.203: PU1501.8 186.25,116.29 185.82,116.72 PC1501.1 PR1505.1
VSET_5085: length 11.1
  TOP w0.14: v1(289.36,20.77) 288.98,21.15 v2(288.98,21.29) 288.32,21.29 CE41.1 288.24,20.77 288.37,20.64 RE58.1 ; v2(295.36,17.37) UE3.C9
  IN6 w0.076: 293.56,18.32 294.52,17.37 v2(295.36,17.37)
  IN6 w0.099: v2(288.98,21.29) 289.56,20.7 291.18,20.7 293.56,18.32
WLAN_PWR_EN: length 76.2
  TOP w0.254: v2(339.51,103.07) 339.35,103.24 RN33.2 339.29,103.63 338.77,103.63 338.54,103.86 UN3.3
  IN2 w0.099: v2(334.33,46.64) 337.44,49.75 337.44,62.48 333.42,66.5 333.42,75.72 330.56,78.59 330.56,79.25 329.64,80.16 329.64,81.74 328.96,82.42 328.26,82.42 327.91,82.78 327.91,83.3 328.42,83.82 329.33,83.82 335.27,89.76 335.27,98.45 338.21,101.4 338.21,101.98 339.3,103.07 v2(339.51,103.07)
  BOTTOM w0.14: v1(333.68,46.89) 334.08,46.89 v2(334.33,46.64) 334.21,46.52 RZ1141.2 334.39,45.85 335.03,46.48 RZ1142.2 335.99,45.96 335.99,44 335.92,43.93 DN3.1
WLAN_WIGIG60GHZ_DIS#: length 84.7
  TOP w0.14: UE3.L13 302.16,20.73 302.53,21.1 302.53,21.38 302.91,21.76 303.8,21.76 303.82,21.78 303.9,21.78 v2(303.91,21.79) 303.91,21.87 303.91,21.87 303.91,22.28 RE71.2 ; v2(327.47,82.2) v1(326.77,82.2)
  IN6 w0.099: v2(327.47,82.2) 327.47,80.18 329.39,78.26 329.39,74.19 328.17,72.98 328.17,64.77 330.57,62.37 330.57,60.28 329.57,59.28 329.57,58.29 328.38,57.11 328.38,51.81 327.93,51.36 327.93,45.52 325.63,43.22 325.63,40.51 325.13,40.02 318.07,40.02 314.5,36.45 314.5,35.79 310.68,31.96 308.69,31.96 306.71,29.97 306.71,26.28 306.32,25.9 305.58,25.9 304.55,24.87 304.55,24.13 303.91,23.49 v2(303.91,21.79)
  BOTTOM w0.14: DN1.1 327.38,82.11 v2(327.47,82.2)
WLAN_WIGIG60GHZ_DIS#_R: length 20.2
  TOP w0.14: v1(327.88,83.48) v2(328.36,83)
  IN2 w0.099: v2(340.79,89.67) 340.67,89.56 339.96,89.56 339.74,89.33 336.68,89.33 330.68,83.34 328.7,83.34 v2(328.36,83)
  BOTTOM w0.14: v2(340.79,89.67) 341.53,89.67 342.3,90.45 JNGFF1.48 ; v2(328.36,83) 328.26,82.89 DN1.2
XCLK_BIASREF: length 4.5
  BOTTOM w0.305: 99.19,19.41 98.86,19.41 98.63,19.64 98.28,19.64 98.06,19.86 UH2.T3
  BOTTOM w0.381: 99.19,19.41 99.43,19.41 99.56,19.54 100.2,19.54 100.46,19.28 100.46,18.87 101.17,18.16 RH71.2
XDP_BPM#0: length 24.7
  TOP w0.14: v2(126.72,90.63) 126.72,90.78 126.95,91.01 JXDP.21
  IN2 w0.099: v2(126.72,90.63) 126.72,90.26 126.98,90.01 126.98,85.78 128.41,84.35 128.41,80.94 130.25,79.09 131.51,79.09 132.3,78.3 132.56,78.3 132.76,78.5 132.98,78.5 133.13,78.35 133.13,78.04 133.22,77.95 134.09,77.95 134.26,78.12 134.54,78.12 134.71,77.95 134.93,77.95 135.06,78.07 135.06,78.31 v2(134.85,78.52)
  BOTTOM w0.076: UH1.BR27 137.82,79.01 137.35,79.01 137.31,79.04 135.37,79.04 v2(134.85,78.52)
XDP_BPM#1: length 28.2
  TOP w0.14: JXDP.23 126.71,91.51 126.14,90.93 v2(126.14,90.63)
  IN2 w0.099: v2(134.16,78.51) 134.12,78.51 133.72,78.92 132.26,78.92 131.49,79.68 130.1,79.68 128.77,81.01 128.77,84.42 127.62,85.56 127.62,90.52 127.84,90.73 128.36,90.73 128.98,91.36 128.98,91.58 128.84,91.72 128.68,91.72 128.14,91.19 126.68,91.19 126.14,90.64 v2(126.14,90.63)
  BOTTOM w0.076: 134.62,79.21 137.38,79.21 UH1.BT27
  BOTTOM w0.14: 134.62,79.21 134.45,79.21 134.16,78.91 v2(134.16,78.51)
XDP_DBRESET#: length 6.7
  TOP w0.14: v2(124.96,96.58) 124.04,97.51 JXDP.48
  BOTTOM w0.14: v2(124.96,96.58) 124.89,96.58 124.25,95.94 RH8.1 123.85,95.81 123.58,96.08 RH5.2 CH175.1 v1(122.64,97.05)
XDP_PLTRST#: length 7.6
  TOP w0.14: v1(118.47,93) 118.28,93.19 RH480.2 RH479.2 RH492.2 118.76,96.38 120.32,96.38 120.68,96.74 121.16,96.74 121.42,97.01 JXDP.46
XDP_PRDY#: length 117.4
  TOP w0.089: v5(136.32,78.98) 136.04,78.7 v2(136.04,78.5)
  TOP w0.14: JXDP.5 126.65,87.01 126.51,86.87 126.51,85.46 126.63,85.34 128.54,85.34 v2(128.72,85.51)
  IN2 w0.099: v2(96.36,12.64) 97.91,14.19 98.46,14.19 98.96,14.69 101.73,14.69 102.01,14.98 103.68,14.98 103.88,15.18 108.34,15.18 108.72,15.56 108.72,16.31 110.29,17.88 112.39,17.88 v2(112.82,18.31)
  IN2 w0.102: v2(128.72,85.51) 128.72,85.41 129.35,84.77 129.64,84.77 130.47,83.95 130.47,81.86 133.01,79.32 133.89,79.32 134.07,79.13 135.41,79.13 v2(136.04,78.5)
  IN4 w0.089: v2(136.04,78.5) 135.66,78.11 134.62,78.11
  IN4 w0.091: 134.62,78.11 133.31,78.11 131.63,76.43 131.63,71.96 132.15,71.44 132.15,66.06 133.41,64.81 133.41,52.99 122.11,41.69 121.03,41.69 111.26,31.92 111.26,28.83 111.51,28.58 111.51,21.09 113.85,18.75 113.85,18.05 113.69,17.9 113.12,17.9 112.82,18.2 v2(112.82,18.31)
  BOTTOM w0.076: v2(136.04,78.5) 136.27,78.73 137.29,78.73 137.34,78.78 138.25,78.78 UH1.BP27
  BOTTOM w0.089: UH2.AM5 96.89,12.1 v2(96.36,12.64)
