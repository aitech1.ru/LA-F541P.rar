# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D51: length 104.3
  IN1 w0.079: v2(169.48,67.07) 170.02,66.53 170.02,65.16 170.2,64.98 170.2,63.26 170.75,62.7 170.75,59.93 173.33,57.35 176.43,57.35 178.2,55.59 178.31,55.59 178.42,55.7 178.42,55.81 177.07,57.16 177.07,57.27 177.17,57.37 177.31,57.37 178.74,55.94 178.74,55.05 179.3,54.48 181.27,54.48 182.55,53.21 183.35,53.21 183.78,52.78 187.54,52.78 187.71,52.62 191,52.62 191.12,52.75 191.12,53.19 191.2,53.26 191.36,53.26 191.44,53.19 191.44,52.75 191.56,52.62 194.1,52.62 197.78,48.93 199.17,48.93 202.24,45.86 202.83,45.86 208.96,39.73 216.76,39.73 217.91,38.58 231.95,38.58 240.56,29.97 240.56,29.15 243.48,26.23 v2(243.48,25.72)
  BOTTOM w0.089: UH1.P11 169.35,67.07 v2(169.48,67.07)
  BOTTOM w0.14: JDIMM2.229 242.67,26.52 v2(243.48,25.72)
DDR_B_D52: length 101.1
  IN1 w0.079: v2(240.18,24.45) 239.69,24.94 239.69,26.19 237.17,28.71 237.17,29.53 230.83,35.87 216.78,35.87 215.64,37.02 207.01,37.02 205.51,38.52 205.26,38.52 202.61,41.17 201.93,41.84 201.93,41.95 202.04,42.07 202.16,42.07 202.83,41.39 202.88,41.34 203.02,41.34 203.12,41.44 203.12,41.55 203.06,41.61 201.77,42.89 200.88,42.89 199.34,44.44 198.45,44.44 192.98,49.91 179.97,49.91 176.88,52.99 175.83,52.99 172.94,55.88 172.32,55.88 168.55,59.65 168.55,63.92 168.19,64.28 168.19,64.62 168.56,64.99 v2(168.56,65.12)
  BOTTOM w0.089: v2(168.56,65.12) 168.43,65.12 UH1.R8
  BOTTOM w0.14: v2(240.18,24.45) 239.25,25.38 239.25,25.98 238.18,27.05 JDIMM2.211
DDR_B_D53: length 102.7
  IN1 w0.079: v2(168.56,66.42) 168.19,66.05 168.19,64.88 168.02,64.7 168.02,64.21 168.37,63.85 168.37,59.59 172.25,55.71 172.71,55.71 175.71,52.71 176.6,52.71 177.86,51.46 177.86,51.35 177.56,51.06 177.56,50.94 177.68,50.83 177.79,50.83 178.08,51.12 178.19,51.12 178.3,51.01 178.3,50.9 178.01,50.61 178.01,50.5 178.12,50.39 178.23,50.39 178.52,50.68 178.64,50.68 179.69,49.63 192.86,49.63 198.33,44.15 199.22,44.15 205.2,38.17 205.45,38.17 206.89,36.73 215.52,36.73 216.67,35.59 230.71,35.59 236.88,29.41 236.88,28.59 239.41,26.07 239.41,23.66 239.89,23.18 v2(240.18,23.18)
  BOTTOM w0.089: v2(168.56,66.42) 168.43,66.42 UH1.R10
  BOTTOM w0.14: v2(240.18,23.18) 239.11,22.11 239.11,21.36 238.42,20.67 JDIMM2.212
DDR_B_D54: length 101.2
  IN1 w0.079: v2(243.48,23.18) 242.93,23.18 242.75,23.37 242.75,26.16 240,28.91 240,29.74 231.72,38.01 217.67,38.01 216.52,39.16 208.73,39.16 202.66,45.23 202.08,45.23 198.93,48.37 197.55,48.37 195.75,50.17 193.87,52.05 187.47,52.05 187.31,52.22 183.55,52.22 183.13,52.63 180.28,52.63 177.03,55.88 174.52,55.88 173.47,56.92 173.26,56.92 170.31,59.87 170.31,62.64 169.85,63.11 169.85,64.75 v2(169.48,65.12)
  BOTTOM w0.089: UH1.P8 169.35,65.12 v2(169.48,65.12)
  BOTTOM w0.14: JDIMM2.224 241.42,21.38 243.23,23.18 v2(243.48,23.18)
DDR_B_D55: length 103.3
  IN1 w0.079: v2(243.48,24.45) 243.31,24.45 243.03,24.73 243.03,26.28 240.28,29.03 240.28,29.85 231.83,38.3 217.79,38.3 216.64,39.44 208.84,39.44 202.76,45.53 202.18,45.53 199.05,48.65 197.67,48.65 193.98,52.34 187.59,52.34 187.43,52.5 183.67,52.5 183.24,52.93 182.43,52.93 181.18,54.18 179.21,54.18 176.8,56.59 176.69,56.59 176.34,56.24 176.23,56.24 176.11,56.35 176.11,56.46 176.46,56.81 176.46,56.92 176.26,57.13 174.93,57.13 174.86,57.06 174.86,56.4 174.79,56.33 174.63,56.33 174.54,56.41 174.54,57.06 174.48,57.13 173.3,57.13 170.52,59.91 170.52,62.69 170.02,63.18 170.02,64.88 169.85,65.06 169.85,66.05 v2(169.48,66.42)
  BOTTOM w0.089: UH1.P10 169.35,66.42 v2(169.48,66.42)
  BOTTOM w0.14: JDIMM2.225 241.67,26.97 242.36,26.29 242.36,25.57 v2(243.48,24.45)
DDR_B_D56: length 100.5
  IN1 w0.079: v2(245.77,25.72) 245.26,26.23 245.26,26.55 242.79,29.02 242.79,29.62 232.78,39.63 218.34,39.63 217.19,40.78 209.4,40.78 199.35,50.82 197.38,50.82 194.02,54.19 191.95,54.19 191.88,54.27 191.88,54.42 191.95,54.5 193.39,54.5 193.46,54.58 193.46,54.74 193.39,54.82 192.35,54.82 192.28,54.9 192.28,55.04 192.2,55.12 192.04,55.12 191.96,55.04 191.96,54.9 191.88,54.82 191.32,54.82 190.37,55.77 190.37,57.63 187.47,60.53 186.19,60.53 185.81,60.9 183.7,60.9 183.28,60.48 173.68,60.48 172.97,61.19 172.97,61.63 172.62,61.98 172.62,63.19 172.18,63.63 171.41,63.63 v2(171.24,63.8)
  BOTTOM w0.076: v2(171.24,63.8) 171.2,63.8 UH1.M7
  BOTTOM w0.14: v2(245.77,25.72) 245.14,25.72 244.67,26.19 JDIMM2.237
DDR_B_D57: length 106
  IN1 w0.079: v2(171.31,67.07) 170.75,66.52 170.75,65.43 170.71,65.39 170.71,63.22 171.3,62.63 171.3,62.13 171.92,61.51 172.3,61.51 172.57,61.24 172.57,60.99 174.81,58.74 178.78,58.74 179.23,58.29 179.23,58.18 178.95,57.9 178.95,57.79 179.06,57.68 179.18,57.68 179.45,57.96 179.56,57.96 179.68,57.85 179.68,57.73 179.4,57.46 179.4,57.35 179.51,57.23 179.62,57.23 179.9,57.51 180.01,57.51 181.82,55.71 181.82,55.21 183.17,53.86 183.43,53.86 184.03,53.26 187.95,53.26 189.64,54.95 190.39,54.95 191.72,53.62 193.78,53.62 197.15,50.26 199.12,50.26 209.16,40.21 216.96,40.21 218.11,39.06 232.55,39.06 242.23,29.38 242.23,28.17 244.29,26.1 244.29,23.39 v2(245.77,21.91)
  BOTTOM w0.089: v2(171.31,67.07) 171.17,67.07 UH1.M11
  BOTTOM w0.14: JDIMM2.236 244.42,20.73 245.61,21.91 v2(245.77,21.91)
DDR_B_D58: length 105.6
  IN1 w0.079: v2(172.19,67.07) 172.66,66.6 172.66,66.28 173.58,65.36 173.95,65.36 174.72,64.59 176.44,64.59 177.42,63.61 188.22,63.61 189.33,62.5 189.77,62.5 198.73,53.53 200.71,53.53 201.82,52.42 203.55,52.42 204.45,51.52 204.45,49.81 208.01,46.24 208.48,46.24 211.24,43.49 219.54,43.49 220.65,42.38 221.15,42.38 221.66,42.89 222.59,42.89 223.06,42.42 224.46,42.42 225.13,43.09 227.02,43.09 227.72,42.39 233.86,42.39 237.45,38.79 237.56,38.79 237.68,38.9 237.68,39.01 236.28,40.41 236.28,40.52 236.39,40.63 236.5,40.63 238.12,39.01 238.12,38.9 237.79,38.57 237.79,38.46 248.81,27.43 v2(248.81,25.72)
  BOTTOM w0.089: UH1.L11 172.09,67.07 v2(172.19,67.07)
  BOTTOM w0.14: v2(248.81,25.72) 248.3,25.72 247.68,26.34 JDIMM2.249
DDR_B_D59: length 102.1
  IN1 w0.079: v2(172.17,64.58) 172.79,63.96 173.44,63.96 175.26,62.13 176.1,62.13 176.74,62.77 187.87,62.77 189.18,61.46 189.61,61.46 198.38,52.69 200.3,52.69 206.38,46.6 206.38,46.43 208.3,44.51 208.41,44.51 208.56,44.67 208.67,44.67 208.78,44.56 208.78,44.44 208.63,44.29 208.63,44.18 208.74,44.07 208.85,44.07 209.01,44.22 209.12,44.22 209.23,44.11 209.23,44 209.08,43.84 209.08,43.73 210.17,42.64 217.97,42.64 219.11,41.49 233.56,41.49 247.78,27.27 247.78,24.54 248,24.32 248,22.5 248.59,21.91 v2(248.81,21.91)
  BOTTOM w0.089: v2(172.17,64.58) 172.12,64.58 UH1.L7
  BOTTOM w0.14: JDIMM2.250 247.93,21.08 248.75,21.9 248.81,21.9 v2(248.81,21.91)
DDR_B_D60: length 104.3
  IN1 w0.079: v2(245.77,23.18) 245.09,23.18 244.59,23.69 244.59,26.65 242.51,28.72 242.51,29.5 232.67,39.35 218.22,39.35 217.08,40.49 209.28,40.49 199.23,50.54 197.26,50.54 193.9,53.9 191.84,53.9 190.09,55.65 190.09,57.51 187.35,60.25 186.07,60.25 185.7,60.62 183.87,60.62 183.43,60.18 173.68,60.18 172.76,61.1 172.76,61.46 172.44,61.79 172.44,62.62 172.23,62.83 171.34,62.83 170.88,63.29 170.88,65.32 170.93,65.37 170.93,66.05 v2(171.31,66.42)
  BOTTOM w0.089: UH1.M10 171.17,66.42 v2(171.31,66.42)
  BOTTOM w0.14: v2(245.77,23.18) 245.61,23.18 243.42,21 JDIMM2.232
DDR_B_D61: length 102.4
  IN1 w0.079: v2(171.24,64.44) 171.88,63.8 172.25,63.8 172.81,63.23 172.81,62.1 173.14,61.78 173.14,61.34 173.7,60.78 175.3,60.78 175.8,61.28 176.32,61.28 176.63,60.97 177.28,60.97 177.62,61.31 178.23,61.31 178.62,60.93 181.73,60.93 181.99,61.19 182.21,61.19 182.29,61.11 182.29,60.89 182.36,60.81 182.52,60.81 182.6,60.89 182.6,61.11 182.68,61.19 182.84,61.19 182.92,61.11 182.92,60.89 182.99,60.81 183.15,60.81 183.52,61.19 185.93,61.19 186.3,60.81 187.58,60.81 190.66,57.74 190.66,56.8 190.96,56.49 190.96,56.38 190.68,56.09 190.68,55.98 190.79,55.87 190.9,55.87 191.19,56.15 191.3,56.15 191.84,55.61 192.99,55.61 197.5,51.1 199.47,51.1 209.51,41.06 217.31,41.06 218.46,39.91 232.9,39.91 243.07,29.74 243.07,29.15 243.37,28.85 243.83,28.85 246.2,26.48 246.2,24.88 v2(245.77,24.45)
  BOTTOM w0.089: UH1.M8 171.2,64.44 v2(171.24,64.44)
  BOTTOM w0.14: v2(245.77,24.45) 243.67,26.54 JDIMM2.233
DDR_B_D62: length 104.5
  IN1 w0.079: v2(172.19,66.42) 172.73,65.88 172.73,65.43 173.64,64.53 174.28,64.53 175.01,63.81 176.73,63.81 177.21,63.33 188.1,63.33 189.38,62.05 189.81,62.05 198.62,53.25 200.54,53.25 207.83,45.96 208.36,45.96 211.12,43.2 218.2,43.2 219.35,42.06 219.46,42.06 219.57,42.17 219.57,42.28 218.87,42.98 218.87,43.09 218.98,43.2 219.09,43.2 220.24,42.06 221.57,42.06 221.65,42.13 221.65,42.42 221.73,42.5 221.89,42.5 221.97,42.42 221.97,42.13 222.04,42.06 222.2,42.06 222.28,42.13 222.28,42.42 222.36,42.5 222.52,42.5 222.6,42.42 222.6,42.13 222.67,42.06 233.79,42.06 248.34,27.5 248.34,24.92 v2(248.81,24.45)
  BOTTOM w0.089: v2(172.19,66.42) 172.09,66.42 UH1.L10
  BOTTOM w0.14: v2(248.81,24.45) 247.1,26.16 247.1,26.69 246.67,27.12 JDIMM2.245
DDR_B_D63: length 103.1
  IN1 w0.079: v2(248.81,23.18) 248.81,23.05 248.68,22.91 248.42,22.91 248.29,23.05 248.29,24.44 248.06,24.66 248.06,27.38 233.67,41.77 219.23,41.77 218.08,42.92 211,42.92 208.25,45.68 207.7,45.68 200.41,52.97 198.5,52.97 189.69,61.77 189.26,61.77 187.99,63.05 176.72,63.05 176.66,62.99 175.6,62.99 175.52,62.91 175.52,62.52 175.44,62.44 175.29,62.44 175.21,62.53 175.21,62.91 175.13,62.99 174.94,62.99 174.17,63.76 174.17,63.87 174.32,64.03 174.32,64.14 174.21,64.25 174.1,64.25 173.94,64.1 173.83,64.1 172.81,65.12 v2(172.19,65.12)
  BOTTOM w0.089: UH1.L8 172.06,65.12 v2(172.19,65.12)
  BOTTOM w0.14: JDIMM2.246 246.93,20.56 248.16,21.8 248.16,22.53 v2(248.81,23.18)
DDR_B_DQS0: length 90.2
  IN1 w0.079: v2(138.48,66.31) 138.48,65.82 138.42,65.76 138.05,65.76 137.24,66.57 136.44,66.57 135.9,66.03 135.9,65.67 135.26,65.03 135.26,64.64 134.57,63.94 134.57,46.47 147.55,33.48 157.31,33.48 157.44,33.35 157.44,33.24 157.28,33.08 157.28,32.85 157.48,32.65 157.73,32.65 157.88,32.8 157.99,32.8 163.1,27.69 175.16,27.69 175.83,27.02 183.32,27.02 184.25,26.09 184.25,24.86 184.8,24.32 184.98,24.32 v2(185.23,24.07)
  BOTTOM w0.089: UH1.BP9 138.75,66.03 v2(138.48,66.31)
  BOTTOM w0.14: v2(185.23,24.07) 185.36,24.2 185.82,24.2 186.14,24.52 186.14,25.98 186.58,26.43 186.58,26.86 186.68,26.95 JDIMM2.13
DDR_B_DQS1: length 88.5
  IN1 w0.079: v2(141.2,65.77) 140.99,65.77 140.93,65.71 140.93,63.03 140.73,62.82 140.73,61.62 141.22,61.12 141.22,58.93 139.24,56.95 139.24,47.33 147.87,38.71 157.63,38.71 164.09,32.24 178.47,32.24 179.31,31.4 184.9,31.4 190.46,25.84 190.46,23.25 190.53,23.19 190.81,23.19 190.89,23.27 v2(190.89,23.44)
  BOTTOM w0.076: v2(141.2,65.77) 141.08,65.66 141.08,65.42 141.17,65.33 141.47,65.33 UH1.BJ9
  BOTTOM w0.14: JDIMM2.34 191.92,20.52 191.79,20.66 191.79,22.83 191.41,23.21 191.12,23.21 v2(190.89,23.44)
DDR_B_DQS2: length 91.7
  IN1 w0.079: v2(196.61,24.07) 196.88,24.34 197.11,24.34 197.31,24.54 197.31,25.2 195.57,26.94 194.68,26.94 192.79,28.84 192.79,30.31 187.94,35.17 186.47,35.17 185.64,36 165.65,36 158.54,43.11 152.41,43.11 152.33,43.19 152.33,43.49 152.14,43.69 151.82,43.69 151.63,43.49 151.63,43.19 151.55,43.11 151.31,43.11 151.23,43.19 151.23,43.49 151.06,43.66 150.7,43.66 150.53,43.49 150.53,43.19 150.45,43.11 150.22,43.11 150.14,43.19 150.14,43.49 149.97,43.66 149.6,43.66 149.43,43.49 149.43,43.19 149.35,43.11 148.78,43.11 143.38,48.51 143.38,56.86 144.9,58.38 144.9,62.84 144.4,63.35 144.4,65.41 v2(144.76,65.77)
  BOTTOM w0.089: v2(144.76,65.77) 144.66,65.77 UH1.BF9
  BOTTOM w0.14: v2(196.61,24.07) 196.83,24.29 197.07,24.29 197.39,24.61 197.39,26.39 197.07,26.7 197.07,26.88 197.18,26.99 JDIMM2.55
DDR_B_DQS3: length 91
  IN1 w0.079: v2(202.65,23.44) 202.43,23.21 202.26,23.21 202.17,23.3 202.17,26.17 199.81,28.53 199.3,28.53 198.25,29.58 198.25,30.21 189.53,38.92 188.03,38.92 187.18,39.78 167.29,39.78 163.07,44 163.07,44.11 163.42,44.46 163.42,44.72 163.19,44.96 162.92,44.96 162.58,44.61 162.46,44.61 162.3,44.78 162.3,44.89 162.64,45.23 162.64,45.48 162.38,45.73 162.14,45.73 161.8,45.39 161.69,45.39 158.63,48.44 151.02,48.44 148.46,51.01 148.46,55.64 147.84,56.26 147.84,63.59 147.15,64.28 147.15,64.44 147.16,64.45 147.16,65.4 v2(147.53,65.77)
  BOTTOM w0.089: v2(147.53,65.77) 147.4,65.77 UH1.BB9
  BOTTOM w0.14: JDIMM2.76 202.43,20.53 202.32,20.63 202.32,20.73 203.38,21.79 203.38,23.01 203.13,23.26 202.82,23.26 v2(202.65,23.44)
DDR_B_DQS4: length 98.9
  IN1 w0.079: v2(230.6,24.75) 230.37,24.52 229.82,24.52 229.67,24.67 229.67,25.47 229.89,25.68 230.17,25.68 230.37,25.89 230.37,26.18 230.17,26.38 229.89,26.38 229.81,26.46 229.81,26.74 228.11,28.45 210.28,28.45 208.35,30.38 203.81,30.38 202.4,31.8 202.01,31.8 191.02,42.79 189.5,42.79 188.75,43.54 173.54,43.54 165.8,51.28 165.8,55.79 163.86,57.73 163.86,63.98 163.61,64.23 163.61,65.33 163.56,65.39 163.56,65.93 163.68,66.05 163.86,66.05 163.99,65.93 v2(163.99,65.77)
  BOTTOM w0.089: UH1.AA9 163.86,65.77 v2(163.99,65.77)
  BOTTOM w0.14: v2(230.6,24.75) 230.41,24.56 230.23,24.56 230.1,24.69 230.1,26.73 230.18,26.8 JDIMM2.179
DDR_B_DQS5: length 99.5
  IN1 w0.079: v2(165.83,65.14) 165.83,65.3 165.99,65.45 166.13,65.45 166.2,65.38 166.2,64.17 166.27,64.1 166.27,58.89 171.38,53.78 171.38,53.53 177.77,47.14 191.83,47.14 203.42,35.56 203.74,35.56 205.08,34.21 214.53,34.21 215.64,33.11 229.43,33.11 232.79,29.75 232.79,29.15 235.86,26.09 235.86,23.34 236.09,23.11 236.35,23.11 236.44,23.02 v2(236.44,22.86)
  BOTTOM w0.076: v2(165.83,65.14) 165.89,65.09 166.25,65.09 166.33,65.16 166.33,65.4 UH1.V9
  BOTTOM w0.14: JDIMM2.200 235.44,20.48 235.31,20.61 235.31,20.81 235.81,21.31 235.81,22.82 236,23.01 236.29,23.01 v2(236.44,22.86)
DDR_B_DQS6: length 101.5
  IN1 w0.079: v2(169.48,65.77) 169.48,65.86 169.31,66.03 169.06,66.03 168.92,65.89 168.92,65.54 169.1,65.36 169.1,59.84 172.53,56.41 173.38,56.41 174.5,55.28 176.22,55.28 176.59,54.91 176.59,54.68 176.27,54.35 176.27,54.24 176.36,54.14 176.51,54.14 176.81,54.45 177.05,54.45 180.45,51.06 193.45,51.06 197.14,47.37 198.07,47.37 198.74,46.7 199.06,46.7 200.92,44.84 200.92,44.81 201.68,44.04 202.44,44.04 208.31,38.17 216.11,38.17 217.26,37.02 231.3,37.02 238.7,29.63 238.7,28.8 241.31,26.19 241.31,25.67 241.14,25.51 241.09,25.51 241.01,25.43 241.01,25.27 241.09,25.19 241.14,25.19 241.31,25.02 241.31,24.68 241.43,24.55 241.49,24.55 v2(241.7,24.77)
  BOTTOM w0.089: UH1.P9 169.35,65.77 v2(169.48,65.77)
  BOTTOM w0.14: v2(241.7,24.77) 241.59,24.65 241.34,24.65 241.27,24.72 241.27,26.16 240.6,26.83 240.6,26.94 240.67,27.01 JDIMM2.221
DDR_B_DQS7: length 103.2
  IN1 w0.079: v2(171.26,65.06) 171.16,65.17 171.16,65.24 171.29,65.38 171.47,65.38 171.62,65.23 171.62,64.4 171.98,64.04 172.24,64.04 173.12,63.16 173.12,63.04 173.71,62.46 173.99,62.46 174.75,61.7 176.34,61.7 176.59,61.95 177.58,61.95 177.62,61.9 186.28,61.9 186.61,61.57 187.84,61.57 191.45,57.95 191.45,57.01 192.14,56.33 193.41,56.33 197.91,51.82 199.76,51.82 209.81,41.77 217.61,41.77 218.75,40.62 233.2,40.62 244.28,29.54 244.28,29.41 246.91,26.78 246.91,24.58 246.28,23.95 246.28,23.49 246.64,23.13 247.11,23.13 247.29,22.95 v2(247.29,22.86)
  BOTTOM w0.076: v2(171.26,65.06) 171.64,65.45 UH1.L9
  BOTTOM w0.14: v2(247.29,22.86) 247.09,23.06 246.93,23.06 246.8,22.93 246.8,21.57 245.93,20.69 JDIMM2.242
DDR_B_DQS#0: length 90.1
  IN1 w0.079: v2(185.23,24.71) 185.23,24.51 185.19,24.47 184.86,24.47 184.41,24.93 184.41,26.16 183.39,27.18 175.89,27.18 175.23,27.84 163.17,27.84 158.06,32.95 157.82,32.95 157.67,32.8 157.55,32.8 157.43,32.92 157.43,33.02 157.59,33.18 157.59,33.42 157.37,33.64 147.62,33.64 134.72,46.53 134.72,63.88 135.42,64.58 135.42,64.97 136.05,65.6 136.05,65.96 136.5,66.41 137.18,66.41 137.99,65.61 138.48,65.61 138.65,65.78 138.65,65.96 138.72,66.03 138.81,66.03 138.92,65.92 139.02,65.92 139.08,65.97 v2(139.08,66.29)
  BOTTOM w0.089: UH1.BN9 139.4,65.97 v2(139.08,66.29)
  BOTTOM w0.14: v2(185.23,24.71) 185.43,24.51 185.69,24.51 185.83,24.65 185.83,26.11 186.28,26.56 186.28,26.95 186.18,27.05 JDIMM2.11
DDR_B_DQS#1: length 88.4
  IN1 w0.079: v2(190.89,22.8) 190.66,23.03 190.46,23.03 190.31,23.19 190.31,25.78 184.84,31.25 179.24,31.25 178.41,32.09 164.03,32.09 157.56,38.55 147.8,38.55 139.09,47.26 139.09,57.02 141.07,58.99 141.07,61.06 140.57,61.55 140.57,62.88 140.78,63.09 140.78,66.05 v2(141.16,66.42)
  BOTTOM w0.076: UH1.BL9 v2(141.16,66.42)
  BOTTOM w0.14: JDIMM2.32 191.43,20.47 191.48,20.53 191.48,22.71 191.28,22.91 191,22.91 v2(190.89,22.8)
DDR_B_DQS#2: length 91.6
  IN1 w0.079: v2(143.87,65.77) 143.87,65.93 143.96,66.02 144.24,66.02 144.32,65.93 144.32,65.55 144.24,65.47 144.24,63.29 144.75,62.78 144.75,58.45 143.23,56.92 143.23,48.44 148.71,42.96 149.42,42.96 149.59,43.13 149.59,43.43 149.67,43.51 149.9,43.51 149.98,43.43 149.98,43.13 150.15,42.96 150.52,42.96 150.69,43.13 150.69,43.43 150.76,43.51 151,43.51 151.08,43.43 151.08,43.13 151.25,42.96 151.61,42.96 151.78,43.13 151.78,43.43 151.89,43.53 152.07,43.53 152.18,43.43 152.18,43.13 152.35,42.96 158.47,42.96 165.58,35.85 185.57,35.85 186.41,35.01 187.87,35.01 192.63,30.25 192.63,28.77 194.62,26.79 195.51,26.79 197.15,25.14 197.15,24.6 197.04,24.49 196.82,24.49 v2(196.61,24.71)
  BOTTOM w0.089: UH1.BG9 143.74,65.77 v2(143.87,65.77)
  BOTTOM w0.14: JDIMM2.53 196.67,27.01 196.77,26.92 196.77,26.58 197.08,26.26 197.08,24.74 196.95,24.6 196.72,24.6 v2(196.61,24.71)
DDR_B_DQS#3: length 91
  IN1 w0.079: v2(146.62,65.77) 146.7,65.85 146.83,65.85 146.99,65.7 146.99,64.22 147.68,63.53 147.68,56.2 148.31,55.57 148.31,50.94 150.96,48.29 158.57,48.29 161.62,45.23 161.86,45.23 162.21,45.58 162.32,45.58 162.49,45.41 162.49,45.3 162.14,44.95 162.14,44.71 162.4,44.45 162.64,44.45 162.99,44.8 163.12,44.8 163.27,44.66 163.27,44.52 162.92,44.17 162.92,43.94 167.23,39.63 187.11,39.63 187.97,38.77 189.47,38.77 198.09,30.14 198.09,29.52 199.23,28.38 199.74,28.38 202.02,26.1 202.02,23.23 202.19,23.06 202.39,23.06 v2(202.65,22.8)
  BOTTOM w0.089: v2(146.62,65.77) 146.49,65.77 UH1.BC9
  BOTTOM w0.14: v2(202.65,22.8) 202.81,22.96 203,22.96 203.08,22.88 203.08,21.92 202.02,20.86 202.02,20.63 201.92,20.53 JDIMM2.74
DDR_B_DQS#4: length 98.9
  IN1 w0.079: v2(230.6,24.11) 230.35,24.37 229.75,24.37 229.52,24.6 229.52,25.53 229.82,25.83 230.1,25.83 230.22,25.95 230.22,26.11 230.1,26.23 229.82,26.23 229.65,26.4 229.65,26.68 228.04,28.29 210.22,28.29 208.28,30.23 203.75,30.23 202.33,31.64 201.95,31.64 190.96,42.63 189.44,42.63 188.68,43.38 173.48,43.38 165.65,51.22 165.65,55.73 163.71,57.67 163.71,63.92 163.46,64.17 163.46,65.27 163.4,65.32 163.4,65.45 v2(163.08,65.77)
  BOTTOM w0.089: v2(163.08,65.77) 162.94,65.77 UH1.AC9
  BOTTOM w0.14: JDIMM2.177 229.67,26.83 229.8,26.7 229.8,24.56 230.1,24.25 230.46,24.25 v2(230.6,24.11)
DDR_B_DQS#5: length 99.5
  IN1 w0.079: v2(165.83,65.78) 166,65.61 166.19,65.61 166.35,65.45 166.35,64.24 166.43,64.16 166.43,58.96 171.54,53.84 171.54,53.59 177.83,47.3 191.89,47.3 203.48,35.71 203.8,35.71 205.14,34.37 214.59,34.37 215.7,33.26 229.5,33.26 232.95,29.81 232.95,29.22 236.02,26.15 236.02,23.41 236.16,23.26 236.21,23.26 v2(236.44,23.5)
  BOTTOM w0.076: UH1.W9 165.5,65.45 v2(165.83,65.78)
  BOTTOM w0.14: v2(236.44,23.5) 236.26,23.31 235.87,23.31 235.5,22.95 235.5,21.43 235.01,20.94 235.01,20.52 234.94,20.45 JDIMM2.198
DDR_B_DQS#6: length 101.6
  IN1 w0.079: v2(241.7,24.13) 241.43,24.4 241.37,24.4 241.15,24.62 241.15,24.96 241.07,25.04 241.03,25.04 240.86,25.21 240.86,25.49 241.03,25.66 241.07,25.66 241.15,25.74 241.15,26.13 238.54,28.74 238.54,29.56 231.24,36.86 217.2,36.86 216.05,38.01 208.25,38.01 202.37,43.89 201.61,43.89 200.76,44.74 200.76,44.78 199,46.54 198.68,46.54 198.01,47.22 197.07,47.22 193.39,50.9 180.38,50.9 176.99,54.3 176.88,54.3 176.57,53.99 176.3,53.99 176.11,54.18 176.11,54.42 176.44,54.74 176.44,54.85 176.16,55.13 174.44,55.13 173.31,56.25 172.47,56.25 168.94,59.77 168.94,65.29 168.76,65.47 168.76,65.57 v2(168.56,65.77)
  BOTTOM w0.089: v2(168.56,65.77) 168.43,65.77 UH1.R9
  BOTTOM w0.14: v2(241.7,24.13) 241.49,24.34 241.22,24.34 240.96,24.6 240.96,26.03 240.29,26.7 240.29,26.84 240.18,26.96 JDIMM2.219
DDR_B_DQS#7: length 103.3
  IN1 w0.079: v2(171.29,65.74) 171.33,65.74 171.78,65.29 171.78,64.46 172.04,64.2 172.3,64.2 173.28,63.22 173.28,63.11 173.77,62.61 174.05,62.61 174.82,61.85 176.28,61.85 176.53,62.1 177.64,62.1 177.69,62.05 186.35,62.05 186.68,61.72 187.9,61.72 191.61,58.02 191.61,57.07 192.2,56.48 193.47,56.48 197.98,51.97 199.83,51.97 209.87,41.93 217.67,41.93 218.82,40.78 233.26,40.78 244.44,29.6 244.44,29.47 247.07,26.84 247.07,24.52 246.44,23.89 246.44,23.56 246.7,23.29 247.09,23.29 v2(247.29,23.5)
  BOTTOM w0.076: UH1.M9 171,65.45 v2(171.29,65.74)
  BOTTOM w0.14: v2(247.29,23.5) 247.16,23.36 246.8,23.36 246.49,23.06 246.49,21.69 245.42,20.63 JDIMM2.240
DDR_B_MA0: length 98
  IN3 w0.089: 159.82,50.5 159.82,50.74 158.56,51.99 158.56,54.18 158.28,54.45 158.28,59.85 157.75,60.38 157.75,61.37 158.01,61.62 158.01,63.47 157.2,64.28 157.2,65.38 v2(157.59,65.77)
  IN3 w0.122: 159.82,50.5 159.82,49.26 167.18,41.9 171.38,41.9 172.39,40.89 194.6,40.89 196.5,38.98 211.19,38.98 219.66,30.51 219.66,23.68 v2(220.72,22.61)
  BOTTOM w0.076: UH1.AJ9 157.46,65.77 v2(157.59,65.77)
  BOTTOM w0.221: JDIMM2.144 219.43,21.32 v2(220.72,22.61)
DDR_B_MA1: length 98.2
  IN3 w0.089: v2(156.12,63.18) 156.12,62.39 155.76,62.02 155.76,54.95 155.89,54.82 155.89,52.4 156.48,51.81 156.48,50.5
  IN3 w0.122: v2(216.38,25.72) 216.38,28.23 215.76,28.85 215.76,30.57 210.06,36.27 194.75,36.27 194.59,36.43 194.59,37.06 194.44,37.2 194.21,37.2 194.09,37.08 194.09,36.4 193.96,36.27 193.71,36.27 193.6,36.38 193.6,37.08 193.48,37.2 193.23,37.2 193.11,37.08 193.11,36.7 192.99,36.58 192.75,36.58 192.62,36.7 192.62,37.08 192.5,37.2 187.4,37.2 187.28,37.32 187.28,37.57 187.4,37.69 189.85,37.69 189.97,37.81 189.97,38.05 189.85,38.17 171.26,38.17 170.26,39.18 166.05,39.18 156.48,48.75 156.48,50.5
  BOTTOM w0.076: UH1.AK6 156.26,63.18 v2(156.12,63.18)
  BOTTOM w0.221: JDIMM2.133 216.67,26.43 216.38,26.14 v2(216.38,25.72)
DDR_B_MA2: length 101.5
  IN3 w0.089: v2(156.9,62.5) 156.49,62.5 155.93,61.95 155.93,59.81 156.66,59.08 156.66,53.78 156.91,53.53 156.91,50.5
  IN3 w0.122: 156.91,50.5 156.91,48.93 166.23,39.61 170.43,39.61 171.44,38.6 193.65,38.6 193.77,38.48 193.77,38.24 193.65,38.11 190.58,38.11 190.45,37.99 190.45,37.75 190.58,37.63 194.62,37.63 195.55,36.69 210.24,36.69 216.84,30.09 216.84,24.42 v2(218.15,23.11)
  BOTTOM w0.076: v2(156.9,62.5) 156.85,62.5 UH1.AK5
  BOTTOM w0.221: v2(218.15,23.11) 218.06,23.11 216.89,21.94 216.89,21.06 216.43,20.59 JDIMM2.132
DDR_B_MA3: length 100.3
  IN3 w0.089: v2(155.34,62.51) 155.58,62.27 155.58,54.88 155.71,54.74 155.71,51.89 156.06,51.55 156.06,50.5
  IN3 w0.122: 156.06,50.5 156.06,48.58 165.88,38.76 170.08,38.76 171.09,37.75 186.73,37.75 186.86,37.63 186.86,37.38 186.73,37.26 182.91,37.26 182.79,37.14 182.79,36.89 182.91,36.77 191.95,36.77 192.88,35.84 209.89,35.84 215.33,30.39 215.33,28.4 215.5,28.23 215.76,28.23 215.95,28.03 215.95,24.87 v2(216.38,24.45)
  BOTTOM w0.076: UH1.AL5 155.67,62.84 v2(155.34,62.51)
  BOTTOM w0.221: JDIMM2.131 216.18,26.68 215.85,26.36 215.85,24.95 216.36,24.45 v2(216.38,24.45)
DDR_B_MA4: length 101.3
  IN3 w0.089: 154.86,50.5 154.7,50.67 154.7,59.2 154.09,59.8 154.09,63 154.18,63.37 154.34,63.53 154.97,63.53 v2(155.34,63.16)
  IN3 w0.122: v2(216.38,21.91) 215.1,23.19 215.1,27.42 214.48,28.04 214.48,30.04 209.53,34.99 192.53,34.99 191.59,35.92 177.76,35.92 177.63,36.04 177.63,36.28 177.76,36.41 180.06,36.41 180.18,36.53 180.18,36.77 180.06,36.89 170.73,36.89 169.73,37.9 165.52,37.9 155.2,48.22 155.2,50.16 154.86,50.5
  BOTTOM w0.076: v2(155.34,63.16) 155.67,63.49 UH1.AL6
  BOTTOM w0.221: JDIMM2.128 215.43,20.43 215.91,20.91 215.99,20.91 216.36,21.29 216.36,21.89 v2(216.38,21.91)
DDR_B_MA5: length 99.6
  IN3 w0.089: v2(154.5,63.16) 154.91,62.75 154.91,62.43 155.4,61.94 155.4,59.38 154.87,58.85 154.87,51.09 155.47,50.5
  IN3 w0.122: 155.47,50.5 155.63,50.34 155.63,48.4 165.7,38.33 169.9,38.33 170.91,37.32 182.24,37.32 182.36,37.2 182.36,36.96 182.24,36.83 180.73,36.83 180.61,36.71 180.61,36.47 180.73,36.35 191.77,36.35 192.7,35.41 209.71,35.41 214.9,30.22 214.9,28.22 215.53,27.6 215.53,24.5 215.65,24.37 215.85,24.37 215.98,24.25 215.98,23.92 215.85,23.79 215.65,23.79 215.53,23.66 215.53,23.41 215.65,23.29 216.27,23.29 v2(216.38,23.18)
  BOTTOM w0.076: UH1.AM6 154.83,63.49 v2(154.5,63.16)
  BOTTOM w0.221: v2(216.38,23.18) 216.32,23.18 215.26,22.11 215.26,21.05 214.92,20.72 JDIMM2.126
DDR_B_MA6: length 100.9
  IN3 w0.089: 154.26,50.5 154.25,50.51 154.25,59.11 153.86,59.5 153.86,62.93 154.02,63.47 154.52,63.97 v2(154.85,63.97)
  IN3 w0.122: v2(214.14,24.37) 214.32,24.19 214.56,24.19 214.67,24.3 214.67,27.25 213.57,28.34 213.57,30.28 209.3,34.56 192.35,34.56 191.41,35.49 174.31,35.49 174.18,35.63 174.18,35.87 174.29,35.98 177.08,35.98 177.21,36.1 177.21,36.35 177.08,36.47 170.56,36.47 169.55,37.47 165.35,37.47 154.78,48.05 154.78,49.98 154.26,50.5
  BOTTOM w0.076: v2(154.85,63.97) 154.67,64.15 UH1.AN7
  BOTTOM w0.221: v2(214.14,24.37) 215.18,25.4 JDIMM2.127
DDR_B_MA7: length 97.6
  IN3 w0.089: v2(154.85,66.42) 154.48,66.06 154.48,64.87 154.19,64.59 154.19,64.16 153.69,63.65 153.48,62.89 153.48,58.98 153.4,58.9 153.4,50.5
  IN3 w0.122: 153.4,50.5 153.4,50.16 153.92,49.63 153.92,47.69 164.99,36.62 169.19,36.62 170.2,35.61 172.98,35.61 173.96,34.64 191.06,34.64 191.99,33.71 203.93,33.71 204.9,32.73 209.92,32.73 212.16,30.49 212.16,28.56 213.7,27.01 213.7,23.46 v2(214.14,23.02)
  BOTTOM w0.076: v2(154.85,66.42) 154.71,66.42 UH1.AN10
  BOTTOM w0.221: v2(214.14,23.02) 214.23,23.02 214.63,22.63 214.63,21.26 213.92,20.56 JDIMM2.122
DDR_B_MA8: length 100.3
  IN3 w0.089: 153.82,50.5 153.82,58.92 153.66,59.08 153.66,62.86 153.86,63.57 154.37,64.08 154.37,64.43 154.46,64.52 v2(154.82,64.52)
  IN3 w0.122: 153.82,50.5 153.82,50.33 154.35,49.81 154.35,47.87 165.17,37.05 169.37,37.05 170.38,36.04 173.16,36.04 174.13,35.07 191.24,35.07 192.17,34.13 209.12,34.13 209.24,34.01 209.24,33.77 209.12,33.64 205.08,33.64 204.96,33.52 204.96,33.28 205.08,33.16 210.09,33.16 212.65,30.61 212.65,29 213.15,28.5 213.15,28.17 214.25,27.07 214.25,25.82 v2(214.16,25.73)
  BOTTOM w0.076: UH1.AN8 154.55,64.8 v2(154.82,64.52)
  BOTTOM w0.221: v2(214.16,25.73) 214.67,26.25 JDIMM2.125
DDR_B_MA9: length 95.5
  IN3 w0.089: 152.54,50.5 152.54,50.9 152.79,51.15 152.79,59.02 153.03,59.25 153.03,62.74 153.37,63.83 153.56,64.02 153.56,65.82 v2(153.01,66.37)
  IN3 w0.122: v2(212.08,24.24) 212.51,24.67 212.51,27 207.63,31.88 201.78,31.88 200.84,32.81 191.68,32.81 190.71,33.79 173.6,33.79 172.63,34.76 169.85,34.76 168.84,35.77 164.64,35.77 153.07,47.34 153.07,49.28 152.54,49.8 152.54,50.5
  BOTTOM w0.076: v2(153.01,66.37) 152.63,66.75 UH1.AR11
  BOTTOM w0.221: JDIMM2.121 213.67,26.31 213.14,25.78 213.14,25.3 v2(212.08,24.24)
DDR_B_MA10: length 101.3
  IN3 w0.089: 160.86,51.41 160.41,51.86 160.09,51.86 159.34,52.61 159.34,54.41 158.98,54.78 158.98,59.91 158.41,60.48 158.41,61.27 158.54,61.4 158.54,63.73 158.5,63.77 v2(158.5,64.47)
  IN3 w0.122: 160.86,51.41 162,50.27 162,48.89 164.7,46.19 164.87,46.19 165.04,46.37 165.04,46.54 163.73,47.86 163.73,48.03 163.9,48.2 164.07,48.2 169.09,43.18 171.91,43.18 172.8,42.29 195.01,42.29 197.03,40.26 211.72,40.26 220.94,31.04 220.94,27.83 221.2,27.57 221.2,21.75 v2(220.71,21.26)
  BOTTOM w0.076: UH1.AH7 158.37,64.47 v2(158.5,64.47)
  BOTTOM w0.221: JDIMM2.146 221.93,20.57 221.24,21.26 v2(220.71,21.26)
DDR_B_MA11: length 101
  IN3 w0.089: 152.97,50.5 152.97,50.71 153.13,50.87 153.13,59 153.25,59.12 153.25,62.72 153.52,63.74 153.98,64.19 153.98,64.62 154.3,64.95 154.3,66.53 v2(154.85,67.07)
  IN3 w0.122: v2(214.16,21.75) 213.28,22.63 213.28,23.21 213.15,23.34 212.78,23.34 212.65,23.46 212.65,23.62 212.78,23.75 213.15,23.75 213.28,23.87 213.28,26.83 211.73,28.38 211.73,30.32 209.74,32.3 204.73,32.3 203.75,33.28 203.42,33.28 203.3,33.16 203.3,32.5 203.18,32.38 202.93,32.38 202.81,32.5 202.81,33.16 202.69,33.28 191.82,33.28 190.88,34.21 173.78,34.21 172.81,35.19 170.03,35.19 169.02,36.19 164.82,36.19 153.5,47.52 153.5,49.45 152.97,49.98 152.97,50.5
  BOTTOM w0.076: UH1.AN11 154.71,67.07 v2(154.85,67.07)
  BOTTOM w0.221: v2(214.16,21.75) 213.88,21.75 213.43,21.29 JDIMM2.120
DDR_B_MA12: length 96.4
  IN3 w0.089: v2(153.02,65.76) 153.38,65.4 153.38,64.1 153.08,63.8 152.8,62.83 152.8,59.77 152.03,59 152.03,54.56 152.09,54.5 152.09,50.5
  IN3 w0.122: v2(212.08,25.59) 212.08,26.82 207.45,31.45 206.77,31.45 206.65,31.33 206.65,30.68 206.53,30.55 206.29,30.55 206.17,30.68 206.17,31.33 206.04,31.45 205.8,31.45 205.68,31.33 205.68,30.68 205.56,30.55 205.31,30.55 205.19,30.68 205.19,31.33 205.07,31.45 204.82,31.45 204.7,31.33 204.7,30.68 204.58,30.55 204.34,30.55 204.21,30.68 204.21,31.33 204.09,31.45 201.6,31.45 200.67,32.38 191.51,32.38 190.53,33.36 173.43,33.36 172.45,34.33 169.67,34.33 168.66,35.34 164.46,35.34 152.64,47.16 152.64,49.1 152.09,49.65 152.09,50.5
  BOTTOM w0.076: v2(153.02,65.76) 152.68,66.1 UH1.AR10
  BOTTOM w0.221: JDIMM2.119 213.18,26.68 v2(212.08,25.59)
DDR_B_MA13: length 104.9
  IN3 w0.089: v2(160.33,65.77) 159.75,65.19 159.75,64.28 160.15,63.88 160.15,61.16
  IN3 w0.122: 160.15,61.16 161.21,60.1 161.21,56.48 164.44,53.25 164.74,53.25 171.21,46.78 171.21,46.61 171.04,46.43 170.87,46.43 169.45,47.86 169.27,47.86 169.1,47.68 169.1,47.51 170.64,45.97 173.07,45.97 173.37,45.68 195.57,45.68 198.19,43.06 212.88,43.06 223.82,32.12 223.82,30.51 224.15,30.18 224.15,23.01 224.06,22.92 223.58,22.92 223.46,22.8 223.46,22.56 223.58,22.44 224.06,22.44 224.18,22.31 224.18,22.07 224.06,21.95 223.56,21.95 223.43,21.82 223.43,21.61 223.56,21.48 v2(225.02,21.48)
  BOTTOM w0.076: v2(160.33,65.77) 160.01,65.45 UH1.AF9
  BOTTOM w0.221: JDIMM2.158 224.93,20.71 225.02,20.81 v2(225.02,21.48)
DDR_B_PAR: length 96.8
  IN3 w0.089: v2(157.59,64.47) 157.59,64.14 158.19,63.54 158.19,61.55 157.97,61.33 157.97,60.42 158.58,59.8 158.58,54.47 158.83,54.22 158.83,52.19 160.29,50.73 160.29,50.5
  IN3 w0.122: 160.29,50.5 160.29,49.39 167.36,42.33 171.56,42.33 172.57,41.32 194.77,41.32 196.68,39.41 211.37,39.41 220.09,30.69 220.09,24.08 220.21,23.96 220.57,23.96 v2(220.75,24.14)
  BOTTOM w0.076: v2(157.59,64.47) 157.46,64.47 UH1.AJ7
  BOTTOM w0.221: JDIMM2.143 219.19,24.87 219.92,24.14 v2(220.75,24.14)
DDR_B_RAS#: length 102.9
  IN3 w0.089: 160.36,54.79 159.75,54.79 159.43,55.11 159.43,60.54 158.9,61.07 158.9,64 159.04,64.15 159.04,65.33 158.87,65.5 158.87,66.05 v2(158.5,66.42)
  IN3 w0.122: v2(222.65,23.01) 222.05,23.6 222.05,27.93 221.79,28.19 221.79,31.4 212.07,41.12 197.39,41.12 195.36,43.15 173.15,43.15 172.27,44.03 169.45,44.03 160.81,52.66 160.81,52.84 160.99,53.01 161.16,53.01 162.57,51.6 162.74,51.6 162.91,51.77 162.91,51.95 161.47,53.39 161.47,53.98 160.66,54.79 160.36,54.79
  BOTTOM w0.076: v2(158.5,66.42) 158.37,66.42 UH1.AH10
  BOTTOM w0.221: JDIMM2.152 223.43,22.23 v2(222.65,23.01)
DDR_B_WE#: length 98.7
  IN3 w0.089: 159.24,61.11 159.08,61.27 159.08,63.93 159.31,64.15 159.31,65.47 159.05,65.73 159.05,66.53 v2(158.5,67.07)
  IN3 w0.122: 159.24,61.11 160.49,59.86 160.49,55.69 162.06,54.12 162.06,53.79 165.42,50.43 165.42,50.26 165.25,50.09 165.07,50.09 163.74,51.42 163.56,51.42 163.39,51.25 163.39,51.08 170.01,44.46 172.44,44.46 172.74,44.16 189.56,44.16 189.77,43.95 195.16,43.95 197.57,41.54 212.25,41.54 222.3,31.49 222.3,28.39 222.64,28.06 222.64,25.73 v2(222.65,25.71)
  BOTTOM w0.076: UH1.AH11 158.37,67.07 v2(158.5,67.07)
  BOTTOM w0.221: v2(222.65,25.71) 222.64,25.71 223.18,26.25 JDIMM2.151
DDR_CKE0_DIMMA: length 53.2
  IN6 w0.117: v2(149.54,55.45) 149.08,54.99 149.08,50.62 148.96,50.5 148.76,50.5 148.61,50.64 148.61,53.27 148.5,53.39 148.26,53.39 148.15,53.27 148.15,49.6 148.03,49.48 147.86,49.48 147.76,49.59 147.59,49.59 147.43,49.42 147.43,49.26 147.76,48.92 147.76,48.75 147.34,48.33 147.34,46.76 134.77,34.18 134.77,32.75 134.64,32.62 133.96,32.62 133.83,32.5 133.83,32.28 133.96,32.16 134.64,32.16 134.77,32.03 134.77,31.82 134.64,31.69 133.96,31.69 133.83,31.56 133.83,31.34 133.96,31.21 134.16,31.21 134.28,31.08 134.28,30.89 134.16,30.77 133.96,30.77 133.83,30.64 133.83,26.39 133.91,26.32 v2(133.91,25.87)
  BOTTOM w0.076: v2(149.54,55.45) 150.02,55.94 150.02,57.25 151.49,58.71 UH1.AT1
  BOTTOM w0.221: JDIMM1.109 134.37,26.94 133.91,26.47 v2(133.91,25.87)
DDR_CKE1_DIMMA: length 51.6
  IN6 w0.117: v2(133.92,24.54) 133.41,25.05 133.41,32.67 133.78,33.04 134.12,33.04 134.34,33.27 134.34,34.36 146.92,46.93 146.92,49.55 147.72,50.35 147.72,53.46 148.06,53.8 148.06,54.17 148.18,54.28 148.67,54.28 148.79,54.4 148.79,54.63 148.67,54.75 148.18,54.75 148.06,54.87 148.06,55.12 v2(149.51,56.56)
  BOTTOM w0.076: v2(149.51,56.56) 149.51,56.97 151.2,58.66 151.2,60.59 UH1.AT2
  BOTTOM w0.221: v2(133.92,24.54) 133.83,24.54 133.16,23.87 133.16,21.47 133.76,20.87 134.22,20.87 134.62,20.47 JDIMM1.110
DDR_CKE2_DIMMB: length 100.9
  IN3 w0.089: 149.09,59.41 150.32,60.64 150.32,62.94 151.72,64.34 151.94,64.34 v2(152.11,64.51)
  IN3 w0.122: 149.09,59.41 149.09,47.22 164.5,31.82 167.52,31.82 167.65,31.69 167.65,31.44 167.54,31.33 165.67,31.33 165.55,31.21 165.55,30.97 165.67,30.85 173.35,30.85 174.52,29.67 176.84,29.67 177.05,29.46 185.04,29.46 185.38,29.8 189.93,29.8 191.09,28.64 198.04,28.64 199.07,27.6 202.63,27.6 203.05,27.19 204.78,27.19 208.99,22.97 210.21,22.97 v2(210.23,22.95)
  BOTTOM w0.089: v2(152.11,64.51) 151.94,64.51 UH1.AT8
  BOTTOM w0.221: JDIMM2.109 210.67,26.85 209.44,25.61 209.44,23.74 v2(210.23,22.95)
DDR_CKE3_DIMMB: length 99.4
  IN3 w0.089: v2(152.1,66.42) 151.58,65.9 151.58,65.02 150.04,63.49 150.04,60.67 148.64,59.26
  IN3 w0.122: 148.64,59.26 148.64,47.08 165.3,30.42 173.17,30.42 175.46,28.13 178.29,28.13 178.41,28.25 178.41,28.79 178.54,28.92 178.78,28.92 178.9,28.79 178.9,28.25 179.02,28.13 179.27,28.13 179.39,28.25 179.39,28.79 179.51,28.92 179.76,28.92 179.88,28.79 179.88,28.25 180,28.13 197.94,28.13 198.89,27.18 202.45,27.18 202.87,26.76 204.55,26.76 207.41,23.9 207.41,21.94 207.84,21.51 v2(210.23,21.51)
  BOTTOM w0.089: UH1.AT10 151.97,66.42 v2(152.1,66.42)
  BOTTOM w0.221: v2(210.23,21.51) 210.92,20.81 JDIMM2.110
DDR_CS0_DIMMA#: length 54.2
  IN6 w0.089: v2(161.19,62.51) 160.91,62.79 158.91,62.79 158.79,62.66 158.79,51.63 159.92,50.5
  IN6 w0.117: v2(146.47,24.75) 146.74,24.75 146.88,24.61 146.88,23.27 146.96,23.2 147.18,23.2 147.25,23.27 147.25,25.54 148.16,26.45 148.16,31.02 150.12,32.99 150.12,34.24 156.82,40.93 156.82,40.93 158.66,42.78 158.66,44.49 159.92,45.74 159.92,50.5
  BOTTOM w0.076: v2(161.19,62.51) 161.51,62.84 UH1.AD5
  BOTTOM w0.221: v2(146.47,24.75) 146.05,24.75 145.87,24.92 145.87,26.47 146.37,26.97 JDIMM1.149
DDR_CS1_DIMMA#: length 56.3
  IN6 w0.117: v2(159.94,53.66) 160.24,53.66 163.41,50.48 163.41,47.74 163.3,47.62 162.8,47.62 162.69,47.5 162.69,47.27 162.8,47.15 163.3,47.15 163.41,47.04 163.41,44.93 161.52,43.04 161.52,42.87 161.68,42.7 161.85,42.7 163.09,43.95 163.28,43.95 163.41,43.82 163.41,43.6 154.38,34.58 154.38,33.05 153.48,32.15 153.32,32.15 153.22,32.25 153.04,32.25 152.89,32.1 152.89,31.92 152.99,31.82 152.99,31.66 151.76,30.43 151.76,28.5 151.88,28.38 151.98,28.38 152.1,28.26 152.1,28.04 151.98,27.92 151.88,27.92 151.76,27.8 151.76,27.58 151.88,27.46 152.02,27.46 152.14,27.33 152.14,27.12 152.02,26.99 151.88,26.99 151.76,26.87 151.76,26.58 151.24,26.06 151.24,24.63 151.09,24.47 150.87,24.47 150.74,24.6 v2(150.74,24.71)
  BOTTOM w0.076: UH1.AE2 160.76,60.94 160.64,60.94 160.53,60.82 160.53,60.1 160.65,59.99 160.65,59.01 160.52,58.88 160.52,58.25 159.55,57.28 159.55,53.74 159.73,53.56 159.84,53.56 v2(159.94,53.66)
  BOTTOM w0.221: v2(150.74,24.71) 150.51,24.49 150.36,24.49 148.37,26.47 JDIMM1.157
DDR_CS2_DIMMB#: length 102.6
  IN3 w0.089: v2(160.31,66.39) 159.92,66 159.92,65.78 159.53,65.4 159.53,64.23 159.86,63.9 159.86,63.29 159.86,61
  IN3 w0.122: 159.86,61 160.87,59.99 160.87,56.05 168.55,48.37 168.55,48.2 168.38,48.03 168.2,48.03 166.48,49.75 166.31,49.75 166.14,49.57 166.14,49.4 170.33,45.22 172.76,45.22 173.06,44.92 189.92,44.92 190.11,44.73 195.45,44.73 197.88,42.3 212.57,42.3 223.06,31.81 223.06,30.2 223.39,29.87 223.39,25.18 v2(222.65,24.44)
  BOTTOM w0.076: UH1.AF11 159.96,66.75 v2(160.31,66.39)
  BOTTOM w0.221: JDIMM2.149 222.67,26.99 221.77,26.08 221.77,25.09 222.42,24.44 v2(222.65,24.44)
DDR_CS3_DIMMB#: length 100.8
  IN3 w0.122: v2(161.18,63.8) 161.18,63.68 161.58,63.28 161.58,61.56 162.94,60.2 162.94,58.2 169.57,51.56 171.19,51.56 175.47,47.29 196.33,47.29 197.04,46.58 197.63,46.58 200.64,46.58 201.25,45.96 206.56,45.96 206.68,45.84 206.68,45.6 206.56,45.47 203.93,45.47 203.8,45.35 203.8,45.11 203.93,44.99 207.24,44.99 208.21,45.96 212.25,45.96 226.13,32.08 226.13,29.09 225.82,28.78 225.82,28.63 225.93,28.52 226.28,28.52 226.4,28.39 226.4,28.09 226.28,27.96 225.94,27.96 225.82,27.84 225.82,27.6 225.94,27.47 226.28,27.47 226.4,27.35 226.4,27.11 226.28,26.99 225.94,26.99 225.82,26.86 225.82,25.25 v2(226.26,24.81)
  BOTTOM w0.076: v2(161.18,63.8) 161.14,63.8 UH1.AE7
  BOTTOM w0.221: v2(226.26,24.81) 224.67,26.39 JDIMM2.157
DDR_RCOMP0: length 3.9
  BOTTOM w0.305: 174.44,59.75 174.44,60.17 UH1.G1
  BOTTOM w0.381: 174.44,59.75 174.44,59.01 174.78,58.66 174.78,58.65 175.12,58.31 175.12,57.64 174.56,57.08 RH148.2
DDR_RCOMP1: length 2.9
  BOTTOM w0.381: UH1.H1 173.93,59.94 173.93,58.75 174.39,58.3 RH149.2
DDR_RCOMP2: length 6.2
  BOTTOM w0.381: RH150.2 172.68,56.01 173.19,56.52 173.19,57.15 172.92,57.42 v1(172.92,58.2) 172.92,58.25 173.46,58.8 173.46,59.57 173.06,59.99 173.06,60.61 UH1.J2
DDR_VTT_PG_CTRL: length 27.5
  TOP w0.127: 123.75,59.01 123.75,61.93 126.28,64.46 130.23,64.46 130.89,63.81 v5(132.47,63.81) 134.54,65.88
  TOP w0.14: 134.54,65.88 134.54,66.63 v2(135.53,67.62) ; UC1.2 126.08,54.36 126.59,54.86 126.59,56.16 123.75,59.01
  BOTTOM w0.102: v2(135.53,67.62) 136,67.62 136.64,68.26 UH1.BT13
DEBUG_TX: length 8.8
  TOP w0.14: v2(309.88,32.64) v1(307.73,32.64) 305.3,30.2 RE299.1 303.53,30.2 RE298.2
  BOTTOM w0.14: v2(309.88,32.64) 309.5,32.64 309.02,32.16 JDEG1.9
DGPU_HOLD_RST#: length 190.3
  TOP w0.14: v2(226.89,45.02) 226.62,44.75 UV19.1 226.62,43.31 RV580.2 ; v2(133.95,12.34) 133.95,15.34 135.39,16.77 v1(138.47,16.77) 138.99,16.77 v2(139.06,16.71) ; U33.9 205.17,48.58 205.01,48.42 205.01,47.47 205.74,46.74 208.16,46.74 v2(208.61,47.19)
  IN1 w0.099: v2(226.89,45.02) 226.16,45.74 219.56,45.74 219.13,45.32 217.12,45.32 216.92,45.11 213.17,45.11 212.46,45.82 210.9,45.82 209.29,47.43 208.85,47.43 v2(208.61,47.19)
  IN2 w0.089: 101.98,9.07 101.82,9.07 101.14,8.39 101.14,8.12 99.36,6.34 95.96,6.34 95.78,6.15 94.77,6.15 94.55,6.36 94.55,7.19 94.18,7.57 90.72,7.57 90.44,7.29 89.44,7.29 89.28,7.45 v2(89.27,7.45)
  IN2 w0.099: v2(133.95,12.34) 133.51,12.78 123.54,12.78 122.77,13.55 119.01,13.55 118.65,13.91 113.32,13.91 112.41,13.01 111.11,13.01 110.09,11.99 106.91,11.99 106.34,11.42 105.25,11.42 102.89,9.07 101.98,9.07
  IN6 w0.099: v2(226.89,45.02) 225.89,44.02 218.35,44.02 216.76,42.43 201.91,42.43 188.68,29.2 188.68,28.72 186.56,26.61 186.56,21.5 186.46,21.4 186.46,21.4 183.58,18.52 174.45,18.52 172.59,16.66 140.06,16.66 139.93,16.79 139.29,16.79 139.27,16.77 139.13,16.77 v2(139.06,16.71)
  BOTTOM w0.089: v2(89.27,7.45) 89.27,7.45 89.38,7.34 89.48,7.34 89.81,7 UH2.BB20
DGPU_PEX_RST#: length 61.6
  TOP w0.14: v1(203.84,43.05) 202.69,43.05 202.44,42.8 202.06,42.8 201.92,42.94 RV1131.2
  TOP w0.203: v2(206.11,48.88) 206.05,48.82 205.68,48.82 205.57,48.93 U33.10
  TOP w0.381: v2(223.29,43.09) 222.52,43.86 UV29.1
  TOP w0.508: RV1084.1 219.69,43.13 v2(220.14,43.59) ; v2(223.29,43.09) 223.75,42.63 RV587.2 ; v2(202.45,44.45) 202.45,43.8 202.05,43.4 RV1131.2
  BOTTOM w0.508: 202.07,48.41 202.68,47.8 204.4,47.8 205.31,48.72 205.94,48.72 v2(206.11,48.88) ; 202.07,48.41 202.07,44.83 v2(202.45,44.45) 202.45,43.83 203.79,42.5 219.05,42.5 v2(220.14,43.59) 222.8,43.59 v2(223.29,43.09) ; 202.07,48.41 200.17,50.32 198.61,50.32 195.2,53.72 195.2,56.96 194.29,57.87 194.29,58.94 193.87,59.36 193.87,60.07 193.04,60.9 190.16,60.9 189.89,61.17 RV577.1 189.03,61.64 RV589.1
DGPU_PEX_RST#_R: length 13.8
  BOTTOM w0.102: UV18.AJ12 199.11,67.27 199.11,65.01 198.91,64.8 196.88,64.8 196.66,64.58 196.66,62.58 196.4,62.31 194.49,62.31 194.16,61.98
  BOTTOM w0.14: 194.16,61.98 v1(191.92,61.98) 191.14,61.98 RV577.2
DGPU_PWR_EN: length 307.1
  TOP w0.14: v2(264.26,9.55) 264.26,10.05 263.86,10.44 263.86,13.45 265.3,14.89 265.3,17.12 266.18,18 269.38,18 272.05,20.67 272.05,21.57 270.64,22.99 269.62,22.99 268.3,24.31 266.6,24.31 261.18,29.73 261.18,33.85 261.63,34.3 263.43,34.3 265.48,36.35 265.48,39.31 265,39.79 264.91,39.79 264.47,40.23 264.11,40.23 262.18,42.17 262.14,42.17 260.3,44.01 260.3,44.03 259.37,44.96 RH537.1 258.7,45.3 256.87,47.14 255.16,47.14 v1(254.57,47.72) 254.57,48.83 253.36,50.05 252.59,50.05 252.11,50.53 UZ31.1
  IN3 w0.089: 81.82,1.91 82.32,2.41 83.8,2.41 84.06,2.67 86.23,2.67 86.66,3.1 88,3.1 88.85,2.25 89.7,2.25 90.09,2.64 92.79,2.64 93,2.43 95.37,2.43 95.89,1.91 ; 75.06,2.76 76.82,2.76 77.48,2.1 80.41,2.1 80.6,1.91
  IN3 w0.091: 75.06,2.76 74.89,2.76 73.83,1.7 66.55,1.7 65.74,2.51 64.27,2.51 62.67,4.11 62.67,4.49 61.85,5.31 61.85,7.04 62.38,7.57 62.8,7.57 63.89,8.66 63.89,9.46 65.57,11.13 65.57,11.58 65.21,11.93 v2(65.11,11.93) ; v2(263.81,3.77) 263.6,3.98 258.39,3.98 257.73,3.32 252.95,3.32 251.43,4.84 242.69,4.84 240.57,2.72 214.25,2.72 213.38,1.85 207.58,1.85 205.29,4.14 198.59,4.14 198.15,3.7 182.37,3.7 181.81,4.25 177.57,4.25 177.24,3.93 174.31,3.93 173.54,3.16 168.44,3.16 168.14,3.46 161.25,3.46 161.12,3.58 152.74,3.58 150.42,1.25 111.18,1.25 110.5,1.94 110.5,3.03 110.15,3.37 108.01,3.37 106.54,1.9 95.89,1.9 95.89,1.91 ; 81.82,1.91 81.67,1.75 80.75,1.75 80.6,1.91
  IN5 w0.089: 72.31,16.08 72.94,16.08 73.3,15.72 76.19,15.72 76.32,15.85 v2(77.15,15.85)
  IN5 w0.099: 72.31,16.08 71.31,16.08 69.94,14.71 69.94,14.36 68.42,12.84 67.02,12.84 66.04,11.86 65.47,11.86 65.41,11.93 v2(65.11,11.93)
  BOTTOM w0.089: v2(77.15,15.85) 76.87,16.13 76.24,16.13 76.01,15.9 UH2.AD48
  BOTTOM w0.14: v2(263.81,3.77) 263.65,3.92 263.65,7.67 264.26,8.28 v2(264.26,9.55)
DGPU_PWR_EN#: length 3.9
  TOP w0.14: v1(246.84,46.86) RV399.2 246.84,48.06 RV657.2 249.02,48.97 QV3.6
DGPU_PWR_EN#_R: length 5.3
  TOP w0.14: CV499.1 246.8,48.96 RV399.1 247.78,49.9 v1(247.78,49.91) 249.18,49.91 249.75,49.34 QV3.5
DGPU_PWROK: length 260.3
  TOP w0.089: v2(100.66,9.71) 100.47,9.53 v1(100.47,9.17) 100.62,9.02 RH516.2
  TOP w0.14: v2(198.24,45.39) 198.08,45.24 198.08,44.96 198.43,44.62 UV20.2
  TOP w0.203: PR705.1 190.96,116.52 v2(191.27,116.84) 191.4,116.97 PU700.13
  IN2 w0.089: 177.77,84.61 178.44,83.95 179.08,83.95
  IN2 w0.099: v2(194.06,63.11) 188.25,68.91 188.25,74.45 183.31,79.4 183.31,79.71 179.08,83.95 ; v2(191.27,116.84) 189.89,116.84 187.86,118.87 184.02,118.87 182.58,117.43 174.17,117.43 173.23,118.37 172.4,118.37 172.09,118.05 172.09,117.41 171.39,116.71 171.39,113.92 170.44,112.97 170.44,112.27 170.12,111.95 166,111.95 163.84,109.79 163.84,106.8 165.1,105.54 165.1,102.08 164.87,101.86 163.78,101.86 163.09,101.17 162.87,101.17 162.49,100.8 162.49,93.56 166.98,89.08 169.73,89.08 170.71,88.1 170.71,86.53 171.83,85.41 175.07,85.41 176.09,84.39 177.04,84.39 177.29,84.65 177.74,84.65 177.77,84.61
  IN5 w0.089: v6(91.28,10.39) 92.3,10.39 93.22,11.3 94.39,11.3 94.71,10.98 95.56,10.98 96.05,10.48 96.67,10.48 97.15,10 99.03,10 99.11,10.08 100.29,10.08 v2(100.66,9.71) 100.94,10 101.98,10
  IN5 w0.099: 101.98,10 103.61,10 104.58,9.02 105.76,9.02 106.66,9.92 107.92,9.92 108.1,10.09 110.06,10.09 110.97,11.01 111.15,11.01 112.12,11.98 115.52,11.98 116.1,12.56 117.59,12.56 118.28,11.87 121.17,11.87 122.65,13.34 131.83,13.34 132.8,14.31 144.02,14.31 144.93,15.22 164.33,15.22 164.8,14.76 176.94,14.76 181.35,19.17 181.69,19.17 v2(182.73,20.21)
  IN6 w0.099: v2(182.73,20.21) 183.05,20.53 183.05,22.35 183.92,23.22 183.92,26.46 185.09,27.62 185.09,29.29 196.99,41.18 196.99,44.14 v2(198.24,45.39) 198.24,45.46 197.97,45.72 196.55,45.72 194.67,47.6 194.67,55.28 193.79,56.16 193.79,62.73 194.06,62.99 v2(194.06,63.11)
  BOTTOM w0.089: UH2.AV16 91.91,10.15 91.66,10.39 v6(91.28,10.39)
DH1_NVVDD: length 17.7
  TOP w0.14: v2(165.62,115.02) 165.62,114.33 v1(165.9,114.05)
  IN4 w0.762: 172.92,101.75 172.92,103.17 170.17,105.93 170.17,109.72 168.23,111.65 166.09,111.65 165.12,112.63 165.12,113.85 165.12,113.86
  vias: v2(165.17,114.61) v2(174.17,102.01) v2(174.17,101.35)
DH1_NVVDDS: length 4.9
  TOP w0.14: v2(192.63,109.65) v1(192.63,109.14)
  IN4 w0.762: 191.59,108.99 190.98,108.99 189.74,110.23 189.74,112.27
  vias: v2(189.61,113.92) v2(189.61,113.29) v2(192.05,109.65)
DH2_NVVDD: length 7.7
  TOP w0.14: v2(173.58,107.16) v1(173.08,107.16)
  IN4 w0.762: 172.92,107.54 172.09,108.38 172.09,113.66 171.56,114.18
  vias: v2(170.48,115.03) v2(170.96,114.64) v2(174.22,107.16)
DH_1.2V: length 14.8
  IN6 w1.016: 284.67,29.85 282.67,29.85 280.95,31.56 276.7,31.56 275.49,32.77 271.09,32.77
  vias: v2(270.75,34.57) v2(270.75,33.97) v2(285.31,29.08) v2(285.75,29.53)
DIMM_CHA_SA0: length 3.9
  TOP w0.254: v2(172.21,18.42) 172.25,18.45 RD28.1 RD1.2
  BOTTOM w0.254: v2(172.21,18.42) 172.85,18.42 173.12,18.69 JDIMM1.256
DIMM_CHA_SA1: length 8.6
  TOP w0.254: v2(174.25,21.58) 174.51,21.58 176.12,23.19 RD29.1 176.12,25.34 v1(175.62,25.85) 174.7,25.85 RD2.2
  BOTTOM w0.254: JDIMM1.260 174.12,21.45 v2(174.25,21.58)
DIMM_CHA_SA2: length 3.5
  TOP w0.14: v2(150.87,18.37) 150.87,18.33 150.57,18.04 v1(150.57,17.95)
  TOP w0.254: RD3.2 150.92,18.31 v2(150.87,18.37) 150.87,18.82 RD30.1
  BOTTOM w0.254: v2(150.87,18.37) 150.63,18.61 JDIMM1.166
DIMM_CHB_SA0: length 6.1
  TOP w0.14: RD38.1 247.48,19.31 247.48,19.13 v1(246.97,18.62)
  TOP w0.254: RD4.2 248.39,20.22 RD38.1 247.96,19.3 247.96,18.62 v2(248.11,18.48)
  BOTTOM w0.254: JDIMM2.256 249.42,18.85 249.05,18.48 v2(248.11,18.48)
DIMM_CHB_SA1: length 3.9
  TOP w0.254: v2(250.89,18.29) 250.89,18.26 250.17,17.54 RD5.2 249.72,17.53 RD39.1
  BOTTOM w0.254: v2(250.89,18.29) 250.89,18.54 250.42,19.01 JDIMM2.260
DIMM_CHB_SA2: length 4.2
  TOP w0.14: RD6.2 v1(227.38,15.65)
  TOP w0.254: v2(227.16,18.36) 227.38,18.14 RD40.1 RD6.2
  BOTTOM w0.254: v2(227.16,18.36) 227.16,18.36 226.93,18.6 JDIMM2.166
DISPOFF#: length 16.5
  TOP w0.14: v2(48.53,30.79) 48.98,31.24 49.35,31.24 v1(49.53,31.42) 51.1,32.99 51.1,34.41 51.46,34.78 55.26,34.78 55.61,34.43 55.61,34.41 v2(55.78,34.24)
  BOTTOM w0.14: JEDP1.24 56.23,35.16 55.78,34.71 v2(55.78,34.24) ; v2(48.53,30.79) 48.53,30.39 47.7,29.56 RV107.1 47.7,27.54 DV1.1
DL1_NVVDD: length 0.6
  TOP w0.14: v1(166.7,112.35) 167.1,112.74 v2(167.1,112.74)
  vias: v2(166.63,98.2) v2(166.8,98.76) v2(167.56,113.15)
DL1_NVVDDS: length 4.8
  TOP w0.14: v2(190.95,110.1) v2(190.95,110.73) v1(190.95,111.51)
  IN1 w0.762: 191.43,111.66 192.12,112.35 192.12,114.81
  vias: v2(191.64,115.72) v2(192.28,115.7)
DL2_NVVDD: length 8.3
  TOP w0.14: v1(168.2,113.72) 168.65,113.27 v2(168.66,113.27)
  IN4 w0.762: 168.55,114.03 168.55,114.27 170.21,115.92 171.9,115.92 172.95,116.97 174.02,116.97 174.58,117.53
  vias: v2(169.01,112.75) v2(174.84,118.4) v2(175.41,118.4) v2(181.64,118.61) v2(182.09,119.05)
DL_1.2V: length 12.4
  TOP w0.14: v2(286.96,28.26) v1(286.96,28.86)
  IN4 w1.016: 275.78,27.05 277.25,27.05 277.9,27.7 283.31,27.7 284.94,26.07 286.07,26.07 286.43,26.44 286.43,26.45
  vias: v2(274.32,27.12) v2(274.96,27.12) v2(286.45,27.81)
DMI_CRX_PTX_N0: length 125.8
  IN3 w0.099: v2(180.09,55.6) 179.83,55.6 179.68,55.75 179.68,58.78 178.56,59.89 178.56,64.28 177.18,65.66 176.31,65.66 175.96,65.31 175.96,65.11 v2(175.81,64.95)
  BOTTOM w0.076: v2(175.81,64.95) 175.48,64.62 UH1.E8
  BOTTOM w0.089: UH2.C33 83.15,26.28 83.94,27.07 83.94,28.92 84.01,28.99 84.01,29.01
  BOTTOM w0.152: v2(180.09,55.6) 179.81,55.32 179.81,54.58 167.54,42.3 119.15,42.3 109.15,32.3 104.24,32.3 103.28,31.34 98.55,31.34 97.21,32.68 91.86,32.68 89.97,30.79 85.28,30.79 84.01,29.53 84.01,29.01
DMI_CRX_PTX_N1: length 124.6
  IN3 w0.089: 176.99,55.57 176.97,55.59 176.97,55.59 176.88,55.69 176.88,60.65 176.87,60.65 176.87,60.68 175.11,62.44 175.11,63.55 175.34,63.77 175.34,63.98 v2(175.16,64.16)
  IN3 w0.099: v2(180.43,53.19) 180.2,53.42 179.14,53.42 176.99,55.57
  BOTTOM w0.076: v2(175.16,64.16) 174.81,63.82 UH1.F6
  BOTTOM w0.089: UH2.C32 83.96,26.19 84.08,26.19 84.29,26.39 84.29,26.71 84.56,26.99 84.56,28.65 84.83,28.92 84.93,28.92 84.94,28.94
  BOTTOM w0.152: v2(180.43,53.19) 180.29,53.33 179.68,53.33 167.57,41.23 119.22,41.23 109.45,31.46 104.59,31.46 103.69,30.56 98.06,30.56 96.87,31.75 v3(95.7,31.75) 92.08,31.75 90.31,29.99 86,29.99 84.94,28.94
DMI_CRX_PTX_N2: length 126.3
  IN3 w0.099: v2(181.1,54.97) 181.1,54.39 180.9,54.18 179.22,54.18 178.32,55.08 177.42,55.98 177.42,61.54 176.02,62.94 176.02,63.12 v2(175.79,63.35)
  BOTTOM w0.076: UH1.E5 175.48,63.04 v2(175.79,63.35)
  BOTTOM w0.089: UH2.C31 84.65,26.25 84.75,26.25 85,26.5 85,26.67 85.14,26.82 85.14,27.95 86.03,28.84 86.09,28.84 86.16,28.77 86.18,28.77
  BOTTOM w0.152: v2(181.1,54.97) 181.1,54.71 181.81,54 181.81,53.14 181.33,52.66 181.1,52.66 180.76,52.33 179.79,52.33 167.69,40.22 119.53,40.22 109.98,30.67 104.92,30.67 104.02,29.77 97.68,29.77 96.53,30.93 v3(92.7,30.93) 92.39,30.93 90.63,29.16 88.65,29.16 88.25,28.77 86.18,28.77
DMI_CRX_PTX_N3: length 130.7
  IN3 w0.099: v2(182.32,52.17) 182.32,52.87 182.1,53.09 181.45,53.09 180.97,52.62 179.37,52.62 176.21,55.78 176.21,55.88 176.2,56.55 174.82,57.94 174.82,60.06 175.27,60.52 175.27,61.48 174.51,62.23 174.51,65.2 174.17,65.55 173.99,65.55 173.86,65.68 v2(173.86,65.74)
  BOTTOM w0.076: UH1.J9 173.68,65.74 v2(173.86,65.74)
  BOTTOM w0.089: 86.89,27.53 86.87,27.53 86.8,27.6 86.6,27.6 85.84,26.83 85.84,26.54 85.59,26.29 85.43,26.29 UH2.C29
  BOTTOM w0.152: 86.89,27.53 88.62,27.53 89.1,28.01 90.62,28.01 92.72,30.11 96.22,30.11 97.35,28.98 104.35,28.98 105.24,29.88 110.33,29.88 111.69,31.24 117.71,37.26 118.91,37.26 120.36,35.82 164.4,35.82 v3(177.67,49.09) 179.95,51.37 181.93,51.37 182.26,51.71 182.26,52.11 v2(182.32,52.17)
DMI_CRX_PTX_P0: length 125.8
  IN3 w0.099: v2(176.46,64.95) 176.27,64.95 176.15,65.07 176.15,65.23 176.39,65.47 177.11,65.47 178.37,64.2 178.37,59.82 179.49,58.7 179.49,55.61 179.93,55.18 179.93,54.97 179.8,54.84 179.45,54.84 179.33,54.97 v2(179.33,55.12)
  BOTTOM w0.076: UH1.D8 176.38,64.55 176.46,64.63 v2(176.46,64.95)
  BOTTOM w0.089: 83.68,29.01 83.68,28.99 83.75,28.92 83.75,27.15 83.32,26.72 UH2.B33
  BOTTOM w0.152: 83.68,29.01 83.68,29.66 85.14,31.12 89.84,31.12 91.72,33.01 97.35,33.01 98.68,31.68 103.15,31.68 104.11,32.63 109.01,32.63 119.01,42.63 167.4,42.63 179.48,54.71 179.48,54.97 v2(179.33,55.12)
