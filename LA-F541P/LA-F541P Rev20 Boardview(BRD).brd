# Allegro board LA-F541P Rev20 Boardview(BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ESPI_IO3: length 246.7
  TOP w0.14: v2(115.56,8.83) 115.56,9.32 v1(115.21,9.66) 114.84,10.03 114.3,10.03 ; v2(302.56,13.37) UE3.L5
  IN1 w0.076: v2(302.56,13.37) 302.97,12.96 302.97,11.3
  IN1 w0.099: v2(115.56,8.83) 115.97,8.42 116.5,8.42 117.86,9.79 124.38,9.79 125.7,11.11 128.34,11.11 129.32,10.13 131.8,10.13 132.53,9.41 135.67,9.41 136.67,8.4 138.65,8.4 139.01,8.77 145.32,8.77 146.87,7.22 150.59,7.22 152.21,5.59 170.13,5.59 170.37,5.35 177.16,5.35 178.06,6.24 178.78,6.24 179.3,5.72 187.35,5.72 187.96,5.12 204.34,5.12 206.94,7.72 209.67,7.72 214.34,3.05 232.79,3.05 233.75,4.01 234.1,4.01 234.27,3.84 234.27,3.3 234.37,3.2 234.57,3.2 234.67,3.3 234.67,3.84 234.77,3.94 234.97,3.94 235.07,3.84 235.07,3.33 235.17,3.23 235.36,3.23 235.46,3.33 235.46,3.84 235.56,3.94 235.76,3.94 235.86,3.84 235.86,3.28 235.96,3.18 236.16,3.18 236.26,3.28 236.26,3.84 236.35,3.94 236.55,3.94 236.65,3.84 236.65,3.28 236.75,3.18 236.95,3.18 237.05,3.28 237.05,3.84 237.15,3.94 237.34,3.94 237.44,3.84 237.44,3.22 237.54,3.13 237.74,3.13 237.84,3.22 237.84,3.84 237.94,3.94 238.14,3.94 238.24,3.84 238.24,3.22 238.34,3.13 238.53,3.13 238.63,3.22 238.63,3.84 238.73,3.94 238.93,3.94 239.03,3.84 239.03,3.22 239.13,3.13 239.33,3.13 239.42,3.22 239.42,3.84 239.52,3.94 240.18,3.94 242.45,6.2 242.59,6.2 242.73,6.06 242.73,5.92 240.64,3.83 240.64,3.69 240.78,3.55 240.92,3.55 244.67,7.31 250.52,7.31 252.02,5.81 252.4,5.81 252.51,5.69 262.41,5.69 263.4,6.69 267.15,6.69 267.48,6.36 273.06,6.36 273.18,6.48 286.65,6.48 287.56,5.56 291.36,5.56 291.92,6.12 292.84,6.12 293.55,6.83 295.1,6.83 295.36,7.09 296.81,7.09 297.04,7.32 297.88,7.32 299.55,8.99 301.12,8.99 301.52,9.4 301.52,9.79 302.97,11.24 302.97,11.3
  BOTTOM w0.14: JLPDE1.6 297.06,31.41 297.62,30.85 301.28,30.85 301.77,30.37 301.77,28.37 301.33,27.94 301.33,26.89 300.15,25.7 300.15,23.91 302.56,21.51 302.56,20.56 303.15,19.96 303.15,15.79 302.96,15.6 302.96,13.77 v2(302.56,13.37)
ESPI_IO3_R: length 42.3
  TOP w0.14: v1(111.57,10.1) 111.66,10.19 112.76,10.19 v2(113.17,9.78) 113.42,10.03 RC5834.1
  IN1 w0.076: 101.98,9.34 101.2,9.34 101.03,9.17 99.16,9.17 98.77,9.56 98.36,9.56 98.36,9.56 97,9.56 96.38,10.19 95.43,10.19 95.28,10.04 94.98,10.04 94.77,10.25 92.17,10.25 91.67,10.75 90.54,10.75 90.22,10.43 89.59,10.43 88.84,11.17 88.11,11.17 87.38,10.43 87.38,9.12 86.41,8.15 85.31,8.15 84.9,8.56 84.9,9.1 84.6,9.4 83.97,9.4 83.85,9.27 82.88,9.27 82.49,8.88 82.49,8.49 82.39,8.39 82.39,8.16 81.48,7.26 81.02,7.26 80.86,7.41 80.86,7.82 v2(80.52,8.16)
  IN1 w0.099: 101.98,9.34 104.17,9.34 104.38,9.12 105.37,9.12 105.81,9.56 111.8,9.56 112.45,10.21 112.74,10.21 v2(113.17,9.78)
  BOTTOM w0.089: UH2.BA38 80.77,7.91 v2(80.52,8.16)
ESPI_RESET#: length 269.7
  TOP w0.089: v2(84.19,1.91) 84.19,2.54 83.94,2.79 83.94,3.43 83.15,4.22 82.73,4.22 82.39,4.57 82.39,4.85 82.55,5.02 82.55,5.73 RH5839.2 83.05,6.22 RH5838.1
  TOP w0.14: v2(305.96,14) 305.92,14 305.75,14.17 301.76,14.17 UE3.K6 ; v2(84.19,1.91) 84.19,1.56 84.29,1.46 85.54,1.46 v1(85.65,1.35)
  IN3 w0.089: 95.61,1.91 95.61,1.93 95.29,2.25 92.93,2.25 92.71,2.46 90.17,2.46 89.77,2.07 88.78,2.07 87.93,2.92 86.74,2.92 86.23,2.41 84.7,2.41 v2(84.19,1.91)
  IN3 w0.091: 95.61,1.91 95.81,1.71 106.77,1.71 108.24,3.18 110.07,3.18 110.31,2.94 110.31,1.86 111.1,1.06 150.5,1.06 152.83,3.39 161.04,3.39 161.17,3.27 168.06,3.27 168.36,2.96 173.62,2.96 174.39,3.74 177.32,3.74 177.65,4.06 181.73,4.06 183,2.8 197.52,2.8 198.67,3.95 205.21,3.95 207.5,1.66 213.58,1.66 214.45,2.53 240.65,2.53 242.77,4.65 251.35,4.65 252.87,3.13 257.81,3.13 258.47,3.79 263.08,3.79 263.53,3.34 264.01,3.34 264.36,3.7 264.36,4.5 264.76,4.89 266.72,4.89 267.66,3.95 270.19,3.95 270.99,3.14 273.6,3.14 274.2,3.74 279.81,3.74 280.46,3.1 288.77,3.1 289.39,3.72 294.22,3.72 294.69,3.25 301.43,3.25 301.91,3.73 307.06,3.73 307.32,3.48 308,3.48 308.51,3.99 308.51,5.42 308.83,5.74 309.67,5.74 309.74,5.67 310.09,5.67 313.13,8.71 313.13,11.1 312.47,11.76 312.47,13.77 311.29,14.95 306.91,14.95 v2(305.96,14)
ESPI_RESET#_R: length 5.8
  TOP w0.089: v6(81.65,8.12) 81.92,7.85 81.92,6.78 82.32,6.38 RH5839.1
  BOTTOM w0.089: v6(81.65,8.12) 81.72,8.05 81.72,7.57 81.91,7.37 81.91,6.49 81.2,5.78 81.2,5.41 80.98,5.2 UH2.BF38
FB_3V: length 6
  TOP w0.14: v2(347.97,24.05) 347.97,24.08 v1(348.46,24.58)
  TOP w0.203: PU400.4 346.41,21.2 346.84,21.63 346.84,22.33 347.12,22.61 347.83,22.61 PR403.2
  TOP w0.254: PR403.2 PR401.2 347.96,24.04 v2(347.97,24.05)
  BOTTOM w0.254: v2(347.97,24.05) PC401.2
FB_5V: length 4.1
  TOP w0.203: PU400.2 346.53,20.4 346.78,20.15 v2(347.06,20.15) 347.23,20.32 PR404.1
  TOP w0.254: PR404.1 PR402.1
  BOTTOM w0.254: v2(347.06,20.15) 347.23,20.32 PC402.1
FBA_ABI#_H: length 28.5
  TOP w0.102: 212.71,97.42 212.71,98.29 212.73,98.32 212.73,102.6 213.15,103.02 v2(213.15,104.08) ; v2(207.13,81.95) 207.13,83.83 206.88,84.08 206.88,86.26 206.85,86.3 206.85,87.09 206.05,87.9 206.05,89.08 206.76,89.79 206.88,89.79 207.14,90.04
  TOP w0.221: 207.14,90.04 207.14,91.62 v1(210.5,94.98) 212.71,97.19 212.71,97.42
  BOTTOM w0.102: UV18.Y29 206.77,82.48 207,82.48 207.14,82.34 207.14,81.97 v2(207.13,81.95) ; v2(213.15,104.08) 213.23,104.15 213.23,104.65 213.12,104.76 212.86,104.76 212.75,104.66 UV24.J4
FBA_ABI#_L: length 43.3
  TOP w0.102: 210.82,90.04 210.67,90.04 208.09,87.47 208.09,87.16 208.22,87.03 208.22,83.63 207.96,83.38 207.96,81.91 v2(207.56,81.51) ; 226.77,104.25 227.12,104.25 227.63,104.76 227.63,105.03 227.85,105.26 228.17,105.26 228.41,105.02 228.41,104.74 228.65,104.5 229.23,104.5 v2(229.61,104.88)
  TOP w0.221: 226.77,104.25 226.17,104.25 v1(224.27,102.35) 221.98,100.05 221.98,99 221.76,98.78 220.98,98.78 220.74,98.54 220.74,98.1 220.94,97.9 221.76,97.9 221.98,97.67 221.98,97.23 221.76,97.01 221.35,97.01 221.12,96.79 221.12,96.35 221.35,96.13 221.76,96.13 221.98,95.91 221.98,94.76 220.67,93.45 216.4,93.45 215.06,92.11 212.89,92.11 210.82,90.04
  BOTTOM w0.102: UV23.J4 v2(229.61,104.88) ; v2(207.56,81.51) 207.94,81.13 UV18.V28
FBA_CAS#_H: length 32.6
  TOP w0.102: 209.37,90.04 209.37,89.84 207.61,88.09 207.61,86.25 207.14,85.78 207.14,84.4 v2(207.53,84.01) ; 215.98,104.48 215.03,104.48 214.22,105.28 213.55,105.28 v2(213.15,105.68)
  TOP w0.221: 215.98,104.48 215.98,104.48 216.55,104.48 217.8,103.23 v1(217.8,99.7) 217.8,96.85 216.59,95.64 214.27,95.64 209.37,90.73 209.37,90.04
  BOTTOM w0.102: UV24.G3 213.6,106.03 213.6,105.83 213.37,105.6 213.23,105.6 v2(213.15,105.68) ; v2(207.53,84.01) 207.6,84.08 207.77,84.08 208.02,83.83 208.02,83.68 UV18.V31
FBA_CAS#_L: length 40.5
  TOP w0.102: v2(228.79,105.67) 227.95,105.67 227.38,106.24 226.86,106.24 226.77,106.15
  TOP w0.221: 226.77,106.15 226.35,105.73 225.59,105.73 223.56,103.7 222.06,103.7 220.98,102.62 220.98,101.12 218.56,98.7 218.56,97.09 219.53,96.12 219.53,95.08 219.35,94.91 214.99,94.91 v2(213.68,93.6)
  BOTTOM w0.102: UV23.L3 229.2,106.08 v2(228.79,105.67) ; 205.93,88.91 205.93,88.3 206.18,88.05 206.18,87.06 206.12,87 206.12,86.35 205.91,86.14 205.91,85.86 205.93,85.84 205.93,85.36 205.91,85.34 205.91,85.06 205.93,85.04 205.93,84.7 UV18.Y32
  BOTTOM w0.221: v2(213.68,93.6) 210.06,93.6 v1(209.07,92.61) 205.93,89.47 205.93,88.91
FBA_CKE_H: length 29.7
  TOP w0.102: 208.64,89.84 206.93,88.14 v2(206.84,88.14)
  TOP w0.221: RV607.2 213.21,104.88 v2(213.95,104.88) 215.43,103.4 216.39,103.4 217.07,102.72 217.07,97.15 216.29,96.36 213.97,96.36 208.64,91.03 208.64,89.84
  BOTTOM w0.102: UV24.J3 v2(213.95,104.88) ; v2(206.84,88.14) 206.69,87.99 206.69,87.82 206.65,87.78 206.65,86.51 206.66,86.49 206.66,86.36 206.63,86.32 206.63,85.78 206.24,85.39 UV18.Y33
FBA_CKE_L: length 40.4
  TOP w0.102: 211.85,90.04 211.7,89.89 211.21,89.89 v2(209,87.68) ; RV605.2 230.05,103.7 229.11,103.7 228.81,103.99 v2(228.81,104.08) 228.55,104.08 228.14,104.49 227.75,104.49 226.77,103.52
  TOP w0.221: 226.77,103.52 226.47,103.52 v1(222.71,99.75) 222.71,96.8 223.48,96.02 223.48,95.23 220.97,92.72 216.71,92.72 215.37,91.38 213.19,91.38 211.85,90.04
  BOTTOM w0.102: UV18.V33 207.56,85.58 207.56,86.17 207.9,86.52 207.9,86.77 ; UV23.J3 v2(228.81,104.08)
  BOTTOM w0.221: v2(209,87.68) 209.34,87.68 209.62,87.96 209.62,88.84 209.47,89 209.1,89 207.53,87.43 207.53,87.13 207.9,86.77
FBA_CLK0: length 54.5
  TOP w0.102: v2(236.81,104.88) 236.96,104.73 238.26,104.73 RV622.1
  IN1 w0.097: v2(210.75,82.37) 210.41,82.71 209.65,82.71 208.62,83.75 208.62,84.65 208.87,84.91 208.87,86.12 209.86,87.11 209.86,88.84 214.11,93.09 214.94,93.09 220.94,99.09 v2(220.94,108.07)
  IN6 w0.097: 226.77,107.26 226.77,107.25 224.65,107.25 223.08,108.82 221.27,108.82 221.04,108.59 221.04,108.18 v2(220.94,108.07)
  IN6 w0.102: v2(236.81,104.88) 236.67,105.02 236.67,105.24 236.38,105.53 235.77,105.53 235.53,105.29 234.18,105.29 232.03,107.44 231.13,107.44 230.59,106.9 228.58,106.9 228.22,107.26 226.77,107.26
  BOTTOM w0.102: UV23.J12 v2(236.81,104.88)
  BOTTOM w0.114: UV18.R30 210.44,82.68 v2(210.75,82.37)
FBA_CLK0#: length 55.4
  TOP w0.102: v2(236.01,104.88) 236.42,104.47 238.35,104.47 RV621.1
  IN1 w0.097: v2(210.82,83.2) 210.82,82.99 210.72,82.89 209.72,82.89 208.79,83.82 208.79,84.58 209.04,84.84 209.04,86.05 210.03,87.04 210.03,88.77 214.18,92.92 215.01,92.92 221.11,99.02 221.11,107.67 221.34,107.9 221.34,107.93 221.48,108.07 v2(221.52,108.07)
  IN6 w0.097: v2(221.52,108.07) 221.51,108.07 221.22,108.35 221.22,108.53 221.34,108.65 223.01,108.65 224.58,107.08 226.77,107.08 226.77,107.08
  IN6 w0.102: 226.77,107.08 228.14,107.08 228.5,106.72 230.67,106.72 231.21,107.26 231.96,107.26 234.11,105.11 235.6,105.11 235.84,105.35 236.31,105.35 236.46,105.2 236.46,105.06 236.43,105.03 236.43,104.87 236.36,104.8 236.09,104.8 v2(236.01,104.88)
  BOTTOM w0.114: UV18.R31 210.44,83.59 v2(210.82,83.2) ; UV23.J11 v2(236.01,104.88)
FBA_CLK1: length 43.3
  TOP w0.102: v2(206.73,104.11) 206.63,104.21 205.67,104.21 205.61,104.27 RV627.1
  IN1 w0.097: v2(204.16,84) 204.04,83.88 204.04,83.74 204.16,83.62 204.37,83.62 206.31,85.56 206.31,86.62 208.81,89.12 208.81,89.72 213.52,94.43 215.31,94.43 219.39,98.5 219.39,101.35 v2(219.2,101.54)
  IN6 w0.097: v2(206.73,104.11) 206.73,104.26 206.95,104.46 207.02,104.53 210.87,104.53 211.13,104.28 212.16,104.28 213.19,103.25 218.13,103.25 219.43,101.95 219.43,101.73 219.24,101.54 v2(219.2,101.54)
  BOTTOM w0.102: v2(206.73,104.11) 206.69,104.14 206.69,104.14 UV24.J12
  BOTTOM w0.114: v2(204.16,84) 204.56,83.6 UV18.AB31
FBA_CLK1#: length 43.6
  TOP w0.102: RV626.1 205.74,104.47 206.39,104.47 v2(206.76,104.84)
  IN1 w0.097: v2(204.18,83.2) 204.19,83.2 206.49,85.49 206.49,86.54 208.99,89.05 208.99,89.65 213.59,94.25 215.39,94.25 219.57,98.43 219.57,101.32 v2(219.79,101.54)
  IN6 w0.097: v2(206.76,104.84) 206.87,104.71 210.95,104.71 211.2,104.45 212.23,104.45 213.26,103.42 218.2,103.42 219.61,102.02 219.61,101.72 v2(219.79,101.54)
  BOTTOM w0.114: UV24.J11 206.79,104.84 v2(206.76,104.84) ; UV18.AC31 203.78,83.6 v2(204.18,83.2)
FBA_CS#_H: length 29.3
  TOP w0.102: v2(206.75,103.28) 206.23,103.8 204.85,103.8 204.67,103.62 ; v2(205.02,83.19) 204.63,83.58 203.62,83.58 202.89,84.31 202.89,86.67 201.99,87.57 201.33,87.57 200.91,88 200.91,88.55
  TOP w0.221: 204.67,103.62 200.76,99.71 200.76,97.81 201.28,97.29 v1(201.28,93.1) 200.12,91.93 200.12,90.45 200.91,89.66 200.91,88.55
  BOTTOM w0.102: v2(205.02,83.19) 205.42,83.6 UV18.AA31 ; UV24.L12 v2(206.75,103.28)
FBA_CS#_L: length 41.1
  TOP w0.102: v2(209.11,82.38) 209.53,82.81 210.96,82.81 211.27,83.11 ; 233.74,100.61 233.74,100.97 234.84,102.06 235.59,102.06 v2(236.01,102.48)
  TOP w0.119: 215.22,86.42 214.94,86.13 213.26,86.13 212.98,85.85 212.53,85.85 212.12,85.44 212.12,83.91 211.8,83.59 211.5,83.59 211.27,83.36 211.27,83.11
  TOP w0.221: 215.22,86.42 216.43,86.42 216.57,86.28 216.95,86.28 217.12,86.11 221.21,86.11 221.74,85.58 223.53,85.58 v1(225.57,87.62) 233.74,95.79 233.74,100.61
  BOTTOM w0.102: UV18.U30 208.74,82.75 v2(209.11,82.38)
  BOTTOM w0.107: UV23.G12 v2(236.01,102.48)
FBA_D0: length 28
  IN6 w0.102: v2(229.7,97.54) 229.7,97.42 ; 215.66,87.89 215.29,87.52 215.29,86.35 214.82,85.88 214.82,84.67 213.59,83.44 213.59,81.29 v2(214.15,80.73)
  IN6 w0.117: 229.7,97.42 229.7,96.89 228.38,95.58 223.27,95.58 215.66,87.97 215.66,87.89
  BOTTOM w0.102: UV23.A4 230.01,97.86 v2(229.7,97.54) ; v2(214.15,80.73) 214.15,80.77 213.82,81.1 UV18.L28
FBA_D1: length 26.3
  IN6 w0.102: v2(212.51,81.52) 213,82.01 213,83.46 213.73,84.19 213.73,85.66 214.31,86.23 214.31,87.6
  IN6 w0.117: v2(228.1,97.52) 223.73,97.52 214.31,88.1 214.31,87.6
  BOTTOM w0.102: UV18.M29 v2(212.51,81.52) ; v2(228.1,97.52) 228.1,97.76 UV23.A2
FBA_D2: length 28.4
  IN6 w0.102: v2(229.59,98.5) 230.32,97.77 230.32,97.42 ; 216.32,87.89 215.49,87.06 215.49,86.27 215.08,85.85 215.08,84.64 213.8,83.36 213.8,81.89 v2(214.16,81.52)
  IN6 w0.117: 216.32,87.89 223.42,94.98 228.52,94.98 230.32,96.77 230.32,97.42
  BOTTOM w0.102: UV23.B4 229.63,98.5 v2(229.59,98.5) ; UV18.L29 213.74,81.94 v2(214.16,81.52)
FBA_D3: length 28.8
  IN6 w0.102: v2(212.48,80.64) 213.39,81.55 213.39,83.53 214.62,84.76 214.62,85.97 215.09,86.44 215.09,87.84 215.14,87.89 ; 228.58,98.24 v2(228.83,98.48)
  IN6 w0.117: 228.58,98.24 228.58,96.56 228.21,96.19 223.14,96.19 215.14,88.18 215.14,87.89
  BOTTOM w0.102: v2(228.83,98.48) 228.44,98.88 UV23.B2 ; UV18.M28 v2(212.48,80.64)
FBA_D4: length 28.6
  IN6 w0.098: 227.85,100.46 227.71,100.46 227.61,100.56 226.77,100.56
  IN6 w0.102: 227.85,100.46 229.19,100.46 v2(229.61,100.88) ; 212.3,87.64 212.41,87.52 212.41,86.37 212,85.95 212,84.33 v2(211.66,84)
  IN6 w0.117: 212.3,87.64 212.3,88.55 224.3,100.56 226.77,100.56
  BOTTOM w0.102: UV23.E4 v2(229.61,100.88) ; UV18.N31 212.06,83.6 v2(211.66,84)
FBA_D5: length 30.4
  IN6 w0.102: v2(211.66,82.37) 211.66,82.61 211.23,83.04 211.23,84.2 211.21,84.23 211.21,86.81 211.54,87.14 ; 226.79,101.26 228.43,101.26 v2(228.81,100.88)
  IN6 w0.117: 211.54,87.14 211.77,87.38 211.77,88.77 224.26,101.26 226.79,101.26
  BOTTOM w0.102: UV18.P29 v2(211.66,82.37) ; UV23.E2 v2(228.81,100.88)
FBA_D6: length 34.8
  IN6 w0.102: v2(210.84,81.52) 210.22,82.13 210.22,82.83 209.61,83.44 209.61,85.24 209.31,85.55 209.31,85.87 210.72,87.28 210.72,89.2 210.81,89.29 ; v2(229.61,102.48) 229.26,102.83 228.26,102.83 228.23,102.86 226.77,102.86
  IN6 w0.117: 226.77,102.86 224.38,102.86 210.81,89.29
  BOTTOM w0.102: v2(210.84,81.52) 210.44,81.92 UV18.R29 ; v2(229.61,102.48) 229.61,102.48 UV23.F4
FBA_D7: length 32.8
  IN6 w0.102: 210.43,82.99 210.6,82.82 210.98,82.82 211.28,82.52 211.28,81.9 v2(211.66,81.52) ; 210.43,84.29 210.43,86.48 211.28,87.33 211.28,89.02 ; v2(228.81,102.44) 228.43,102.06 227.67,102.06
  IN6 w0.117: 211.28,89.02 224.33,102.06 227.67,102.06
  IN6 w0.119: 210.43,84.29 210.43,82.99
  BOTTOM w0.102: v2(228.81,102.44) 228.78,102.44 UV23.F2 ; UV18.P28 v2(211.66,81.52)
FBA_D8: length 31
  IN6 w0.102: 215.44,84.16 215.44,82.27 215.16,81.99 215.16,80.84 v2(215.03,80.7) ; 233.33,97.68 235.12,97.68 v2(235.21,97.76)
  IN6 w0.117: 215.44,84.16 215.67,84.39 215.67,85.6 216.09,86.02 216.09,86.34 216.97,87.22 217.36,87.22 217.67,87.54 217.67,87.54 221.56,91.43 226.66,91.43 232.91,97.68 233.33,97.68
  BOTTOM w0.102: UV23.A11 235.3,97.76 v2(235.21,97.76) ; v2(215.03,80.7) 215.42,81.1 UV18.J28
FBA_D9: length 29.9
  IN6 w0.102: v2(216.63,82.37) 216.63,84.23 217.94,85.55 217.94,86.32 218.06,86.44 ; v2(236.81,98.48) 236.81,97.81 236.42,97.42
  IN6 w0.117: 236.42,97.42 235.72,96.72 233.87,96.72 226.33,89.19 220.8,89.19 218.82,87.21 218.82,87.2 218.06,86.44
  BOTTOM w0.102: v2(216.63,82.37) 216.63,82.34 UV18.H29
  BOTTOM w0.107: UV23.A13 v2(236.81,98.48)
FBA_D10: length 31
  IN6 w0.102: 235.62,97.42 235.62,98.08 v2(236.01,98.48) ; v2(215.79,81.52) 216.25,81.99 216.25,85.85 216.6,86.19 217.03,86.19 217.43,86.6
  IN6 w0.117: 235.62,97.42 235.44,97.24 233.22,97.24 226.88,90.9 221.78,90.9 218.3,87.43 218.3,87.42 217.47,86.6 217.43,86.6
  BOTTOM w0.102: UV18.J29 215.44,81.88 v2(215.79,81.52)
  BOTTOM w0.107: UV23.B11 v2(236.01,98.48)
FBA_D11: length 34.4
  IN6 w0.102: 237.36,97.62 237.36,98.55 237.02,98.9 236.66,98.9 236.43,99.12 236.43,99.43 236.66,99.66 237.02,99.66 237.4,99.28 v2(237.61,99.28) ; v2(216.66,81.52) 216.66,81.86 217.01,82.21 217.01,82.87 216.93,82.96 216.93,84.24 217.68,84.99 218.24,84.99 219.35,86.09 219.35,86.12
  IN6 w0.117: 219.35,86.12 219.35,86.99 221.02,88.66 226.55,88.66 234.08,96.2 235.94,96.2 237.36,97.62
  BOTTOM w0.102: UV18.H28 v2(216.66,81.52)
  BOTTOM w0.107: UV23.B13 v2(237.61,99.28)
FBA_D12: length 36.9
  IN6 w0.102: v2(217.66,82.36) 217.96,82.66 217.96,84.16 218.18,84.38 218.58,84.38 219.68,85.48 220.12,85.48 220.66,86.02 221.26,86.02 221.49,85.79 222.07,85.79 222.17,85.89 ; v2(235.21,100.88) 235.63,100.46 238,100.46
  IN6 w0.117: 222.17,85.89 222.26,85.98 222.26,86.14 223.06,86.95 227.05,86.95 234.73,94.63 236.66,94.63 239.23,97.2 239.23,99.29 238.37,100.14 238.32,100.14 238,100.46
  BOTTOM w0.102: UV18.G29 217.09,81.95 217.5,82.36 v2(217.66,82.36)
  BOTTOM w0.107: UV23.E11 v2(235.21,100.88)
FBA_D13: length 33.7
  IN6 w0.098: 222.55,85.26 222.29,85.26
  IN6 w0.102: v2(218.34,84) 218.49,84 219.77,85.28 220.17,85.28 220.19,85.26 222.29,85.26 ; 238.84,100.66 238.7,100.52 238.23,100.52 237.88,100.88 v2(237.61,100.88) ; 222.67,85.38 222.55,85.26
  IN6 w0.117: 238.84,100.66 239.33,100.66 239.75,100.24 239.75,96.98 236.87,94.11 234.95,94.11 227.27,86.42 223.99,86.42 222.95,85.38 222.67,85.38
  BOTTOM w0.102: v2(218.34,84) UV18.E31
  BOTTOM w0.107: UV23.E13 v2(237.61,100.88)
FBA_D14: length 39.8
  IN6 w0.102: 223.9,84.86 223.31,84.27 222.22,84.27 221.47,83.51 220.69,83.51 220.44,83.76 220.44,84.06 220.22,84.29 219.6,84.29 v2(219.2,83.89) ; 238.75,102.07 236.41,102.07 v2(236.01,101.68)
  IN6 w0.117: 223.9,84.86 224.42,85.38 227.7,85.38 235.38,93.06 238.09,93.06 241.62,96.58 241.62,99.97 239.52,102.07 238.75,102.07
  BOTTOM w0.102: v2(219.2,83.89) 219.2,83.96 218.76,84.4 UV18.E32
  BOTTOM w0.107: UV23.F11 v2(236.01,101.68)
FBA_D15: length 37.9
  IN6 w0.102: v2(236.81,101.68) 237.19,101.3 238.64,101.3 238.71,101.37 ; 223.27,84.96 222.77,84.47 222.14,84.47 222.08,84.42 220.37,84.42 220.3,84.49 219.27,84.49 218.82,84.04 218.82,83.68 v2(218.34,83.2)
  IN6 w0.117: 223.27,84.96 224.2,85.9 227.48,85.9 235.17,93.58 237.88,93.58 241.1,96.8 241.1,99.75 239.48,101.37 238.71,101.37
  BOTTOM w0.102: UV18.F30 v2(218.34,83.2)
  BOTTOM w0.107: UV23.F13 v2(236.81,101.68)
FBA_D16: length 43.4
  IN1 w0.102: 225.43,87.44 223.28,87.44 222.01,86.17 v2(221.81,86.17) ; v2(235.88,111.3) 235.57,111.3 234.83,110.56 234.83,109.52 235.06,109.3 238.44,109.3 238.84,108.9
  IN1 w0.117: 238.84,108.9 240.05,107.69 240.05,97.89 237.92,95.77 235.49,95.77 227.16,87.44 225.43,87.44
  BOTTOM w0.102: v2(235.88,111.3) 235.88,111.15 UV23.U11 ; v2(221.81,86.17) 221.62,86.36 221.04,86.36 220.68,86 UV18.C34
FBA_D17: length 43.5
  IN1 w0.102: v2(220.01,84.89) 220.36,85.24 221.8,85.24 222,85.45 224.1,85.45 225.04,86.39 225.43,86.39
  IN1 w0.117: 225.43,86.39 227.64,86.39 235.97,94.72 238.36,94.72 238.85,95.22 239.51,95.22 240.85,96.56 241.1,96.93 241.1,97.33 241.09,97.33 241.09,103.33 241.62,103.85 241.62,107.6 239.02,110.21 239.02,110.26 238.8,110.47 v2(237.65,110.47)
  BOTTOM w0.102: v2(220.01,84.89) 220.01,84.89 219.59,84.46 UV18.D32 ; UV23.U13 237.24,110.88 v2(237.65,110.47)
FBA_D18: length 46.4
  IN1 w0.102: v2(235.24,110.43) 235.73,110.92 236.4,110.92 ; v2(221.64,84.8) 222.07,85.23 224.17,85.23 224.81,85.87 225.43,85.87
  IN1 w0.117: 225.43,85.87 227.85,85.87 236.18,94.2 238.57,94.2 239.07,94.69 239.73,94.69 241.26,96.22 241.62,96.77 241.62,97.54 241.62,97.55 241.62,103.11 242.14,103.63 242.14,107.82 240.35,109.61 240.35,110.63 240.11,110.87 239.76,110.87 239.76,110.87 239.14,110.87 239.06,110.96 238.62,110.96 238.53,110.86 237.43,110.86 237.37,110.92 236.4,110.92
  BOTTOM w0.102: v2(235.24,110.43) 235.59,110.08 UV23.T11 ; UV18.B33 v2(221.64,84.8)
FBA_D19: length 41.4
  IN1 w0.098: 224.29,86.91 223.04,85.66 221.93,85.66
  IN1 w0.102: v2(220.81,85.64) 221.19,85.64 221.36,85.47 221.74,85.47 221.93,85.66 ; 224.29,86.91 225.43,86.91 ; v2(236.85,110.43) 237.59,109.7 238.78,109.7 238.84,109.64
  IN1 w0.117: 238.84,109.64 241.09,107.39 241.09,104.07 240.57,103.54 240.57,97.67 238.14,95.24 235.71,95.24 227.38,86.91 225.43,86.91
  BOTTOM w0.102: UV18.C33 220.44,85.26 v2(220.81,85.64) ; v2(236.85,110.43) 236.86,110.43 UV23.T13
FBA_D20: length 42.2
  IN1 w0.102: v2(234.38,108.14) 233.91,107.67 233.91,101.19 234.63,100.46 234.63,98.93 233.74,98.05 233.13,98.05 232.5,97.42 ; 221.83,89.54 220.48,88.19 217.04,88.19 216.28,87.44 216.28,85.52 216.52,85.28 216.88,85.28 218.31,86.71 v2(218.92,86.71)
  IN1 w0.117: 232.5,97.42 232.17,97.09 232.17,96.89 227.31,92.03 224.31,92.03 221.83,89.54
  BOTTOM w0.102: v2(218.92,86.71) 218.62,86.71 218.24,86.33 217.8,86.33 217.61,86.14 217.61,85.86 217.94,85.53 UV18.F33 ; UV23.N11 235.15,108.14 v2(234.38,108.14)
FBA_D21: length 36.7
  IN1 w0.102: v2(217.04,86.75) 217.05,86.75 218.09,87.79 221.01,87.79 221.11,87.69 221.11,87.66 221.33,87.44 221.65,87.44 223.53,89.32 ; v2(236.86,107.25) 236.41,106.81 236.41,99.12 236.16,98.87 235.14,98.87 234.83,98.56 234.83,98.07 234.18,97.42
  IN1 w0.117: 223.53,89.32 223.87,89.66 226.42,89.66 234.18,97.42
  BOTTOM w0.102: v2(217.04,86.75) 217.04,86.3 217.37,85.97 217.37,85.65 217.61,85.42 217.61,84.78 217.94,84.45 UV18.F32 ; v2(236.86,107.25) 237.21,107.61 UV23.N13
FBA_D22: length 34.5
  IN1 w0.102: 221.48,88.38 221.09,87.99 217.12,87.99 216.49,87.36 216.49,86.08 v2(216.75,85.81) ; v2(235.26,106.52) 235.64,106.14 235.64,105.35 234.83,104.54 234.83,99.12 234.84,99.11 234.84,98.85 234.63,98.64 234.63,98.49 233.81,97.67 233.43,97.67 233.18,97.42
  IN1 w0.117: 233.18,97.42 232.98,97.22 232.98,96.96 227.41,91.39 224.49,91.39 221.48,88.38
  BOTTOM w0.102: UV18.H33 216.73,85.69 216.73,85.78 v2(216.75,85.81) ; v2(235.26,106.52) UV23.M11
FBA_D23: length 38.5
  IN1 w0.102: v2(215.84,83.95) 216.47,83.95 217.11,84.58 217.11,84.93 218.33,86.16 218.92,86.16 219.38,86.62 219.38,87.23 219.73,87.58 220.9,87.58 221.25,87.24 221.81,87.24 223.66,89.09 225.43,89.09 ; v2(237.62,107.25) 237.21,106.85 237.21,98.2 236.43,97.42
  IN1 w0.117: 236.43,97.42 236.35,97.34 234.84,97.34 226.59,89.09 225.43,89.09
  BOTTOM w0.102: UV23.M13 237.59,107.25 v2(237.62,107.25) ; v2(215.84,83.95) 216.24,84.35 UV18.H32
FBA_D24: length 39
  IN1 w0.097: 210.63,87.35 210.63,88.64 211.53,89.54
  IN1 w0.102: 210.63,87.35 210.63,85.79 v2(210.82,85.6)
  IN1 w0.117: v2(230.38,111.26) 229.36,111.26 228.79,111.82 226.42,111.82 221.62,107.03 221.62,98.2 215.74,92.32 214.31,92.32 211.53,89.54
  BOTTOM w0.102: v2(210.82,85.6) 211.22,86 UV18.P34
  BOTTOM w0.221: UV23.U4 230.01,110.89 v2(230.38,111.26)
FBA_D25: length 36.1
  IN1 w0.102: 213.75,89.54 213.68,89.54 211.39,87.25 211.39,86.23 211.63,85.99 211.63,84.83 v2(211.59,84.78) ; 226.77,109.83 226.81,109.83 226.91,109.73 228.41,109.73 228.76,110.08 v2(228.76,110.52)
  IN1 w0.117: 213.75,89.54 214.96,90.75 216.39,90.75 224.46,98.81 224.46,107.64 226.64,109.83 226.77,109.83
  BOTTOM w0.102: UV18.P32 211.24,84.43 v2(211.59,84.78) ; v2(228.76,110.52) 228.76,110.53 UV23.U2
FBA_D26: length 39.9
  IN1 w0.098: 211.19,87.34 211.19,87.72 213.01,89.54
  IN1 w0.102: 226.77,110.5 227.27,110.5 227.77,110 228.04,110 228.1,110.05 228.13,110.05 228.35,110.27 228.35,110.64 228.61,110.9 228.92,110.9 228.97,110.86 229.94,110.86 v2(230.37,110.43) ; 211.19,87.34 211.19,86.18 211.19,86.18 211.19,86.15 211.43,85.91 211.43,85.26 211.2,85.03 211.2,84.39 v2(210.85,84.04)
  IN1 w0.117: 226.77,110.5 226.57,110.5 223.71,107.63 223.71,107.61 223.47,107.37 223.47,106.88 223.45,106.86 223.45,98.54 216.18,91.27 214.74,91.27 213.01,89.54
  BOTTOM w0.102: UV18.P31 211.24,83.66 v2(210.85,84.04)
  BOTTOM w0.221: v2(230.37,110.43) 230.02,110.08 UV23.T4
FBA_D27: length 37
  IN1 w0.097: 212.27,89.54 210.99,88.26 210.99,87.42
  IN1 w0.102: 210.99,87.42 210.99,86.1 210.99,86.1 210.99,86.06 211.23,85.82 211.23,85.34 210.81,84.93 v2(210.81,84.79) ; 226.77,111.17 226.9,111.29 227.24,111.29 227.48,111.05 227.48,110.92 v2(227.97,110.43)
  IN1 w0.117: 212.27,89.54 214.52,91.79 215.96,91.79 222.15,97.98 222.15,106.3 222.94,107.1 222.94,107.6 226.51,111.17 226.77,111.17
  BOTTOM w0.102: UV18.P33 210.83,84.79 v2(210.81,84.79) ; v2(227.97,110.43) 228.06,110.43 UV23.T2
FBA_D28: length 38
  IN1 w0.098: 217.41,89.54 217.36,89.49
  IN1 w0.102: v2(230.37,107.33) 230.1,107.33 229.99,107.43 229.99,107.44 229.73,107.7 227.63,107.7 227.24,107.31 226.89,107.31 226.84,107.37 226.77,107.37 ; v2(212.54,83.25) 212.97,83.69 212.97,85.13 212.71,85.39 212.71,85.67 212.45,85.94 212.45,86.96 212.58,87.09 212.58,87.4 213.31,88.12 214.11,88.12 215.48,89.49 217.36,89.49
  IN1 w0.117: 226.77,107.37 226.49,107.37 226.02,106.9 226.02,98.16 217.41,89.54
  BOTTOM w0.102: v2(230.37,107.33) 230.36,107.33 UV23.N4 ; UV18.L31 213.65,83.6 213.3,83.25 v2(212.54,83.25)
FBA_D29: length 37.9
  IN1 w0.102: 230.17,97.42 230.95,98.19 230.95,104.59 231.84,105.47 231.84,106.97 231.05,107.76 230.19,107.76 230,107.95 229.64,107.95 v2(228.81,108.79) ; v2(213.23,86.63) 213.23,87.19 213.55,87.5 214.41,87.5 215.74,88.84 218.93,88.84 219.63,89.54
  IN1 w0.117: 219.63,89.54 226.43,96.34 229.1,96.34 230.17,97.42
  BOTTOM w0.102: UV23.N2 228.41,107.89 228.79,108.27 228.79,108.78 v2(228.81,108.79) ; v2(213.23,86.63) 213.28,86.63 213.74,86.18 UV18.L34
FBA_D30: length 37.1
  IN1 w0.098: 218.14,89.54 217.88,89.29
  IN1 w0.102: 217.88,89.29 215.56,89.29 214.19,87.92 213.39,87.92 212.78,87.31 212.78,87.01 212.65,86.87 212.65,86.02 212.92,85.76 212.92,85.47 213.35,85.03 v2(213.35,84.77) ; v2(231.29,106.3) 230.69,106.9 229.77,106.9 229.77,106.9 229.45,106.9 229.42,106.94 228.7,106.94 228.55,107.08 226.91,107.08 226.8,106.98 226.8,106.87 226.77,106.84
  IN1 w0.117: 226.77,106.84 226.55,106.62 226.55,97.94 218.15,89.54 218.14,89.54
  BOTTOM w0.102: UV18.L32 213.36,84.77 v2(213.35,84.77) ; UV23.M4 230.4,106.49 231.08,106.49 231.27,106.3 v2(231.29,106.3)
FBA_D31: length 32.7
  IN1 w0.098: 226.77,97.43 226.83,97.48
  IN1 w0.102: 226.83,97.48 226.83,105.25 226.99,105.41 227.48,105.41 227.59,105.51 227.59,106.24 v2(227.14,106.68) ; 218.89,89.54 218.43,89.08 215.65,89.08 214.27,87.71 213.47,87.71 212.99,87.23 212.99,86.92 212.85,86.79 212.85,86.11 213.31,85.65 v2(213.31,85.63)
  IN1 w0.117: 218.89,89.54 226.77,97.43
  BOTTOM w0.102: v2(227.14,106.68) 227.08,106.74 227.08,106.94 227.39,107.25 227.71,107.25 227.84,107.38 228.22,107.38 228.41,107.19 UV23.M2 ; v2(213.31,85.63) UV18.L33
FBA_D32: length 24
  IN6 w0.102: 210.8,97.42 211.48,98.1 212.51,98.1 212.89,98.48 v2(213.15,98.48) ; 203.1,89.29 202.86,89.05 202.86,85.96 200.9,84 v2(200.9,82.36)
  IN6 w0.117: 210.8,97.42 203.1,89.72 203.1,89.29
  BOTTOM w0.102: v2(200.9,82.36) 200.9,82.35 200.87,82.31 200.87,81.53 UV18.AG28 ; v2(213.15,98.48) UV24.U4
FBA_D33: length 22.4
  IN6 w0.102: 204.09,89.09 203.26,88.27 203.26,85.6 202.06,84.4 202.06,82.78 v2(201.66,82.37)
  IN6 w0.117: 204.09,89.09 204.09,89.23 212.02,97.16 213.43,97.16 v2(213.95,97.68)
  BOTTOM w0.102: UV24.U2 v2(213.95,97.68) ; UV18.AF29 v2(201.66,82.37)
FBA_D34: length 24.1
  IN6 w0.102: v2(212.35,98.48) 211.12,98.48 210.99,98.35 ; 202.57,89.29 202.57,85.96 200.39,83.77 200.39,81.97 v2(199.94,81.52)
  IN6 w0.117: 202.57,89.29 202.57,89.93 210.99,98.35
  BOTTOM w0.102: UV18.AG29 200.37,81.95 v2(199.94,81.52) ; UV24.T4 v2(212.35,98.48)
FBA_D35: length 24.4
  IN6 w0.102: v2(213.95,98.48) 213.5,98.02 212.96,98.02 212.41,97.47 211.59,97.47 ; v2(201.66,81.52) 201.28,81.9 201.28,82.82 201.2,82.9 201.2,84.01 203.06,85.87 203.06,88.71 203.42,89.07
  IN6 w0.117: 211.59,97.47 203.62,89.5 203.62,89.27 203.42,89.07
  BOTTOM w0.102: UV24.T2 v2(213.95,98.48) ; UV18.AF28 v2(201.66,81.52)
FBA_D36: length 29
  IN6 w0.102: v2(213.15,101.68) 213.15,101.55 213.57,101.14 213.57,100.72 213.8,100.5 215.09,100.5 215.66,99.93 215.66,97.42 ; 207.4,89.29 207.4,87.7 204.9,85.2 204.04,85.2 203.51,84.66 203.51,84.12 202.83,83.44 202.83,82.71 v2(202.51,82.39)
  IN6 w0.117: 215.66,97.42 215.66,97.16 214.08,95.59 212.67,95.59 207.4,90.32 207.4,89.29
  BOTTOM w0.102: v2(213.15,101.68) UV24.N4 ; v2(202.51,82.39) 202.53,82.39 UV18.AD30
FBA_D37: length 31
  IN6 w0.102: v2(202.38,81.79) 202.62,81.55 203.02,81.55 203.72,82.25 203.72,82.51 203.98,82.77 204.32,82.77 204.6,83.04 204.6,83.32 206.49,85.21 206.52,85.21 208.09,86.78 208.09,87.71 208.45,88.06 208.45,89.29 ; 215.98,100.99 214.89,102.08 214.35,102.08 v2(213.95,101.68)
  IN6 w0.117: 215.98,100.99 216.7,100.26 216.7,96.73 214.52,94.54 213.1,94.54 208.45,89.89 208.45,89.29
  BOTTOM w0.102: UV24.N2 v2(213.95,101.68) ; UV18.AD29 202.78,81.79 v2(202.38,81.79)
FBA_D38: length 30.1
  IN6 w0.102: 214.88,101.3 213.8,101.3 213.55,101.54 213.55,102.08 v2(213.15,102.48) ; 207.92,88.06 207.82,87.96 207.82,86.81 206.57,85.55 206.45,85.55 205.3,84.39 204.02,84.39 203.73,84.11 203.73,82.81 203.32,82.39 v2(203.32,82.38)
  IN6 w0.117: 207.92,88.06 207.92,90.1 212.88,95.06 214.3,95.06 216.18,96.94 216.18,100 214.88,101.3
  BOTTOM w0.102: v2(213.15,102.48) UV24.M4
  BOTTOM w0.127: v2(203.32,82.38) 203.74,81.96 UV18.AC29
FBA_D39: length 32
  IN6 w0.102: 215.23,102.48 v2(214.75,102.48) ; 202.51,80.65 203.04,80.65 204.6,82.21 204.6,82.5 204.91,82.81 205.19,82.81 206.41,84.03 206.41,84.26 207.88,85.73 208.31,85.73 209.7,87.12 209.7,88.95
  IN6 w0.117: 215.23,102.48 217.23,100.48 217.23,96.51 214.73,94.02 213.32,94.02 209.7,90.4 209.7,88.95 ; v2(202.5,80.65) 202.51,80.65
  BOTTOM w0.102: v2(202.5,80.65) 202.5,80.69 202.91,81.1 UV18.AD28 ; UV24.M2 v2(214.75,102.48)
FBA_D40: length 21.3
  IN6 w0.102: 200.05,89.15 199.25,88.35 199.25,84.09 198.62,83.45 198.62,82.73 v2(198.21,82.32) ; v2(207.55,98.48) 207.44,98.48 206.38,97.42
  IN6 w0.117: 200.05,89.15 200.05,90.95 206.38,97.29 206.38,97.42
  BOTTOM w0.102: v2(198.21,82.32) 198.59,81.95 UV18.AJ29 ; UV24.U11 v2(207.55,98.48)
FBA_D41: length 21.1
  IN6 w0.102: 198.88,89.29 198.63,89.03 198.63,86.48 198.72,86.39 198.72,84.13 198.21,83.62 198.21,83.41 197.44,82.64 v2(197.44,82.3) ; v2(205.95,98.48) 205.95,98.1 205.71,97.85 205.44,97.85
  IN6 w0.117: 205.44,97.85 204.81,97.22 204.81,97.2 198.89,91.28 198.89,89.3 198.88,89.29
  BOTTOM w0.102: UV18.AK29 v2(197.44,82.3) ; UV24.U13 v2(205.95,98.48)
FBA_D42: length 22.3
  IN6 w0.102: v2(199.16,82.37) 198.82,82.72 198.82,83.37 199.54,84.09 199.54,86.43 199.45,86.52 199.45,87.96 200.47,88.98 ; 207.33,97.42 207.93,98.02 207.93,98.9 v2(207.55,99.28)
  IN6 w0.117: 207.33,97.42 207.25,97.42 200.57,90.74 200.57,89.08 200.47,88.98
  BOTTOM w0.102: UV18.AJ30 v2(199.16,82.37) ; UV24.T11 v2(207.55,99.28)
FBA_D43: length 22.9
  IN6 w0.102: 199.45,88.99 199.05,88.6 199.05,84.17 198.41,83.54 198.41,83.18 197.83,82.59 197.83,81.91 v2(198.26,81.47) ; 205.75,97.42 206.36,98.03 206.36,98.87 v2(205.95,99.28)
  IN6 w0.117: 199.45,88.99 199.45,91.1 205.75,97.39 205.75,97.42
  BOTTOM w0.102: UV24.T13 v2(205.95,99.28) ; UV18.AK28 v2(198.26,81.47)
FBA_D44: length 26.5
  IN6 w0.102: 203.99,99.45 204.99,100.46 205.31,100.46 205.57,100.72 205.57,101.03 205.79,101.26 207.13,101.26 v2(207.55,101.68) ; v2(196.62,82.3) 196.26,82.67 196.26,83.35 196.49,83.59 196.83,83.59 197.05,83.81 197.05,89.04 197.01,89.08
  IN6 w0.117: 197.01,89.08 197.01,91.62 203.99,98.6 203.99,99.45
  BOTTOM w0.102: UV18.AM29 196.24,81.91 v2(196.62,82.3) ; UV24.N11 v2(207.55,101.68)
FBA_D45: length 24.2
  IN6 w0.102: v2(195.84,83.15) 195.84,83.32 196.22,83.69 196.22,85.22 196.28,85.28 196.28,88.65 196.49,88.85 ; v2(205.95,101.68) 205.93,101.68 205.53,101.28 205.02,101.28 204.77,101.03 204.77,100.91 203.91,100.06
  IN6 w0.117: 196.49,88.85 196.49,91.84 203.34,98.69 203.34,99.49 203.91,100.06
  BOTTOM w0.102: v2(195.84,83.15) 196.24,83.55 UV18.AM31 ; UV24.N13 v2(205.95,101.68)
FBA_D46: length 29.3
  IN6 w0.098: 194.41,86.77 194.41,84.06
  IN6 w0.102: v2(195.04,82.3) 194.41,82.93 194.41,84.06 ; v2(207.57,102.47) 207.18,102.86 204.71,102.86 203.91,102.06
  IN6 w0.117: 194.41,86.77 194.5,86.87 194.5,87.62 194.48,87.64 194.48,92.15 203.45,101.12 203.45,101.59 203.91,102.06
  BOTTOM w0.102: v2(195.04,82.3) 195.04,82.3 195.44,81.9 UV18.AN29 ; v2(207.57,102.47) 207.57,102.44 207.21,102.08 UV24.M11
FBA_D47: length 27.4
  IN6 w0.102: v2(205.95,102.48) 205.53,102.06 204.65,102.06 203.91,101.32 203.91,100.85 ; v2(195.84,82.27) 195.37,82.74 194.88,82.74 194.62,83 194.62,84.38 196.03,85.79 196.03,88.39
  IN6 w0.117: 203.91,100.85 195.96,92.9 195.96,88.45 196.03,88.39
  BOTTOM w0.102: UV18.AM30 196.24,82.67 v2(195.84,82.27) ; UV24.M13 v2(205.95,102.48)
FBA_D48: length 37.6
  IN1 w0.102: 203.91,111.22 204.21,111.51 ; 205.5,111.51 205.58,111.42 205.82,111.42 v2(206.76,110.49)
  IN1 w0.117: 204.21,111.51 204.34,111.64 205.37,111.64 205.5,111.51 ; v2(195,83.83) 193.04,85.78 193.04,87.75 193.43,88.13 193.43,92.22 197.85,96.65 198.29,96.65 199.22,97.58 199.22,101.69 200.31,102.78 200.31,105.26 201.08,106.03 201.08,108.38 203.91,111.22
  BOTTOM w0.102: v2(195,83.83) 195.16,83.83 UV18.AN31 ; UV24.A11 207.14,110.88 v2(206.76,110.49)
FBA_D49: length 34.4
  IN1 w0.102: v2(205.11,111.25) 205.1,111.25 204.69,111.25 203.91,110.48
  IN1 w0.117: v2(195.78,84.79) 194.78,84.79 193.57,86 193.57,87.53 193.96,87.93 193.96,92.02 198.07,96.12 198.5,96.12 199.85,97.47 199.85,101.58 200.83,102.56 200.83,105.02 201.6,105.79 201.6,108.16 203.91,110.48
  BOTTOM w0.102: UV18.AN32 195.77,84.73 195.77,84.78 v2(195.78,84.79) ; UV24.A13 205.54,110.88 205.17,111.25 v2(205.11,111.25)
FBA_D50: length 40.5
  IN1 w0.102: 207.05,111.51 207.33,111.23 207.33,110.75 v2(207.57,110.5)
  IN1 w0.117: 207.05,111.51 206.39,112.17 204.08,112.17 199.78,107.87 199.78,102.99 198.7,101.9 198.7,97.8 198.07,97.17 197.64,97.17 192.9,92.44 192.9,88.35 192.52,87.96 192.52,85.47 193.97,84.03 v2(193.97,84.01)
  BOTTOM w0.102: v2(207.57,110.5) UV24.B11 ; UV18.AP30 194.64,83.34 v2(193.97,84.01)
FBA_D51: length 31.8
  IN1 w0.102: 203.91,109.69 v2(205.17,109.69)
  IN1 w0.117: v2(194.09,87.31) 194.49,87.71 194.49,91.8 198.29,95.6 198.72,95.6 200.4,97.29 200.4,101.34 201.81,102.75 201.81,105.25 202.12,105.56 202.12,107.95 203.87,109.69 203.91,109.69
  BOTTOM w0.102: v2(194.09,87.31) 193.93,87.15 193.93,85.09 194.62,84.4 UV18.AP32 ; v2(205.17,109.69) UV24.B13
FBA_D52: length 29.7
  IN1 w0.102: v2(205.93,106.49) 205.5,106.06 204.74,106.06 204.6,105.92
  IN1 w0.117: v2(196.63,84.81) 197.29,85.47 197.29,87.89 196.49,88.7 196.49,91.58 198.93,94.03 199.93,94.03 202.69,96.79 202.69,101.24 203.4,101.95 203.4,104.06 204.6,105.26 204.6,105.92
  BOTTOM w0.102: v2(196.63,84.81) 196.24,85.2 UV18.AM33 ; UV24.E11 206.79,107.68 206.3,107.19 206.22,107.19 205.93,106.9 v2(205.93,106.49)
FBA_D53: length 32.1
  IN1 w0.102: 203.91,101.72 203.91,103.82 205.57,105.48 205.57,105.83 205.85,106.11 206.15,106.11 206.31,106.27 206.31,106.65 205.96,107 205.45,107 205.33,106.87 205.01,106.87 204.79,107.09 204.79,107.71 v2(205.15,108.08)
  IN1 w0.117: 203.91,101.72 203.21,101.02 203.21,96.57 200.15,93.5 199.15,93.5 197.01,91.36 197.01,88.91 197.81,88.11 197.81,85.23 196.67,84.08 v2(196.67,83.97)
  BOTTOM w0.102: v2(205.15,108.08) UV24.E13 ; UV18.AL31 v2(196.67,83.97)
FBA_D54: length 26.9
  IN1 w0.102: v2(206.76,106.49) 206.76,106.22 206.33,105.8 206.33,105.52 206.11,105.3 205.83,105.3 204.34,103.81
  IN1 w0.117: 204.34,103.81 204.34,100.97 203.75,100.38 203.75,96.37 200.36,92.98 199.37,92.98 197.53,91.15 197.53,89.13 198.34,88.32 v2(198.34,85.6)
  BOTTOM w0.102: v2(206.76,106.49) 206.77,106.49 UV24.F11 ; v2(198.34,85.6) UV18.AK33
FBA_D55: length 31
  IN1 w0.102: 204.79,97.42 204.79,98.3 204.77,98.32 204.77,103.55 205.71,104.5 206.11,104.5 206.33,104.72 206.33,105.03 206.59,105.3 207.02,105.3 207.17,105.44 207.17,106.71 206.31,107.57 205.49,107.57 v2(205.17,107.25)
  IN1 w0.117: 204.79,97.42 204.79,96.67 200.58,92.46 199.58,92.46 198.06,90.93 198.06,89.35 198.95,88.46 198.95,85.41 v2(198.31,84.77)
  BOTTOM w0.102: v2(205.17,107.25) 205.54,106.88 UV24.F13 ; UV18.AK32 v2(198.31,84.77)
FBA_D56: length 36.6
  IN1 w0.098: v2(212.35,110.49) 212.55,110.49
  IN1 w0.102: 215.98,109.79 215.71,110.06 214.24,110.06 214.2,110.1 212.94,110.1 212.55,110.49 ; v2(204.48,87.06) 204.65,87.06 205.17,87.57 205.17,88.55 206.54,89.92
  IN1 w0.117: 206.54,89.92 212.73,96.11 214.79,96.11 216.78,98.1 216.78,101.86 217.59,102.66 217.59,108.19 215.98,109.79
  BOTTOM w0.102: UV24.A4 212.37,110.49 v2(212.35,110.49) ; v2(204.48,87.06) 204.28,87.06 203.22,86 UV18.AD34
FBA_D57: length 41.5
  IN1 w0.098: 215.76,110.89 215.35,110.48 v2(214.75,110.48)
  IN1 w0.102: v2(203.77,88.22) 203.77,88.2 203.46,87.89 203.46,87.44 204.22,86.68 204.64,86.68 205.49,87.53 205.49,88.58 206.57,89.66 207.02,89.66 207.28,89.92
  IN1 w0.117: 207.28,89.92 212.95,95.59 215.01,95.59 217.31,97.89 217.31,101.64 218.11,102.44 218.11,109.04 216.26,110.89 215.76,110.89
  BOTTOM w0.102: UV24.A2 v2(214.75,110.48) ; v2(203.77,88.22) 203.77,88.2 203.46,87.89 203.46,87.03 202.96,86.53 202.72,86.53 202.4,86.22 202.4,85.82 202.31,85.73 202.31,85.44 202.42,85.34 202.42,85.06 202.41,85.05 202.41,84.92 UV18.AD32
FBA_D58: length 45.7
  IN1 w0.102: 215.58,111.51 215.19,111.13 212.41,111.13 211.96,110.68 211.96,110.24 212.09,110.11 212.46,110.11 212.9,109.67 v2(213.17,109.67) ; 203.33,83.52 203.33,85.79 204.01,86.48 204.84,86.48 205.92,87.56 205.92,88.72 206.61,89.41 207.51,89.41 207.68,89.58
  IN1 w0.117: 215.58,111.51 215.63,111.57 216.32,111.57 218.63,109.26 218.63,102.22 217.83,101.42 217.83,97.67 215.23,95.06 213.16,95.06 207.68,89.58 ; 203.33,83.52 v2(203.33,83.19)
  BOTTOM w0.102: UV24.B4 213.17,109.67 v2(213.17,109.67) ; UV18.AC30 203.72,82.8 v2(203.33,83.19)
FBA_D59: length 34
  IN1 w0.102: v2(204.66,87.63) 204.66,88.78 205.8,89.92 ; 215.98,98.04 215.36,97.42 ; 215.98,109.05 215.77,109.26 215.17,109.26 v2(214.76,109.67)
  IN1 w0.117: 215.98,109.05 217.06,107.97 217.06,102.87 216.26,102.07 216.26,98.32 215.98,98.04 ; 215.36,97.42 214.58,96.63 212.51,96.63 205.8,89.92
  BOTTOM w0.102: UV18.AD33 202.61,85.53 202.61,86.14 202.8,86.33 203.17,86.33 204.37,87.53 204.56,87.53 v2(204.66,87.63) ; UV24.B2 214.35,110.07 v2(214.76,109.67)
FBA_D60: length 32.6
  IN1 w0.102: 208.86,97.42 209.96,98.52 209.96,106.26 210.97,107.27 212.35,107.27 v2(212.39,107.32) ; v2(199.84,87.26) 199.46,87.64 199.46,88.78
  IN1 w0.117: 199.46,88.78 199.46,89.64 203.02,93.2 204.64,93.2 205.27,93.83 208.2,96.76 208.2,96.76 208.86,97.42
  BOTTOM w0.102: UV18.AF31 200.91,83.93 200.43,83.93 200.05,84.31 200.05,86.19 200.28,86.42 200.28,86.82 v2(199.84,87.26) ; v2(212.39,107.32) UV24.E4
FBA_D61: length 29.9
  IN1 w0.102: v2(213.95,108.08) 213.53,107.66 213.53,107.12 213.31,106.9 213.03,106.9 212.77,106.64 212.77,106.32 212.51,106.06 211.91,106.06 210.69,104.84 210.69,97.77 210.34,97.42
  IN1 w0.117: v2(200.78,86.68) 200.78,87.64 200.51,87.91 200.51,89.21 203.45,92.15 205.08,92.15 210.34,97.42
  BOTTOM w0.102: UV18.AG34 200.78,86.34 v2(200.78,86.68) ; v2(213.95,108.08) UV24.E2
FBA_D62: length 29.5
  IN1 w0.102: v2(212.36,106.48) 211.95,106.48 210.38,104.9 210.38,98.2 209.6,97.42
  IN1 w0.117: v2(200.85,84.84) 200.81,84.84 200.28,85.37 200.28,87.63 199.98,87.93 199.98,89.42 203.24,92.68 204.86,92.68 209.6,97.42
  BOTTOM w0.102: v2(200.85,84.84) 200.85,84.81 UV18.AG32 ; UV24.F4 v2(212.36,106.48)
FBA_D63: length 29.6
  IN1 w0.102: 201.03,88.35 201.03,88.02 201.36,87.69 201.36,85.98 200.95,85.57 200.89,85.57 ; v2(214.76,106.55) 214.69,106.55 214.2,106.06 213.8,106.06 213.57,105.83 213.57,105.43 213.4,105.26 213,105.26 212.77,105.03 212.77,104.23 211,102.46 211,97.42
  IN1 w0.117: 211,97.42 211,97.34 205.29,91.63 203.67,91.63 201.03,88.99 201.03,88.35 ; v2(200.81,85.57) 200.89,85.57
  BOTTOM w0.102: UV24.F2 214.43,106.88 v2(214.76,106.55) ; v2(200.81,85.57) UV18.AG33
FBA_DBI0#: length 26.8
  IN6 w0.102: v2(211.66,83.2) 212.13,83.67 212.13,84.16 212.2,84.23 212.2,84.98 212.61,85.39 212.61,87.43 212.82,87.64
  IN6 w0.117: v2(228.01,100.08) 227.51,99.57 224.05,99.57 212.82,88.34 212.82,87.64
  BOTTOM w0.102: UV23.D2 v2(228.01,100.08) ; v2(211.66,83.2) 211.26,82.8 UV18.P30
FBA_DBI1#: length 32.2
  IN6 w0.102: v2(217.51,84) 217.51,84 218.09,84.58 218.5,84.58 219.6,85.68 219.95,85.68 219.98,85.72 ; 238.84,99.36 238.51,99.7 237.36,99.7 236.98,100.08 v2(236.81,100.08)
  IN6 w0.117: 219.98,85.72 220.5,86.23 220.7,86.23 221.03,86.56 221.89,86.56 222.83,87.5 226.87,87.5 234.52,95.15 236.44,95.15 238.84,97.55 238.84,99.36
  BOTTOM w0.102: UV18.F31 217.91,83.6 v2(217.51,84)
  BOTTOM w0.107: UV23.D13 v2(236.81,100.08)
FBA_DBI2#: length 36.9
  IN1 w0.098: v2(219.76,86.74) 219.81,86.79 222.04,86.79
  IN1 w0.102: v2(237.61,108.08) 238.69,107 238.71,107 238.84,106.87 ; 225.43,88.55 223.8,88.55 222.04,86.79
  IN1 w0.117: 225.43,88.55 226.79,88.55 235.05,96.81 236.74,96.81 239,99.07 239,106.69 238.95,106.74 238.95,106.76 238.84,106.87
  BOTTOM w0.102: UV18.F34 218.27,86 218.35,86.07 218.35,86.07 218.6,86.33 218.87,86.33 219.07,86.14 219.28,86.14 219.71,86.57 219.71,86.69 v2(219.76,86.74)
  BOTTOM w0.107: UV23.P13 v2(237.61,108.08)
FBA_DBI3#: length 34.5
  IN1 w0.098: 214.49,89.54 213.78,88.82
  IN1 w0.102: v2(227.97,108.9) 227.94,108.88 226.77,108.88 ; v2(212.58,84.82) 211.84,85.56 211.84,86.08 211.6,86.32 211.6,87.17 213.25,88.82 213.78,88.82
  IN1 w0.117: 214.49,89.54 215.17,90.22 216.61,90.22 224.98,98.59 224.98,107.42 226.44,108.88 226.77,108.88
  BOTTOM w0.102: UV18.M32 212.6,84.74 212.6,84.8 v2(212.58,84.82) ; v2(227.97,108.9) 228.39,108.48 UV23.P2
FBA_DBI4#: length 25.1
  IN6 w0.102: v2(202.45,83.18) 202.45,83.35 203.3,84.21 203.3,85.06 203.67,85.43 203.67,85.51 204.4,86.23 204.57,86.23 205.75,87.41 205.75,89.29 ; v2(213.95,100.08) 214.36,99.67 214.9,99.67 215.13,99.43 215.13,97.42
  IN6 w0.117: 205.75,89.29 205.75,89.4 212.45,96.11 213.87,96.11 215.13,97.38 215.13,97.42
  BOTTOM w0.102: v2(202.45,83.18) 202.5,83.18 202.92,83.6 UV18.AD31 ; UV24.P2 v2(213.95,100.08)
FBA_DBI5#: length 24.6
  IN6 w0.102: 204.24,97.78 204.77,98.31 204.77,99.16 205.57,99.96 205.57,100.23 205.95,100.62 v2(205.95,100.88) ; 197.53,89.2 197.53,83.87 197.06,83.39 197.06,81.89 v2(196.64,81.47)
  IN6 w0.117: 204.24,97.78 203.91,97.78 197.53,91.4 197.53,89.2
  BOTTOM w0.102: UV18.AL29 197.04,81.87 v2(196.64,81.47) ; UV24.P13 v2(205.95,100.88)
FBA_DBI6#: length 31.9
  IN1 w0.102: v2(205.95,108.88) 205.53,108.46 204.7,108.46 204.13,107.89 204.09,107.89 203.91,107.71
  IN1 w0.117: v2(195.84,84.01) 196.21,84.39 196.21,85.74 196.77,86.29 196.77,87.67 195.96,88.48 195.96,91.8 198.72,94.55 199.71,94.55 201.47,96.31 201.47,100.91 202.86,102.29 202.86,104.81 203.17,105.13 203.17,106.96 203.91,107.71
  BOTTOM w0.102: v2(195.84,84.01) 196.22,84.4 UV18.AM32
  BOTTOM w0.107: UV24.D13 v2(205.95,108.88)
FBA_DBI7#: length 32.9
  IN1 w0.098: 203.33,89.29 202.21,88.17
  IN1 w0.102: v2(214.75,108.88) 215.01,108.88 215.4,108.49 215.8,108.49 215.98,108.31 ; 215.98,104.47 215.77,104.27 215.77,98.57 214.62,97.42 ; 202.21,88.17 v2(201.42,88.17)
  IN1 w0.117: 214.62,97.42 214.36,97.16 212.3,97.16 205.12,89.98 204.02,89.98 203.33,89.29 ; 215.98,104.47 216.16,104.65 216.16,108.13 215.98,108.31
  BOTTOM w0.102: v2(201.42,88.17) 201.42,88.12 201.42,87.14 201.24,86.96 UV18.AF34
  BOTTOM w0.107: UV24.D2 v2(214.75,108.88)
FBA_EDC0: length 26.5
  IN6 w0.102: v2(212.51,84) 212.96,84.45 212.96,85.43 212.85,85.54 212.85,87.06 212.91,87.11 ; v2(228.81,100.08) 228.41,99.67 228.41,99.12 228.18,98.89 227.85,98.89
  IN6 w0.117: 212.91,87.11 213.34,87.55 213.34,88.12 224.11,98.89 227.85,98.89
  BOTTOM w0.102: v2(212.51,84) 212.91,83.6 UV18.M31 ; UV23.C2 v2(228.81,100.08)
FBA_EDC1: length 37.1
  IN6 w0.102: v2(236.81,99.28) 236.93,99.28 237.68,98.52 237.68,97.42 ; 219.97,86.24 219.87,86.24 218.41,84.79 217.76,84.79 217.13,84.16 217.13,83.04 217.22,82.96 217.22,81.79 217.04,81.62 217.04,81.37 216.82,81.14 215.53,81.14 215.38,81.29 215.38,81.73 215.82,82.16 v2(215.82,82.36)
  IN6 w0.117: 237.68,97.42 237.68,97.2 236.16,95.68 234.3,95.68 226.76,88.14 222.63,88.14 221.58,87.08 220.81,87.08 219.97,86.24
  BOTTOM w0.102: v2(215.82,82.36) 215.82,82.85 216.1,83.13 216.62,83.13 217.06,83.57 UV18.G31
  BOTTOM w0.107: UV23.C13 v2(236.81,99.28)
FBA_EDC2: length 40.1
  IN1 w0.102: v2(236.84,108.9) 237.29,108.46 238.52,108.46 238.84,108.13 ; 225.43,87.96 223.5,87.96 222.09,86.55 220.46,86.55 219.52,85.61 v2(218.33,85.61) ; 238.83,97.42 238.84,97.42
  IN1 w0.117: 238.83,97.42 237.7,96.29 235.27,96.29 226.94,87.96 225.43,87.96 ; 238.84,97.42 239.52,98.11 239.52,107.45 238.84,108.13
  BOTTOM w0.102: v2(218.33,85.61) UV18.E33 ; v2(236.84,108.9) UV23.R13
FBA_EDC3: length 34.4
  IN1 w0.102: 212.9,88.01 212.03,87.14 v2(212.03,87.06) ; 226.79,108.1 227.7,108.1 228.35,108.75 228.35,109.12 v2(228.81,109.58)
  IN1 w0.117: 212.9,88.01 213.22,88.33 214.02,88.33 215.39,89.7 216.83,89.7 225.5,98.37 225.5,107.2 226.4,108.1 226.79,108.1
  BOTTOM w0.102: v2(228.81,109.58) 228.5,109.28 UV23.R2 ; v2(212.03,87.06) 212.47,86.62 212.47,85.54 212.81,85.2 UV18.M33
FBA_EDC4: length 22.8
  IN6 w0.102: 205.22,89.29 205.22,87.18 204.6,86.55 203.79,86.55 203.47,86.23 203.47,85.51 202.51,84.56 v2(202.51,83.95) ; 214.33,97.42 214.33,98.9 v2(213.95,99.28)
  IN6 w0.117: 214.33,97.42 214.33,97.32 213.65,96.63 212.23,96.63 205.22,89.62 205.22,89.29
  BOTTOM w0.102: v2(202.51,83.95) 202.15,83.6 UV18.AE31 ; UV24.R2 v2(213.95,99.28)
FBA_EDC5: length 21.7
  IN6 w0.102: 197.92,83.72 v2(197.48,83.28) ; v2(205.95,100.08) 205.95,99.82 205.53,99.4 205.53,98.32 205.15,97.94
  IN6 w0.117: 205.15,97.94 204.81,97.94 198.06,91.18 198.06,85.87 197.92,85.73 197.92,83.72
  BOTTOM w0.102: UV24.R13 v2(205.95,100.08) ; v2(197.48,83.28) 197.84,82.93 UV18.AK30
FBA_EDC6: length 31.8
  IN1 w0.102: 203.91,108.59 204.32,108.59 204.99,109.26 205.33,109.26 205.35,109.28 205.55,109.28 v2(205.95,109.68)
  IN1 w0.117: v2(195,85.57) 196.24,86.81 196.24,87.31 195.44,88.12 195.44,92.01 198.5,95.07 199.5,95.07 200.94,96.51 200.94,101.11 202.33,102.51 202.33,105.03 202.65,105.34 202.65,107.73 203.5,108.59 203.91,108.59
  BOTTOM w0.107: UV18.AN33 195.07,85.57 v2(195,85.57) ; UV24.C13 v2(205.95,109.68)
FBA_EDC7: length 34.2
  IN1 w0.117: v2(213.95,108.88) 214.34,108.49 214.59,108.49 214.59,108.49 214.89,108.49 215.21,108.17 215.21,107.69 215.43,107.47 215.43,105.28 215.19,105.04 215.19,104.12 215.43,103.87 215.43,98.53 214.97,98.06 212.47,98.06 204.9,90.5 203.74,90.5 201.99,88.75 v2(201.44,88.75)
  BOTTOM w0.102: v2(201.44,88.75) 201.44,88.73 201.85,88.32 201.85,87.11 201.44,86.7 201.44,86.32 201.58,86.18 201.58,85.53 201.25,85.2 UV18.AF33
  BOTTOM w0.107: UV24.C2 v2(213.95,108.88)
FBA_MA0_MA10_H: length 30.9
  TOP w0.102: 204.22,88.9 204.22,88.61 205.04,87.79 205.04,86.61 206.22,85.43 206.22,83.61 206.02,83.41 206.02,82.57 v2(205.84,82.39)
  TOP w0.221: 204.22,88.9 204.22,93.58 209.7,99.06 209.7,103.82 v1(210.08,104.2) 210.53,104.65 210.91,104.65 211.27,104.3 v2(211.27,103.43)
  BOTTOM w0.102: v2(205.84,82.39) 206.21,82.39 206.31,82.49 206.31,82.72 UV18.Y30 ; UV24.K4 212.75,103.98 212.65,104.08 211.39,104.08 211.27,103.95 v2(211.27,103.43)
FBA_MA0_MA10_L: length 42.8
  TOP w0.102: v2(207.56,83.19) 207.56,83.49 207.92,83.85 207.92,87.04 207.89,87.07 207.89,87.75 210.09,89.95 210.09,90.04 ; 226.77,105.04 227.19,105.46 228.25,105.46 228.46,105.26 229.77,105.26 229.99,105.03 229.99,104.5 v2(229.58,104.09)
  TOP w0.221: 210.09,90.04 210.09,90.43 212.5,92.84 214.76,92.84 215.09,93.17 215.09,93.86 215.41,94.18 220.36,94.18 220.91,94.73 220.91,95.37 220.29,95.99 220.29,96.48 219.87,96.9 219.87,98.97 222.41,101.52 222.41,101.83 222.01,102.24 222.01,102.55 222.32,102.86 222.64,102.86 223.04,102.46 223.35,102.46 225.87,104.98 226.71,104.98 226.77,105.04
  BOTTOM w0.102: UV23.H4 229.64,104.05 229.63,104.05 v2(229.58,104.09) ; v2(207.56,83.19) 207.94,82.81 UV18.V30
FBA_MA1_MA9_H: length 24.7
  TOP w0.102: v2(205.64,86.55) 205.25,86.94 205.25,88.23 204.95,88.53 204.95,88.82
  TOP w0.221: 204.95,88.82 204.95,93.22 205.1,93.37 206.02,94.29 206.69,94.29 207,94.6 207,95.27 210.44,98.71 v1(210.44,100.14) 210.44,100.51 211.18,101.25 211.18,101.5 210.97,101.7 210.55,101.7 210.36,101.89 210.36,102.76 210.6,103 211.15,103 211.38,102.76 v2(211.38,102.25)
  BOTTOM w0.102: v2(211.38,102.25) 211.07,102.55 211.07,102.94 211.17,103.04 211.58,103.04 211.95,103.42 UV24.K5
  BOTTOM w0.127: UV18.AA34 205.49,86 205.71,86.21 205.71,86.45 205.64,86.51 v2(205.64,86.55)
FBA_MA1_MA9_L: length 38.3
  BOTTOM w0.102: UV23.H5 231.22,103.27 ; UV18.U34 210.09,87.35 210.09,88.55 210.35,88.81 210.35,89.67
  BOTTOM w0.221: 231.22,103.27 231.33,103.16 231.33,96.84 230.07,95.58 226.2,95.58 225.65,95.03 225.34,95.03 224.95,95.42 224.64,95.42 224.32,95.11 224.32,94.8 224.71,94.41 224.71,94.1 224.4,93.78 224.09,93.78 223.7,94.17 223.39,94.17 223.07,93.86 223.07,93.55 223.46,93.16 223.46,92.85 222.62,92.01 v1(218.21,92.01) 212.59,92.01 210.35,89.77 210.35,89.67
FBA_MA2_BA0_H: length 31.7
  TOP w0.102: 202.03,89.74 202.03,89.59 202.44,89.19 202.44,87.76 203.58,86.62 203.58,85.19 205.41,83.36 205.41,83.01 205.19,82.79 204.83,82.79 204.6,82.55 204.6,82.21 205.02,81.79 v2(205.02,81.54) ; v2(207.55,103.28) 207.09,102.81 206.6,102.81 206.36,102.57 206.36,102.35 206.1,102.09 204.9,102.09
  TOP w0.221: 202.03,89.74 202.03,90.43 201.81,90.65 201.15,90.65 200.93,90.88 200.93,91.32 201.15,91.54 201.81,91.54 202.03,91.76 v1(202.03,95.33) 202.03,97.62 202.6,98.18 202.6,98.64 202.33,98.91 201.92,98.91 201.7,99.13 201.7,99.57 201.92,99.79 202.33,99.79 202.55,100.01 202.55,100.47 204.17,102.09 204.9,102.09
  BOTTOM w0.102: UV18.AA28 205.02,81.52 v2(205.02,81.54) ; UV24.K11 v2(207.55,103.28)
FBA_MA2_BA0_L: length 44.8
  TOP w0.102: v2(209.74,81.69) 209.91,81.69 210.18,81.97 210.92,81.97 211.28,82.33 211.28,82.53 211.57,82.82 212.68,82.82 212.97,83.11 212.97,84.93 213.29,85.25 213.58,85.25 214.15,85.82 214.99,85.82 ; v2(236.01,104.08) 236.41,103.68 236.41,101.54 236.39,101.52 236.39,101.52 236.17,101.3 236.17,101.3 236.13,101.26 235.06,101.26 234.71,100.91 234.71,100.61
  TOP w0.221: 214.99,85.82 v1(215.61,85.82) 216,85.82 216.47,85.34 216.86,85.34 217.29,84.91 218.49,84.91 218.98,84.43 220.61,84.43 220.68,84.36 221.42,84.36 221.45,84.33 221.83,84.33 221.85,84.35 222.57,84.35 222.59,84.33 223.31,84.33 234.75,95.77 234.75,100.57 234.71,100.61
  BOTTOM w0.102: UV18.U29 209.48,81.95 v2(209.74,81.69)
  BOTTOM w0.107: UV23.H11 v2(236.01,104.08)
